# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_N0: length 161
  TOP w0.112: CT56.2 40.61,114.25 40.61,114.4 v1(40.42,114.58)
  IN1 w0.119: v1(56.1,127.44) 56.29,127.26 57.43,127.26 60.1,124.58 61.86,124.58 64.86,121.58 65.54,121.58 68.29,118.83 69.79,118.83 70.24,119.29 72.35,119.29 72.73,118.91 73.97,118.91 74.99,119.92 75.73,119.92 76.66,118.99 79.19,118.99 80.42,117.76 81.53,117.76 82.33,116.96 83.13,116.96 84.25,115.85 85.56,115.85 86.31,115.1 94.6,115.1 95.09,115.59 110.2,115.59 110.68,115.12 122.08,115.12 125.55,111.65 125.55,111.65 125.55,111.12 132.5,104.18 138.79,104.18 143.42,99.55 143.42,96.73 143.33,96.64 143.33,94.18 143.83,93.68 144.49,93.68 146.35,91.82 146.35,88.27 147.13,87.49 147.13,85.23 147.25,85.11 147.4,85.11 v1(147.56,85.27)
  BOTTOM w0.076: UC1.C50 135.19,78.24 135.19,78.13 135.32,78 135.47,78.07 135.71,78.07 135.82,78.03 136,78.03 136.09,78.06 136.38,78.06 136.4,78.04 136.43,78.03 136.45,78.02 137.26,78.02 138.11,77.17 138.17,77.17
  BOTTOM w0.112: 138.17,77.17 139.93,77.17 140.08,77.32 140.08,78.37 143.46,81.75 143.73,81.75 147.01,85.04 147.33,85.04 v1(147.56,85.27) ; v1(56.1,127.44) 55.92,127.26 52.88,127.26 52.35,126.73 50.47,126.73 47.92,124.18 44.68,124.18 44.04,123.54 44.04,118.31 42.95,117.22 42.39,117.22 40.6,115.43 40.6,114.76 v1(40.42,114.58) 40.6,114.41 40.6,113.91 RT105.1
CPU_DP2_N0_C: length 3.2
  TOP w0.112: UT5.7 40.34,110.53 40.52,110.71 40.52,111.19 40.66,111.33 40.66,111.63 40.64,111.64 40.64,112.19 40.65,112.19 40.65,112.65 CT56.1
CPU_DP2_N1: length 163.2
  TOP w0.112: v1(38.64,114.58) 38.81,114.41 38.81,114.25 CT58.2
  IN1 w0.119: v1(147.55,86.43) 147.73,86.62 148.07,86.62 148.62,87.17 148.62,87.8 147.06,89.36 147.06,92.19 145.79,93.47 145.79,99.14 139.85,105.08 132.58,105.08 126.86,110.8 126.86,112.94 126.21,113.59 125.63,113.59 123.34,115.87 111.25,115.87 110.88,116.24 94.83,116.24 94.38,115.78 86.53,115.78 85.82,116.49 84.52,116.49 83.4,117.61 82.69,117.61 81.75,118.55 80.54,118.55 79.46,119.63 76.92,119.63 75.58,120.98 71.43,120.98 71.08,120.62 67.47,120.62 64.92,123.17 64.4,123.17 62.31,125.26 60.34,125.26 56.9,128.7 54.53,128.7 54.32,128.49 51.94,128.49 v1(51.75,128.67)
  BOTTOM w0.076: UC1.C52 135.25,79.58 135.32,79.65 135.63,79.65 135.74,79.67 135.82,79.69 135.95,79.69 136.19,79.6 136.27,79.6 136.32,79.63 136.36,79.64 136.4,79.68 136.7,79.68 136.7,79.67 136.74,79.67 136.77,79.71 137.55,79.71 137.63,79.79 139.15,79.79 139.16,79.77 139.18,79.77
  BOTTOM w0.112: v1(147.55,86.43) 146.94,86.43 146.62,86.12 146.62,85.31 144,82.68 143.66,82.68 142.5,81.52 142.37,81.39 140.75,79.77 139.18,79.77 ; v1(51.75,128.67) 51.57,128.49 49.84,128.49 47.19,125.83 44.85,125.83 43.22,124.2 42.62,124.2 41.82,123.4 41.82,119.89 41.27,119.33 41.27,117.08 39.75,115.57 39.18,115.57 38.81,115.2 38.81,114.76 v1(38.64,114.58) 38.81,114.42 38.81,113.9 RT107.1
CPU_DP2_N1_C: length 3.2
  TOP w0.112: CT58.1 38.8,112.65 38.8,111.41 38.81,111.4 38.81,111.28 39.21,110.88 39.21,110.74 39.14,110.66 UT5.10
CPU_DP2_N2: length 139.8
  TOP w0.112: v1(36.85,114.58) 37.04,114.4 37.04,114.24 CT60.2
  IN1 w0.119: v1(36.85,114.58) 37.01,114.75 37.01,115.43 37.47,115.89 39.65,115.89 41.63,117.86 49.4,117.86 49.79,117.48 58,117.48 58.61,116.87 60.8,116.87 61.06,116.61 64,116.61 65.11,115.51 66.27,115.51 67.25,116.49 71.63,116.49 72.39,115.73 73.99,115.73 74.75,116.49 77.31,116.49 79.5,114.3 82.39,114.3 83.25,113.44 84.56,113.44 85.89,112.11 95.32,112.11 95.74,112.53 108.64,112.53 108.8,112.38 116.2,112.38 116.47,112.11 119.17,112.11 121.17,110.12 123.08,110.12 130.03,103.16 130.03,101.71 131.63,100.11 131.63,98.38 136.14,93.88 137.1,93.88 139.97,91.01 139.97,89.73 140.89,88.81 140.89,78.22 140.52,77.85 139.92,77.85 v1(139.65,77.58)
  BOTTOM w0.112: RT109.1 37.04,113.96 37.04,114.4 v1(36.85,114.58) ; v1(139.65,77.58) 139.64,77.59 138.36,77.59 138.08,77.86 138.08,77.89 137.58,78.39 136.64,78.39 UC1.A50
CPU_DP2_N2_C: length 3.4
  TOP w0.112: CT60.1 37.11,112.55 37.11,111.6 37.94,110.78 UT5.13
CPU_DP2_N3: length 139.2
  TOP w0.112: v1(35.07,114.58) 35.31,114.35 35.31,114.14 35.06,113.89 CT62.2
  IN1 w0.119: v1(35.07,114.58) 35.07,114.58 35.48,114.18 35.48,113.84 35.89,113.42 44.28,113.42 45.63,114.77 51.78,114.77 53.63,116.62 57.64,116.62 58.25,116.01 60.44,116.01 60.7,115.75 63.65,115.75 64.75,114.65 66.63,114.65 67.61,115.63 71.03,115.63 71.79,114.87 75.16,114.87 75.92,115.63 76.94,115.63 79.13,113.44 80.21,113.44 81.49,112.16 82.92,112.16 83.54,111.54 84.09,111.54 84.39,111.25 95.67,111.25 96.1,111.67 108.29,111.67 108.44,111.52 115.84,111.52 116.19,111.17 118.36,111.17 121.07,108.46 122.41,108.46 125.2,105.67 126.09,105.67 129.08,102.69 129.08,100.73 130.51,99.29 130.51,98.18 132.55,96.13 136.61,92.08 137.44,91.25 137.44,90.5 138.74,89.21 138.74,88.47 139.03,88.18 139.03,88.16 139.94,87.25 139.94,79.31 139.62,78.99 139.26,78.99 139.05,79.21 v1(139.05,79.35)
  BOTTOM w0.076: 138.81,79.04 135.89,79.04 135.88,79.04 135.81,79.04 135.71,79.14 135.2,79.14 UC1.D51
  BOTTOM w0.112: RT111.1 35.26,113.9 35.26,114.4 v1(35.07,114.58) ; v1(139.05,79.35) 139.05,79.28 138.81,79.04
CPU_DP2_N3_C: length 3.9
  TOP w0.112: UT5.16 36.74,110.58 36.83,110.67 36.83,110.79 36.48,111.14 36.1,111.14 35.49,111.75 35.49,111.77 35.25,112.01 35.25,112.62 CT62.1
CPU_DP2_P0: length 161.2
  TOP w0.112: v1(41.01,114.58) 40.83,114.4 40.83,114.27 CT55.2
  IN1 w0.119: v1(147.56,84.68) 147.56,84.7 147.36,84.89 147.16,84.89 146.91,85.14 146.91,87.4 146.13,88.18 146.13,91.72 144.4,93.46 143.74,93.46 143.11,94.09 143.11,96.74 143.2,96.82 143.2,99.46 138.7,103.96 132.41,103.96 125.34,111.03 125.34,111.56 121.99,114.9 110.59,114.9 110.11,115.37 95.19,115.37 94.69,114.88 86.22,114.88 85.47,115.63 84.16,115.63 83.04,116.75 82.24,116.75 81.44,117.54 80.33,117.54 79.1,118.77 76.57,118.77 75.64,119.7 75.08,119.7 74.07,118.69 72.64,118.69 72.26,119.07 70.33,119.07 69.88,118.61 68.19,118.61 65.45,121.36 64.77,121.36 61.77,124.36 60.01,124.36 57.34,127.04 56.29,127.04 v1(56.1,126.86)
  BOTTOM w0.076: 138.17,76.95 138.15,76.95 138.13,76.97 138.05,76.97 137.18,77.84 136.42,77.84 136.37,77.85 136.35,77.89 136.34,77.89 136.32,77.89 136.31,77.9 136.12,77.9 136.03,77.86 135.79,77.86 135.68,77.9 135.51,77.9 135.36,77.84 135.06,77.84 134.6,78.3 UC1.D50
  BOTTOM w0.112: RT104.1 40.82,113.95 40.82,114.4 v1(41.01,114.58) 40.82,114.77 40.82,115.34 42.48,117 43.04,117 44.26,118.22 44.26,123.45 44.78,123.96 48.01,123.96 50.56,126.51 52.44,126.51 52.97,127.04 55.92,127.04 v1(56.1,126.86) ; v1(147.56,84.68) 147.56,84.7 147.44,84.82 147.44,84.82 147.1,84.82 143.82,81.53 143.55,81.53 140.3,78.28 140.3,77.23 140.03,76.95 138.17,76.95
CPU_DP2_P0_C: length 3.1
  TOP w0.112: UT5.6 40.74,111.1 40.88,111.23 v4(40.88,111.95) 40.88,112.72 CT55.1
CPU_DP2_P1: length 163
  TOP w0.112: CT57.2 39.04,114.23 39.04,114.4 v1(39.22,114.58)
  IN1 w0.119: v1(51.75,128.08) 51.94,128.27 54.41,128.27 54.62,128.48 56.81,128.48 60.25,125.04 62.22,125.04 64.31,122.95 64.83,122.95 67.37,120.4 71.17,120.4 71.52,120.76 75.49,120.76 76.83,119.42 79.37,119.42 80.45,118.33 81.66,118.33 82.6,117.39 83.31,117.39 84.43,116.27 85.73,116.27 86.44,115.57 94.47,115.57 94.92,116.02 110.79,116.02 111.15,115.65 123.25,115.65 125.54,113.37 126.12,113.37 126.64,112.85 126.64,110.71 132.49,104.86 139.76,104.86 145.57,99.05 145.57,93.37 146.85,92.1 146.85,89.27 148.41,87.71 148.41,87.26 147.98,86.83 147.73,86.83 v1(147.55,87.02)
  BOTTOM w0.076: UC1.D52 134.59,79.63 134.78,79.82 135.62,79.82 135.71,79.83 135.79,79.85 136.03,79.85 136.21,79.78 136.27,79.78 136.27,79.79 136.33,79.84 136.67,79.84 136.7,79.87 137.48,79.87 137.58,79.97 139.15,79.97 139.16,79.99 139.18,79.99
  BOTTOM w0.112: 139.18,79.99 140.66,79.99 142.28,81.61 142.34,81.67 143.57,82.9 143.9,82.9 146.4,85.4 146.4,86.21 146.85,86.65 147.19,86.65 147.55,87.02 v1(147.55,87.02) ; RT106.1 39.03,113.96 39.03,114.39 v1(39.22,114.58) 39.04,114.77 39.04,115.11 39.27,115.34 39.84,115.34 41.49,116.99 41.49,119.24 42.04,119.8 42.04,123.31 42.71,123.98 43.32,123.98 44.95,125.61 47.28,125.61 49.93,128.27 51.57,128.27 v1(51.75,128.08)
CPU_DP2_P1_C: length 3.2
  TOP w0.112: CT57.1 39.04,112.66 v4(39.04,111.97) 39.04,111.37 39.43,110.97 39.43,110.78 39.54,110.68 UT5.9
CPU_DP2_P2: length 139.7
  TOP w0.112: v1(37.43,114.58) 37.26,114.41 37.26,114.22 CT59.2
  IN1 w0.119: v1(139.65,78.34) 139.92,78.07 140.43,78.07 140.67,78.31 140.67,88.72 139.75,89.64 139.75,90.92 137.01,93.66 136.05,93.66 131.42,98.29 131.42,100.02 129.82,101.62 129.82,103.07 122.98,109.9 121.08,109.9 119.08,111.9 116.38,111.9 116.11,112.16 108.71,112.16 108.55,112.31 95.83,112.31 95.41,111.89 85.8,111.89 84.47,113.22 83.16,113.22 82.3,114.09 79.4,114.09 77.22,116.27 74.84,116.27 74.08,115.52 72.3,115.52 71.54,116.27 67.34,116.27 66.36,115.29 65.02,115.29 63.91,116.39 60.97,116.39 60.71,116.65 58.52,116.65 57.91,117.26 49.7,117.26 49.31,117.65 41.72,117.65 39.74,115.67 37.56,115.67 37.23,115.34 37.23,114.78 v1(37.43,114.58)
  BOTTOM w0.112: RT108.1 37.26,113.9 37.26,114.41 v1(37.43,114.58) ; v1(139.65,78.34) 139.65,78.16 139.29,77.81 138.45,77.81 137.64,78.62 136.22,78.62 136.15,78.55 UC1.B50
CPU_DP2_P2_C: length 3.4
  TOP w0.112: CT59.1 37.34,112.76 v4(37.34,112) 37.34,111.68 38.16,110.87 38.16,110.65 38.34,110.47 UT5.12
CPU_DP2_P3: length 139.3
  TOP w0.112: CT61.2 35.53,114.14 35.53,114.46 v1(35.66,114.58)
  IN1 w0.119: v1(35.66,114.58) 35.7,114.55 35.7,113.93 35.98,113.64 44.19,113.64 45.54,114.99 51.69,114.99 53.53,116.83 57.74,116.83 58.34,116.23 60.53,116.23 60.79,115.97 63.74,115.97 64.84,114.87 66.53,114.87 67.52,115.85 71.12,115.85 71.88,115.09 75.07,115.09 75.83,115.85 77.03,115.85 79.22,113.66 80.3,113.66 81.58,112.38 83.01,112.38 83.63,111.76 84.18,111.76 84.48,111.47 95.58,111.47 96,111.89 108.38,111.89 108.53,111.74 115.94,111.74 116.28,111.39 118.45,111.39 121.16,108.68 122.5,108.68 125.29,105.89 126.18,105.89 129.29,102.78 129.29,100.82 130.73,99.38 130.73,98.27 136.77,92.23 136.77,92.22 137.65,91.33 137.65,90.59 138.95,89.29 138.95,88.55 140.16,87.34 140.16,79.22 139.7,78.77 139.18,78.77 v1(139.05,78.64)
  BOTTOM w0.076: UC1.C51 135.5,78.93 135.28,78.93 135.2,78.85 135.2,78.7 135.35,78.56 135.74,78.56 136.06,78.87 138.73,78.87 138.76,78.84
  BOTTOM w0.112: RT110.1 35.48,113.96 35.48,114.41 v1(35.66,114.58) ; v1(139.05,78.64) 138.85,78.84 138.76,78.84
CPU_DP2_P3_C: length 3.9
  TOP w0.112: UT5.15 37.14,110.62 37.05,110.71 37.05,110.88 36.57,111.36 36.21,111.36 v4(35.93,111.65) 35.47,112.1 35.47,112.66 CT61.1
CPU_DP3_AUXN: length 1.3
  TOP w0.089: v1(132.85,76.89) 132.58,76.63 TP1.1
  BOTTOM w0.076: UC1.G46 132.87,76.77 132.87,76.88 v1(132.85,76.89)
CPU_DP3_AUXP: length 3.6
  TOP w0.089: TP2.1 134.5,78.79 134.5,77.47 134.29,77.25 133.93,77.25 v1(133.56,76.88)
  BOTTOM w0.076: v1(133.56,76.88) 133.17,76.5 UC1.F46
CPU_POPIRCOMP: length 12.5
  TOP w0.305: RC119.1 107.7,57.73 108.12,58.14 109.45,58.14 110.24,58.94 v2(113.37,58.94) 116.83,58.94 117.38,59.49 v1(117.38,59.5)
  BOTTOM w0.254: v1(117.38,59.5) 117.38,59.36 UC1.AT16
CPU_XDP_TCK0: length 27.1
  TOP w0.089: v1(137.23,84.34) 137.58,84.7 v1(137.58,85)
  TOP w0.102: v1(137.58,85) 137.66,85.07 137.66,90.43 136.09,92
  TOP w0.112: 136.09,92 135.69,92.4 132.8,92.4 132.03,93.16 130.61,93.16 130.32,92.87 TPC2.1 127.39,92.87 125.1,95.17 RC146.1
  BOTTOM w0.076: v1(137.23,84.34) 136.99,84.34 136.71,84.62 136.71,84.62 136.7,84.63 136.15,84.63 UC1.B61 ; v1(137.58,85) 137.93,84.66 138.27,84.66 138.43,84.5
  BOTTOM w0.089: 138.1,83.16 136.64,83.16 UC1.A59
  BOTTOM w0.102: 138.1,83.16 138.2,83.16 138.46,83.42 138.46,84.46 138.43,84.5
CPVEE: length 3.4
  TOP w0.203: CA25.2 21.14,11.31 21.69,11.86 22.98,11.86 22.99,11.85 UA1.34
CS_1.2V: length 4.2
  TOP w0.089: v2(38.82,24.16) 38.31,24.16 PRM03.1
  TOP w0.203: PUM01.13 36.85,26.39 37.75,25.48 PRM03.1
CSCOMP_2PH_CPU: length 75.1
  TOP w0.089: v1(152.72,87.21) v2(151.88,87.21)
  IN1 w0.254: v1(177.43,48.05) 177.43,48.67 177.77,49 182.4,49 183.76,50.36 183.76,52.83 181.26,55.34 181.26,58.02 179.88,59.39 179.88,60.24 179.38,60.75 179.38,62.88 178.68,63.57 176.85,63.57 175.74,64.68 175.74,65.57 174.65,66.65 174.65,66.98 172.76,68.87 172.76,69.99 172.38,70.37 172.38,71.48 165.98,77.88 160.01,77.88 158.12,79.77 153.27,79.77 150.79,82.25 150.79,86.82 151.44,87.47 152.47,87.47 v1(152.72,87.21)
  BOTTOM w0.203: PUZ01.6 175.63,52.33 175.45,52.16 175.45,51.54 175.8,51.19 175.8,50.95 PCZ17.1 PCZ18.1 176.3,49.56 PRZ28.1 177.43,49.29 PRZ27.2
  BOTTOM w0.254: v1(177.43,48.05) PRZ27.2 ; v1(152.72,87.21) PHZ02.2
CSCOMP_2PH_CPU_R: length 71.2
  TOP w0.089: v1(152.72,88.13) v2(153.44,88.13)
  IN1 w0.254: v1(152.72,88.13) 152.41,87.82 151.29,87.82 150.43,86.97 150.43,82.07 153.11,79.39 157.99,79.39 159.86,77.52 165.83,77.52 172.03,71.32 172.03,70.22 172.4,69.85 172.4,68.74 174.3,66.83 174.3,66.51 175.39,65.42 175.39,64.54 176.71,63.22 178.52,63.22 179.03,62.71 179.03,60.57 179.54,60.07 179.54,59.24 180.9,57.87 180.9,55.16 183.41,52.65 183.41,50.54 182.22,49.36 177.4,49.36 176.82,48.78 v1(176.82,48.05)
  BOTTOM w0.203: PRZ26.2 PRZ27.1 176.82,48.38 v1(176.82,48.05)
  BOTTOM w0.254: v1(152.72,88.13) PHZ02.1
CSI2_COMP: length 2
  TOP w0.089: v2(134.17,57.34) v1(134.17,56.8) 134.17,56.16 RC7.1
  BOTTOM w0.102: v1(134.17,56.8) 134.17,56.88 UC1.E13
CSIN_CHG: length 4.4
  TOP w0.254: PCB20.1 200.83,47.02 v2(201.03,46.81) 201.27,46.58 v1(201.7,46.58)
  BOTTOM w0.203: PCB18.2 201.12,47.15 v1(201.7,46.58) 201.79,46.49 PUB01.14
  BOTTOM w0.254: PCB18.2 200.17,47.15 PRB03.2
CSIP_CHG: length 5.8
  TOP w0.089: PCB19.1 200.64,48.96 v2(200.64,49.82)
  TOP w0.254: v1(201.74,47.75) 201.74,48.17 201.14,48.78 PCB19.1
  BOTTOM w0.203: PRB02.2 200.22,48.07 PCB18.1 201.42,48.07 v1(201.74,47.75) 201.74,47.18 202.04,46.89 PUB01.15
CSN1_VCORE1: length 6.1
  BOTTOM w0.254: PLI01.3 156.85,69.56 157.14,69.27 158.83,69.27 159.24,69.68 159.24,70 160.88,71.64 PRZ31.1
CSN2_VCORE2: length 13.5
  BOTTOM w0.254: PLI02.3 157.61,83.23 157.86,83.48 159.32,83.48 159.7,83.1 159.7,79.7 159.5,79.49 v2(159.5,79.21) 159.5,73.79 159.79,73.49 PRZ30.1
CSN_1A_VGT: length 56
  TOP w0.089: v1(157.15,98.96) v2(156.4,98.96)
  IN1 w0.152: v1(157.15,98.96) 157.49,99.31 158.29,99.31 160.99,96.6 164.39,96.6 164.5,96.5 164.58,96.5 168.93,92.14 168.94,92.02 168.94,88.63 169.09,88.48 169.09,82.51 169.68,81.93 169.68,75.41 173.32,71.76 173.32,70.76 173.71,70.37 173.71,69.25 174.53,68.44 175.02,68.44 175.52,67.93 v1(175.52,66.48)
  BOTTOM w0.152: PRZ51.1 173.5,63.27 174.29,64.07 174.29,65.69 175.08,66.48 v1(175.52,66.48) ; PLG01.3 152.69,96.31 153.01,96 155,96 PHZ03.2 v1(157.15,98.96)
CSN_1A_VGT_NTC: length 48
  TOP w0.089: v1(158.07,98.9) v2(158.53,98.43)
  TOP w0.152: v1(174.87,63.67) 175.81,64.61 175.81,65.37 174.98,66.19 174.98,66.83 175.36,67.21 175.36,67.61 174.95,68.02 v1(174.76,68.02)
  IN1 w0.152: v1(158.07,98.9) 160.61,96.36 164.29,96.36 164.4,96.25 164.47,96.25 168.69,92.03 168.7,92.01 168.7,88.53 168.84,88.38 168.84,82.41 169.43,81.82 169.43,75.3 173.08,71.66 173.08,70.65 173.46,70.27 173.46,69.15 174.59,68.02 v1(174.76,68.02)
  BOTTOM w0.152: v1(158.07,98.9) PHZ03.1
  BOTTOM w0.254: v1(174.87,63.67) 174.41,63.21 174.41,63.18 PRZ45.1
CSN_1B_VCCSA: length 41.7
  TOP w0.089: v1(152.35,57.31) v2(152.35,56.57)
  IN2 w0.152: v1(183.78,55.79) 182.21,55.79 v1(178.76,59.24)
  IN3 w0.152: v1(152.35,57.31) 152.35,57.04 153.02,56.37 153.32,56.37 154.04,55.65 157.52,55.65 157.76,55.9 159.41,55.9 159.62,56.11 165.49,56.11 166.81,57.44 167.71,57.44 168.88,58.61 171.12,58.61 171.48,58.26 172.35,58.26 172.47,58.37 177.88,58.37 178.75,59.24 v1(178.76,59.24)
  BOTTOM w0.152: PRZ06.1 183.4,56.17 v1(183.78,55.79) ; PHZ01.1 151.59,56.34 151.99,56.74 151.99,56.95 v1(152.35,57.31) 153.01,57.98 153.01,59.39 152.77,59.63 PLA01.3
CSON_CHG: length 5.4
  TOP w0.254: v1(206.07,43.05) v2(206.07,42.21) 206.07,41.55 PCB43.1
  BOTTOM w0.203: PUB01.1 205.97,43.15 v1(206.07,43.05)
  BOTTOM w0.254: v1(206.07,43.05) 206.13,42.98 PCB41.2 206.13,40.38 206.14,40.37 PRB36.1
CSOP_CHG: length 6.4
  TOP w0.089: v2(205.25,43.66) 205.47,43.44 v1(205.47,43.05)
  TOP w0.254: v1(205.47,43.05) 205.53,42.98 205.53,41.94 PCB38.1
  BOTTOM w0.203: PRB32.1 205.22,40.37 PCB41.1 205.51,41.49 205.51,43.01 v1(205.47,43.05) 205.57,43.14 PUB01.2
CSP1_2PH_CPU: length 7.2
  TOP w0.089: PRZ37.2 171.92,48.25 171.38,48.79 v2(171.38,49.42)
  TOP w0.254: v1(173.29,51.11) 173.11,51.11 172.77,50.78 PCZ20.2 PRZ32.2 172.77,49.1 171.96,48.29 PRZ37.2
  BOTTOM w0.203: v1(173.29,51.11) 173.62,51.11 174.03,51.51 PUZ01.10
CSP1_VCORE1: length 45.1
  TOP w0.089: v2(156.57,67.29) 156.85,67.02 v1(156.85,66.68)
  TOP w0.254: PRZ25.1 175.61,48.26 175.61,47.81 174.58,46.78 173.72,46.78 173.18,46.24 172.48,46.24 172.25,46.48 172.25,47.05 PRZ37.1 171.24,48.05 v1(171.24,48.05)
  IN2 w0.152: v1(156.68,48.66) 156.91,48.66 157.74,49.49 157.74,50.53 156.83,51.44 156.83,55.51 157.74,56.42 157.74,56.88 156.47,58.15 156.47,61.93 156.85,62.31 v1(156.85,66.68)
  IN3 w0.152: v1(171.24,48.05) 170.68,48.05 169.99,47.37 166.4,47.37 164.62,49.16 160.3,49.16 159.61,48.47 156.86,48.47 v1(156.68,48.66)
  BOTTOM w0.254: PLI01.2 v1(156.85,66.68)
CSP2_2PH_CPU: length 7
  TOP w0.089: PRZ38.2 174.33,48.25 v2(174.63,47.95)
  TOP w0.254: PRZ39.2 PRZ38.2 173.61,48.78 v1(173.47,48.92)
  BOTTOM w0.203: PUZ01.9 174.43,51.42 PCZ21.2 PRZ33.2 v1(173.47,48.92)
CSP2_VCORE2: length 64.1
  TOP w0.089: v1(157.61,85.86) v2(156.98,85.86)
  TOP w0.152: PRZ38.1 174.06,47.34 v1(174.25,47.53) 174.74,47.53 175.12,47.92 PRZ29.1
  IN2 w0.152: v1(157.61,85.86) 158.58,84.89 158.58,70.01 157.54,68.97 157.54,62.42 156.85,61.73 156.85,58.12 157.99,56.98 157.99,56.32 157.84,56.18 157.07,55.41 157.07,51.55 157.99,50.63 157.99,49.39 v1(156.68,48.08)
  IN3 w0.152: v1(156.68,48.08) 156.79,48.19 159.74,48.19 160.41,48.87 164.56,48.87 166.3,47.12 170.1,47.12 170.5,47.53 v1(174.25,47.53)
  BOTTOM w0.152: PLI02.2 v1(157.61,85.86)
CSP_1A_VCORE: length 57.2
  TOP w0.152: v1(174.9,67.46) 174.63,67.19 174.63,66.05 175.46,65.22 175.46,64.75 175.06,64.35 174.76,64.35 174.35,63.95 174.35,63.41 174.56,63.2 PCZ26.1 ; PRZ44.2 v2(154.29,96.01) 155.73,96.01 v1(155.87,95.86)
  TOP w0.254: PCZ26.1 174.41,61.74 174.41,60.75 174.38,60.73 v1(174.38,60.36)
  IN1 w0.152: v1(174.9,67.46) 174.66,67.46 173.11,69.01 173.11,70.13 172.73,70.51 172.73,71.66 169.19,75.2 169.19,81.72 168.6,82.31 168.6,88.27 168.45,88.42 168.45,91.93 164.37,96 160.46,96 159.87,96.59 156.55,96.59 155.87,95.91 v1(155.87,95.86)
  BOTTOM w0.203: PCZ27.1 174.38,61.21 v1(174.38,60.36) 174.38,59.87 174.83,59.42 PUZ01.29
  BOTTOM w0.254: PCZ27.1 174.35,62.04 PRZ45.2
CSP_1A_VGT_R: length 2.6
  TOP w0.089: v2(153.25,93.48) 152.95,93.48 v1(152.69,93.73)
  TOP w0.152: v1(152.69,93.73) 152.56,93.87 PRZ44.1
  BOTTOM w0.152: PLG01.2 v1(152.69,93.73)
CSP_1B_VCCSA: length 39
  TOP w0.089: v1(154.8,56.8) 154.44,56.45 v2(154.22,56.45)
  TOP w0.152: PRZ10.2 181.57,58.17 v1(181.68,58.28) ; v1(154.8,56.8) 154.8,57.32 154.57,57.55 PRZ13.2
  IN3 w0.152: v1(154.8,56.8) 155.46,56.14 157.31,56.14 157.56,56.39 159.21,56.39 159.42,56.61 165.22,56.61 165.77,57.15 165.77,58.91 167.15,60.28 170.12,60.28 170.62,60.79 172.29,60.79 173.32,59.76 176.43,59.76 177.07,60.41 179.03,60.41 181.15,58.28 v1(181.68,58.28)
  BOTTOM w0.152: PUZ01.40 179.16,56.9 179.32,57.06 180.26,57.06 PCZ08.2 PCZ09.2 181.68,57.59 v1(181.68,58.28)
CSP_1B_VCCSA_R: length 2.5
  TOP w0.089: v1(154.29,59.72) 154.29,60.05 v2(153.96,60.38)
  TOP w0.152: PRZ13.1 154.03,59.47 v1(154.29,59.72)
  BOTTOM w0.152: v1(154.29,59.72) 154.38,59.63 PLA01.2
CSREF_2PH_CPU: length 42.5
  TOP w0.089: v1(162.14,72.58) v2(162.7,72.58)
  TOP w0.254: v1(174.25,48.94) 173.69,49.5 PRZ32.1 PCZ20.1 174.15,50.92 174.15,51.83 PCZ19.1
  IN1 w0.254: v1(162.14,72.58) 164.98,72.58 165.81,71.75 165.81,69.96 170.2,65.57 170.2,59.76 170.78,59.17 172.02,59.17 172.37,58.82 172.37,53.86 174.25,51.98 v1(174.25,48.94)
  BOTTOM w0.203: PUZ01.8 174.83,50.9 PCZ21.1 PRZ33.1 174.39,49.08 v1(174.25,48.94)
  BOTTOM w0.254: v1(162.14,72.58) 162.14,71.87 PRZ31.2 160.78,72.77 PRZ30.2
CSSUM_2PH_CPU: length 7.2
  TOP w0.089: v1(175.27,51.11) 174.97,51.42 v2(174.75,51.42)
  TOP w0.254: PRZ25.2 PRZ29.2 175.12,50.76 175.27,50.92 v1(175.27,51.11)
  BOTTOM w0.203: PRZ26.1 175.38,49.19 PCZ18.2 PCZ17.2 175.38,51.01 v1(175.27,51.11) 175.13,51.25 175.13,52.31 175.23,52.4 PUZ01.7
DAT_SMB: length 5.9
  TOP w0.112: v1(162.05,41.35) 162.35,41.04 v2(162.68,41.04) 165.44,41.04 165.45,41.03 PR37.1
  BOTTOM w0.112: v1(162.05,41.35) 162.73,41.35 163.01,41.07 PBATT1.6
DAT_TP_SIO: length 158.6
  TOP w0.102: 44.15,83.83 UE1.79
  TOP w0.112: v2(44.22,85.12) 44.15,85.06 44.15,83.83 ; v1(44.01,81.73) 44.06,81.68 44.27,81.68 44.34,81.76 44.34,82.03 44.27,82.1 44.27,82.47 44.15,82.58 UE1.79 ; R31.2 114.97,26.73 C26.1 114.99,26.32 v1(115.53,25.79)
  IN1 w0.119: v1(44.01,81.73) 44.05,81.69 44.23,81.69 44.33,81.8 44.33,82.17 44.26,82.24 35.89,82.24 35.57,82.56 v1(35.3,82.56)
  BOTTOM w0.112: JTP1.2 124.05,29.85 124.49,29.41 124.49,28.22 123.47,27.2 118.31,27.2 116.67,25.56 115.75,25.56 v1(115.53,25.79) 115.13,26.18 113.88,26.18 113.29,25.59 99.77,25.59 99.18,25 76.9,25 70.71,31.2 66.24,31.2 65.32,32.11 57.29,32.11 55.53,33.88 55.04,33.88 53.87,35.05 47.62,35.05 43,39.67 43,41.37 41.62,42.75 39.91,42.75 37.01,45.66 37.01,49.64 37.46,50.1 37.46,51.18 36.68,51.96 36.68,55.88 34.72,57.84 34.72,60.53 34.25,61 34.25,62.55 32.59,64.21 32.59,65.03 33.29,65.73 33.29,69.54 35.14,71.4 35.14,79.02 34.74,79.42 34.74,82.71 34.99,82.96 35.16,82.96 35.3,82.81 v1(35.3,82.56)
DBC_PANEL_EN: length 156.3
  TOP w0.089: v1(151.85,26.92) 151.85,30.98 150.08,32.75 150.08,34.25 147.49,36.84 146.84,36.84 146.34,36.34 145.05,36.34 144.61,36.78 143.41,36.78 141.39,38.81 141.39,41.11 140.95,41.75 140.17,42.8 139.7,43.27 138.25,43.87 135.94,43.87 135.43,43.63 134.08,43.63 133.73,43.98 133.73,44.86 132.96,45.63 129.49,45.63 128.34,44.48 127.37,44.48 126.88,44 126.88,43.3 126.04,42.46 126.04,42 125.82,41.78 124.05,41.78 123.17,40.9 122.48,40.9 121.52,41.85 121.52,43.38 121.07,43.83 121.07,45.04 120.85,45.26 120.54,45.26 120.32,45.04 120.18,45.04 119.94,45.29 117.95,45.29 116.91,46.33 116.91,47.93 119.93,50.96 119.93,51.59 120.15,51.81 120.15,52.37 120.74,52.96 v1(120.74,53.28) ; v2(209.07,52.8) 209.57,52.8 209.58,52.79 R6.2
  TOP w0.102: R6.2 211.04,52.79 v1(211.39,53.13)
  IN1 w0.089: v1(177.47,31.15) 177.06,31.55 174.32,31.55 173.64,30.88 159.68,30.88 157.81,29.01 156.01,29.01 154.9,27.9 152.83,27.9 v1(151.85,26.92)
  IN2 w0.089: v1(211.39,53.13) 211.4,53.13 212.43,52.1 212.43,47.47 212.92,46.97 212.92,46.53 215.41,44.04 215.41,39.76 215.06,39.41 215.06,33.52 214.51,32.98 213.15,32.98 213,33.13 211.43,33.13 210.24,31.95 196.93,31.95 195.75,33.13 193.35,33.13 192.32,32.1 188.36,32.1 187.68,32.78 180.63,32.78 179.31,31.46 178.35,31.46 178.03,31.15 v1(177.47,31.15)
  BOTTOM w0.076: UC1.AM5 120.74,53.11 v1(120.74,53.28)
DBC_PANEL_EN_R: length 4.7
  TOP w0.089: R6.1 209.6,53.7 209.55,53.75 209.54,53.75 v2(209.05,54.24)
  TOP w0.102: v1(211.32,55.18) 210.57,54.44 R5.2 R6.1
  BOTTOM w0.089: 211.88,55.45 211.58,55.45 v1(211.32,55.18)
  BOTTOM w0.102: JEDP1.11 211.88,55.45
DCIN_CHG:
  vias: v1(202.03,50.91) v1(202.66,50.91) v2(201.99,50.35)
DDC_CLK_HDMI: length 38
  IN3 w0.135: v1(28.67,88.04) 28.43,87.8 28.43,86.77 27.84,86.19 25.96,86.19 23.15,89 v1(23.15,89.34) 25.08,89.34 25.8,90.06 v1(26.39,90.06)
  BOTTOM w0.112: RI13.1 26.84,90.52 v1(26.39,90.06) ; JHDMI1.15 11.49,99.35 11.9,99.75 11.9,100.98 12.36,101.44 12.84,101.44 13.66,100.63 13.66,98.73 13.91,98.48 13.91,91.89 17.5,88.3 19.35,88.3 19.73,88.68 22.49,88.68 v1(23.15,89.34) ; v1(28.67,88.04) QI2.6
DDC_DATA_HDMI: length 23.4
  BOTTOM w0.112: QI2.3 25.25,89.34 25,89.09 RI14.1 22.91,88.19 v2(22.37,88.19) 19.94,88.19 19.55,87.81 17.29,87.81 13.41,91.69 13.41,98.28 13.16,98.53 13.16,99.29 JHDMI1.16
DDR4_DRAMRST#: length 17.4
  TOP w0.112: 67.35,83.01 CD29.1 ; 67.35,83.01 v2(58.2,83.01) 57.15,83.01 v1(56.92,83.24) ; 67.35,83.01 69.01,83.01 RD8.2 69.13,82.89 v1(68.5,82.26)
  BOTTOM w0.102: v1(56.92,83.24) 58.25,83.24 JDIMM2.108 ; v1(68.5,82.26) 69.48,83.24 JDIMM1.108
DDR_A_ACT#: length 52.4
  IN1 w0.183: 103.85,86.9 104.68,86.08 104.68,85.85 106.12,84.41 107.47,84.41 107.65,84.23 v1(107.65,83.54) ; 75.57,86.05 77.62,86.05
  IN1 w0.188: 75.57,86.05 74.49,86.05 74.48,86.04 72.71,86.04 72.52,85.86 72.52,85.14 72.71,84.96 73.28,84.96 73.47,84.77 v1(73.47,84.53) ; 77.62,86.05 78.7,87.12 103.64,87.12 103.85,86.9
  BOTTOM w0.076: v1(107.65,83.54) 108.15,83.04 v2(108.3,83.04) 110.01,83.04 110.14,82.91 111.04,82.91 112.28,81.67 113.5,81.67 113.69,81.48 114.05,81.48 114.05,81.48 114.14,81.51 114.34,81.51 114.43,81.48 114.43,81.48 114.44,81.47 114.45,81.47 114.67,81.47 UC1.BA55
  BOTTOM w0.183: JDIMM1.114 72.04,81.74 73.47,83.17 v1(73.47,84.53)
DDR_A_ALERT#: length 54.7
  IN1 w0.076: v1(109.81,80.14) 109.12,79.44 105.68,79.44 105.16,79.96 105.14,79.97 105.14,80.24 104.77,80.62
  IN1 w0.183: 103.87,81.51 104.77,80.62
  IN1 w0.188: v1(73.51,81.64) 72.32,80.46 72.32,78.26 72.61,77.97 76.02,77.97 76.55,77.44 79.63,77.44 80.12,77.93 80.97,77.93 80.97,77.93 87.31,77.93 90.89,81.51 103.87,81.51
  BOTTOM w0.076: v1(109.81,80.14) 110.06,80.14 110.51,79.69 110.51,79.24 v2(110.51,79.23) 110.97,78.77 112.03,78.77 112.43,78.37 113.65,78.37 113.78,78.5 114.03,78.5 114.1,78.46 114.11,78.45 114.14,78.44 114.28,78.44 114.44,78.48 114.68,78.48 114.74,78.45 115.01,78.45 115.12,78.48 115.45,78.48 115.64,78.29 UC1.AW50
  BOTTOM w0.183: v1(73.51,81.64) 73.07,81.2 72.25,81.2 72.21,81.24 JDIMM1.116
DDR_A_BG0: length 54.4
  IN1 w0.183: v1(106.44,83.51) 106.44,83.74 106.25,83.92 105.6,83.92 105.42,84.11 105.42,84.51 104.4,85.53 104.4,85.97 103.94,86.44 103.93,86.44
  IN1 w0.188: 103.93,86.44 103.72,86.65 83.39,86.65 83.2,86.46 83.2,85.85 83.01,85.66 82.64,85.66 82.45,85.85 82.45,86.46 82.26,86.65 81.89,86.65 81.7,86.46 81.7,86 81.51,85.81 81.13,85.81 80.95,86 80.95,86.46 80.76,86.65 80.38,86.65 80.19,86.46 80.19,86 80.01,85.81 79.45,85.81 79.26,86 79.26,86.27 79.08,86.46 78.7,86.46 78.51,86.27 78.51,85.77 78.32,85.59 75.64,85.59 74.99,84.94 v1(74.99,84.53)
  BOTTOM w0.076: UC1.AY55 115.44,81.35 115.15,81.05 114.99,80.98 114.81,80.98 114.65,81.03 114.51,81.03 114.29,80.97 114.17,80.97 114.09,81 114.06,81.01 113.56,81.01 113.42,80.87 112.82,80.87 110.98,82.71 v2(109.58,82.71) 107.24,82.71 v1(106.44,83.51)
  BOTTOM w0.183: JDIMM1.115 79.15,81.49 78.09,81.49 75.48,84.1 75.43,84.1 v1(74.99,84.53)
DDR_A_BG1: length 53.5
  IN1 w0.076: v1(105.83,83.51) 105.28,83.51 105.2,83.59 105.2,84.42 104.13,85.49
  IN1 w0.183: 103.37,86.18 103.44,86.18 104.13,85.49
  IN1 w0.188: v1(76.52,84.53) 76.52,84.97 76.71,85.16 77.47,85.16 77.69,84.94 77.69,84.65 77.88,84.46 78.22,84.46 79.11,85.35 81.11,85.35 81.51,84.94 82.03,84.94 82.29,85.2 82.78,85.2 83.04,84.94 83.67,84.94 83.86,85.13 83.86,86 84.04,86.18 84.42,86.18 84.61,86 84.61,85.13 84.8,84.94 85.17,84.94 85.36,85.13 85.36,86 85.55,86.18 85.92,86.18 86.11,86 86.11,85.13 86.3,84.94 86.68,84.94 86.86,85.13 86.86,86 87.05,86.18 87.43,86.18 87.62,86 87.62,85.54 87.8,85.35 88.12,85.35 88.95,86.18 103.37,86.18
  BOTTOM w0.076: v1(105.83,83.51) 106.92,82.42 111.03,82.42 112.74,80.71 113.54,80.71 113.68,80.85 114.03,80.85 114.14,80.79 114.28,80.79 114.51,80.86 114.65,80.86 114.86,80.78 115.12,80.78 UC1.AY54
  BOTTOM w0.183: v1(76.52,84.53) 77.46,83.59 77.46,82.81 78.28,81.99 79.15,81.99 JDIMM1.113
DDR_A_BS0: length 52.8
  IN1 w0.076: 104.78,76.88 105.51,76.88 105.6,76.97 108.88,76.97 108.93,77.02 109.27,77.02 109.35,76.95 109.35,76.93 109.43,76.86 109.58,76.86 109.65,76.93 109.65,76.95 109.73,77.02 109.88,77.02 109.96,76.95 109.96,76.93 110.04,76.86 110.19,76.86 110.26,76.93 110.26,76.95 110.34,77.02 110.49,77.02 110.57,76.95 110.57,76.93 110.64,76.86 110.8,76.86 110.87,76.93 110.87,76.95 110.95,77.02 111.1,77.02 111.18,76.95 111.18,76.93 111.25,76.86 112.63,76.86 112.7,76.93 112.7,76.95 112.78,77.02 115.39,77.02 116.05,77.68 116.05,78.07 115.9,78.23 115.9,79.15 116.14,79.4 116.67,79.4 116.87,79.19 116.87,78.91 v1(116.68,78.72)
  IN1 w0.183: 104.78,76.88 103.68,76.88 103.56,76.76
  IN1 w0.188: 103.56,76.76 103.56,76.76 94.44,76.76 89.68,72.01 76.93,72.01 v1(76.49,72.44)
  BOTTOM w0.076: v1(116.68,78.72) 117.03,79.07 UC1.AU52
  BOTTOM w0.183: v1(76.49,72.44) 75.27,71.21 72.48,71.21 72,70.74 70.95,70.74 JDIMM1.150
DDR_A_BS1: length 54.4
  IN1 w0.076: v1(117.41,77.8) 117.6,77.8 117.65,77.85 117.65,78.05 117.76,78.16 117.76,78.27 117.68,78.34 116.29,78.34 116.21,78.27 116.21,77.61 115.46,76.86 114.84,76.86 114.76,76.78 114.76,76.54 114.69,76.46 114.54,76.46 114.46,76.54 114.46,76.78 114.38,76.86 114.23,76.86 114.15,76.78 114.15,76.54 114.08,76.46 113.93,76.46 113.85,76.54 113.85,76.78 113.77,76.86 113.24,76.86 113.02,76.64 107.94,76.64
  IN1 w0.188: 107.94,76.64 107.94,76.64 104.93,76.64 104.89,76.6 103.87,76.6 103.56,76.29 94.63,76.29 89.87,71.54 74.93,71.54 74.75,71.73 74.75,72.21 v1(74.97,72.44)
  BOTTOM w0.076: UC1.AT48 117.62,77.34 117.41,77.62 v1(117.41,77.8)
  BOTTOM w0.183: JDIMM1.145 78.38,71.99 77.49,72.88 75.41,72.88 v1(74.97,72.44)
DDR_A_CAS#: length 53.9
  IN1 w0.076: 104.32,74.84 104.93,74.84 105,74.92 105,75.5 105.08,75.57 105.23,75.57 105.31,75.5 105.31,74.92 105.39,74.84 105.54,74.84 105.63,74.93 105.63,75.71 105.7,75.79 105.86,75.79 105.93,75.71 105.93,74.92 106.01,74.84 110.25,74.84 110.33,74.92 110.33,75.05 110.41,75.13 110.56,75.13 110.64,75.05 110.64,74.92 110.71,74.84 110.86,74.84 110.94,74.92 110.94,75.05 111.02,75.13 111.17,75.13 111.25,75.05 111.25,74.92 111.32,74.84 114.15,74.84 116.38,77.07 116.62,77.07 116.7,77 v1(116.7,76.88)
  IN1 w0.183: 103.44,74.89 104.27,74.89 104.32,74.84
  IN1 w0.188: v1(73.51,69.06) 74.05,69.61 76.81,69.61 76.81,69.61 80.67,69.61 81.2,70.14 90.46,70.14 95.21,74.89 103.44,74.89
  BOTTOM w0.076: UC1.AU48 117.03,77.22 v1(116.7,76.88)
  BOTTOM w0.183: v1(73.51,69.06) 73.07,69.51 72.23,69.51 71.96,69.24 70.95,69.24 JDIMM1.156
DDR_A_CKE0: length 50.9
  IN1 w0.183: v1(108.87,83.54) 109.36,83.54 109.54,83.72 109.54,84.5 109.36,84.68 106.23,84.68 104.95,85.96 104.95,86.49 104.51,86.92
  IN1 w0.188: 104.51,86.92 103.85,87.59 81.08,87.59 80.94,87.73 78.21,87.73 78.02,87.54 78.02,87.11 77.83,86.92 77.46,86.92 77.27,87.11 77.27,87.54 77.08,87.73 76.38,87.73 76.2,87.54 76.2,87.11 76.39,86.92 76.5,86.92 76.68,86.73 v1(76.68,86.49)
  BOTTOM w0.076: UC1.BA56 114.41,82.07 114.21,82.07 113.88,82.3 112.37,82.3 110.77,83.9 109.23,83.9 v1(108.87,83.54)
  BOTTOM w0.183: JDIMM1.109 79.15,82.99 78.09,82.99 77.91,83.17 77.91,84.7 76.68,85.92 v1(76.68,86.49)
DDR_A_CKE1: length 50.7
  IN1 w0.076: v1(109.99,83.54) 109.99,84.82 109.92,84.9 106.33,84.9 105.22,86.01 105.22,86.85
  IN1 w0.183: 104.75,87.34 105.22,86.87 105.22,86.85
  IN1 w0.188: v1(73.64,86.49) 73.64,87.26 74.56,88.19 81.13,88.19 81.28,88.05 104.04,88.05 104.75,87.34
  BOTTOM w0.076: v1(109.99,83.54) 110.88,83.54 112.42,82 113.82,82 UC1.BB56
  BOTTOM w0.183: JDIMM1.110 71.9,82.74 72.14,82.97 72.14,85 v1(73.64,86.49)
DDR_A_CKE2: length 5.8
  BOTTOM w0.076: TP3.1 110.99,83.19 112.35,81.84 113.57,81.84 113.76,81.64 114.01,81.64 114.11,81.68 114.37,81.68 114.46,81.64 115.6,81.64 UC1.AW56
DDR_A_CKE3: length 6.6
  BOTTOM w0.076: UC1.AY56 114.77,82.24 114.24,82.24 113.93,82.47 112.43,82.47 110.54,84.36 TP4.1
DDR_A_CLK0: length 52.7
  IN1 w0.076: v1(117.45,80.54) 117.28,80.38 117.28,80.12 117.11,79.95 115.69,79.95 114.11,78.37 111.78,78.37 111.72,78.43 104.19,78.43 103.77,78.85
  IN1 w0.119: v1(75.41,74.78) 75.58,74.61 75.58,74.25 75.83,74 77.14,74 77.52,74.38 78.9,74.38 79.05,74.53 87.69,74.53 90.83,77.67 91,77.67 91.54,77.13 91.89,77.13 92.4,77.65 92.4,78 91.9,78.5 91.9,78.67 92.08,78.85 103.77,78.85
  BOTTOM w0.076: v1(117.45,80.54) 117.45,80.32 UC1.AT53
  BOTTOM w0.102: JDIMM1.137 78.25,75.99 78.1,75.83 75.92,75.83 75.88,75.8 75.86,75.8 75.66,75.6 75.66,75.02 v1(75.41,74.78)
DDR_A_CLK1: length 52
  IN1 w0.076: v1(117.34,81.46) 117.17,81.29 117.17,81.08 117,80.9 114.88,80.9 112.75,78.78 104.67,78.78 103.77,79.68 103.37,79.68
  IN1 w0.119: v1(73.89,74.78) 73.66,75.01 73.66,75.22 73.96,75.52 74.45,75.52 74.71,75.26 78.8,75.26 78.92,75.39 87.38,75.39 91.67,79.67 103.33,79.67 103.34,79.68 103.37,79.68
  BOTTOM w0.076: v1(117.34,81.46) UC1.AT55
  BOTTOM w0.102: v1(73.89,74.78) 73.6,75.07 73.6,75.37 73.36,75.61 71.87,75.61 71.74,75.74 JDIMM1.138
DDR_A_CLK#0: length 52.6
  IN1 w0.076: 103.85,79.06 103.86,79.06 103.98,78.94 103.98,78.93 104.31,78.6 111.79,78.6 111.85,78.54 114.04,78.54 115.62,80.12 117.04,80.12 117.12,80.19 117.12,80.37 117.09,80.39 117.09,80.59 117.04,80.64 116.78,80.64 v1(116.68,80.54)
  IN1 w0.119: 103.85,79.06 103.47,79.06 103.46,79.07 91.99,79.07 91.68,78.76 91.68,78.58 91.68,78.41 92.18,77.91 92.18,77.74 91.8,77.35 91.63,77.35 91.09,77.89 90.74,77.89 87.6,74.75 78.96,74.75 78.81,74.6 77.43,74.6 77.05,74.22 75.92,74.22 75.8,74.34 75.8,74.66 75.92,74.78 v1(76.18,74.78)
  BOTTOM w0.076: v1(116.68,80.54) 116.84,80.54 117.03,80.35 UC1.AU53
  BOTTOM w0.102: JDIMM1.139 78.21,75.49 78.08,75.62 76,75.62 75.88,75.51 75.88,75.07 v1(76.18,74.78)
DDR_A_CLK#1: length 52
  IN1 w0.076: 103.39,79.89 103.43,79.85 103.84,79.85 104.74,78.94 112.68,78.94 114.81,81.07 116.93,81.07 117.01,81.14 117.01,81.32 116.87,81.46 v1(116.7,81.46)
  IN1 w0.119: 103.39,79.89 91.58,79.89 87.29,75.61 78.83,75.61 78.71,75.48 74.8,75.48 74.54,75.74 73.87,75.74 73.44,75.31 73.44,74.94 73.28,74.78 v1(73.13,74.78)
  BOTTOM w0.076: v1(116.7,81.46) UC1.AU55
  BOTTOM w0.102: JDIMM1.140 71.72,75.24 71.86,75.38 73.27,75.38 73.37,75.28 73.37,75.02 v1(73.13,74.78)
DDR_A_CS#0: length 55.3
  IN1 w0.076: 105.39,73.01 110.79,73.01 111.62,72.18 113.34,72.18 115.76,74.59 117.22,74.59 117.29,74.67 v1(117.29,75.05)
  IN1 w0.183: 102.89,73.01 105.39,73.01
  IN1 w0.188: 102.89,73.01 96.53,73.01 96.35,72.82 96.35,72.2 95.48,71.34 95.21,71.34 94.89,71.66 94.62,71.66 94.36,71.39 94.36,71.13 94.95,70.54 94.95,70.27 94.68,70.01 94.42,70.01 93.83,70.59 93.56,70.59 93.29,70.33 93.29,70.06 93.88,69.47 93.88,69.21 93.62,68.94 93.35,68.94 92.76,69.53 92.5,69.53 92.08,69.12 92.08,68.85 92.67,68.26 92.67,68 92.41,67.73 92.14,67.73 91.55,68.32 91.28,68.32 90.46,67.49 90.46,67.11 90.27,66.92 89.45,66.92 89.26,67.11 89.26,67.49 89.08,67.68 88.7,67.68 88.51,67.49 88.51,67.11 88.32,66.92 87.95,66.92 87.76,67.11 87.76,67.49 87.57,67.68 85.04,67.68 84.8,67.44 84.53,67.44 84.3,67.68 82.68,67.68 82.18,67.18 81.5,67.18 81.22,67.46 v1(81.22,67.7)
  BOTTOM w0.076: v1(117.29,75.05) 117.29,75.26 UC1.AU45
  BOTTOM w0.183: v1(81.22,67.7) 81.22,70.78 81.02,70.99 JDIMM1.149
DDR_A_CS#1: length 57.2
  IN1 w0.076: v1(116.73,75.05) 116.73,75.34 116.66,75.42 116.35,75.42 114.68,73.75 113.4,73.75 113.33,73.67 113.33,73.41 113.25,73.34 113.1,73.34 113.02,73.41 113.02,73.67 112.94,73.75 112.34,73.75 112.11,73.52 112.11,72.51 112.03,72.43 111.6,72.43 110.8,73.23
  IN1 w0.183: 75.44,67.31 75.62,67.49 77.32,67.49
  IN1 w0.188: v1(74.73,66.91) 74.73,67.04 75,67.31 75.44,67.31 ; 77.32,67.49 77.88,66.93 78.26,66.93 78.64,67.31 78.97,67.31 79.35,66.93 79.75,66.93 80.03,67.2 80.03,67.89 80.29,68.15 90.45,68.15 94.76,72.45 95.02,72.45 95.35,72.13 95.61,72.13 95.88,72.4 95.88,72.66 95.55,72.99 95.55,73.25 95.79,73.49 102.85,73.49 103.01,73.32 104.27,73.32 104.63,73.68 105.24,73.68 105.7,73.23 106.27,73.23 106.51,73.46 107.05,73.46 107.28,73.23 107.8,73.23 108.09,73.52 108.55,73.52 108.84,73.23 109.26,73.23 109.41,73.38 109.88,73.38 110.04,73.23 110.8,73.23
  BOTTOM w0.076: UC1.AU43 117.03,74.75 v1(116.73,75.05)
  BOTTOM w0.183: JDIMM1.157 78.02,68.99 77.66,68.62 76.45,68.62 v1(74.73,66.91)
DDR_A_D0: length 66.4
  IN1 w0.114: v1(120.05,94.74) 120.63,94.74 121.46,95.58 121.46,96.02
  IN1 w0.119: v1(74.47,109.14) 74.86,109.53 75.72,109.53 75.76,109.57 77.75,109.57 78.34,108.98 81.62,108.98 82.52,108.08 86.29,108.08 88.18,106.19 116.01,106.19 121.46,100.74 121.46,96.02
  BOTTOM w0.076: v1(120.05,94.74) 119.69,94.38 119.69,93.23 120.37,92.55 120.37,92.27 120.72,91.92 120.72,90.64 UC1.AL71
  BOTTOM w0.112: JDIMM1.4 72.01,109.24 72.54,109.77 73.84,109.77 v1(74.47,109.14)
DDR_A_D1: length 67.5
  IN1 w0.119: v1(76,109.14) 76.41,108.72 77.46,108.72 77.91,108.27 80.73,108.27 81.37,108.27 82.24,107.41 84.1,107.41 85.11,106.4 85.11,105.64 85.23,105.52 85.6,105.52 85.72,105.64 85.72,106.24 85.84,106.36 86.08,106.36 86.2,106.24 86.2,105.64 86.32,105.52 86.56,105.52 86.68,105.64 86.68,105.86 86.8,105.98 87.04,105.98 87.16,105.86 87.16,105.64 87.28,105.52 115.74,105.52 120.08,101.17 120.08,99.7 120.43,99.34 120.43,98.87 v1(120.05,98.49)
  BOTTOM w0.076: UC1.AL68 120.21,88.67 120.04,88.68 119.86,88.86 119.85,88.99 119.85,89.46 119.81,89.54 119.81,89.73 119.86,89.89 119.86,90.03 119.8,90.25 119.8,90.37 119.83,90.45 119.85,90.48 119.85,90.98 119.64,91.19 119.64,92.59 119.2,93.03 119.2,97.63 v2(119.49,97.92) v1(120.05,98.49)
  BOTTOM w0.112: JDIMM1.3 78.09,109.49 77.94,109.64 76.5,109.64 v1(76,109.14)
DDR_A_D2: length 68.1
  IN1 w0.114: 118.49,99.07 118.93,98.63 118.93,97.71 v1(118.43,97.21) ; 74.78,106.79 76.52,106.79 76.52,106.79 76.61,106.79
  IN1 w0.119: 76.61,106.79 77,106.79 77.01,106.8 77.63,106.8 78.02,106.4 81.4,106.4 82.07,105.73 82.91,105.73 84.43,104.21 95.56,104.21 95.68,104.09 95.68,103.4 95.8,103.28 96.04,103.28 96.16,103.4 96.16,104.09 96.28,104.21 96.52,104.21 96.64,104.09 96.64,103.4 96.76,103.28 97,103.28 97.11,103.4 97.11,104.09 97.23,104.21 97.47,104.21 97.59,104.09 97.59,103.81 97.71,103.69 97.95,103.69 98.07,103.81 98.07,104.09 98.19,104.21 114.64,104.21 118.49,100.36 118.49,100.31 118.49,100.31 118.49,100.03 118.49,99.07 ; v1(72.75,106.04) 72.75,106.67 72.87,106.79 74.78,106.79
  BOTTOM w0.076: UC1.AN68 119.23,89.19 119.19,89.39 119.22,89.49 119.24,89.61 119.19,89.78 118.98,89.98 118.98,90.91 118.98,90.92 118.98,92.25 118.51,92.72 118.51,93.99 117.87,94.63 v2(117.87,96.38) 117.87,96.64 v1(118.43,97.21)
  BOTTOM w0.112: v1(72.75,106.04) 71.94,105.24 JDIMM1.20
DDR_A_D3: length 67.9
  IN1 w0.114: 118.16,98.87 v1(118.56,98.47) ; 76.21,106.46 76.66,106.46
  IN1 w0.119: 76.66,106.46 77.14,106.46 77.15,106.46 77.49,106.46 77.88,106.07 81.26,106.07 81.93,105.4 82.77,105.4 84.3,103.87 91.13,103.87 91.25,103.75 91.25,103.07 91.37,102.95 91.61,102.95 91.72,103.07 91.72,103.75 91.84,103.87 92.08,103.87 92.2,103.75 92.2,103.07 92.32,102.95 92.56,102.95 92.68,103.07 92.68,103.75 92.8,103.87 93.04,103.87 93.16,103.75 93.16,103.07 93.28,102.95 93.52,102.95 93.64,103.07 93.64,103.75 93.75,103.87 93.99,103.87 94.11,103.75 94.11,103.07 94.23,102.95 94.47,102.95 94.59,103.07 94.59,103.75 94.71,103.87 94.95,103.87 95.07,103.75 95.07,103.07 95.19,102.95 102.57,102.95 103.49,103.87 114.45,103.87 118.16,100.17 118.16,98.87 ; v1(75.79,106.04) 76.21,106.46
  BOTTOM w0.076: v1(118.56,98.47) 119.03,98 119.03,92.96 119.47,92.52 119.47,91.12 119.68,90.91 119.68,90.51 119.62,90.36 119.62,90.36 119.62,90.26 119.69,90.03 119.69,89.89 119.61,89.68 119.61,89.42 UC1.AN69
  BOTTOM w0.112: v1(75.79,106.04) 76.85,104.99 79.15,104.99 JDIMM1.21
DDR_A_D4: length 67.4
  IN1 w0.114: v1(120.05,93.47) 121.8,95.21 121.8,99.08
  IN1 w0.119: v1(72.95,109.14) 73.67,109.87 75.58,109.87 75.62,109.91 77.96,109.91 78.54,109.33 81.75,109.33 82.66,108.41 86.42,108.41 88.31,106.52 116.15,106.52 121.8,100.88 121.8,99.08
  BOTTOM w0.076: UC1.AL70 120.74,90.12 120.91,90.29 120.97,90.42 121.01,90.54 121.01,90.78 120.88,90.9 120.88,92.01 120.56,92.34 120.56,92.97 v1(120.05,93.47)
  BOTTOM w0.112: v1(72.95,109.14) 72.05,108.24 70.95,108.24 JDIMM1.8
DDR_A_D5: length 67.8
  IN1 w0.114: v1(120.05,95.38) 120.4,95.38 121.13,96.1 121.13,96.45
  IN1 w0.119: v1(77.52,109.14) 77.6,109.06 77.6,109.06 78.05,108.61 80.59,108.61 81.51,108.61 82.38,107.74 84.94,107.74 85.06,107.62 85.06,106.92 85.29,106.69 85.54,106.69 85.66,106.81 85.66,107.62 85.78,107.74 86.01,107.74 86.13,107.62 86.13,106.81 86.25,106.69 87.2,106.69 88.04,105.85 115.88,105.85 121.13,100.6 121.13,100.36 121.01,100.24 120.53,100.24 120.42,100.12 120.42,99.88 120.53,99.76 121.01,99.76 121.13,99.64 121.13,99.4 121.01,99.28 120.76,99.28 120.64,99.16 120.64,98.92 120.76,98.8 121.01,98.8 121.13,98.68 121.13,98.26 121.01,98.14 120.55,98.14 120.43,98.02 120.43,97.78 120.55,97.66 121.01,97.66 121.13,97.54 121.13,97.3 121.01,97.18 120.55,97.18 120.43,97.06 120.43,96.82 120.55,96.7 121.01,96.7 121.13,96.59 121.13,96.45
  BOTTOM w0.076: v1(120.05,95.38) v2(120.67,94.76) 120.73,94.7 120.73,92.39 121.05,92.08 121.05,91 121.17,90.87 121.17,90.52 121.15,90.43 121.13,90.36 121.12,90.28 121.08,90.15 121.08,90.15 121.01,89.96 121.01,89.79 120.74,89.52 UC1.AL69
  BOTTOM w0.112: v1(77.52,109.14) 78.17,108.49 79.15,108.49 JDIMM1.7
DDR_A_D6: length 66
  IN1 w0.114: 117.74,95.99 v1(118.43,95.3)
  IN1 w0.119: 117.74,95.99 117.38,96.35 117.38,97.98 117.26,98.1 111.47,98.1 107.3,102.28 84.94,102.28 82.5,104.73 81.65,104.73 80.98,105.4 74.92,105.4 73.8,104.28 73.36,104.28 73.24,104.4 73.24,104.91 73.12,105.02 72.89,105.02 72.77,104.91 72.77,104.4 72.65,104.28 72.23,104.28 72.11,104.4 72.11,105.48 72.23,105.6 73.82,105.6 v1(74.27,106.04)
  BOTTOM w0.076: v1(118.43,95.3) v2(118.43,94.78) 118.43,94.33 118.7,94.06 118.7,92.78 119.14,92.34 119.14,90.98 119.15,90.98 119.15,90.24 UC1.AN70
  BOTTOM w0.112: v1(74.27,106.04) 73.85,106.47 72.32,106.47 72.09,106.24 70.95,106.24 JDIMM1.16
DDR_A_D7: length 65
  IN1 w0.114: v1(118.43,96.57) 117.82,97.18 117.82,99.6
  IN1 w0.119: v1(77.32,106.04) 77.63,105.73 81.12,105.73 81.79,105.06 82.63,105.06 85.08,102.61 85.33,102.61 85.45,102.73 85.45,103.42 85.57,103.54 85.81,103.54 85.93,103.42 85.93,102.73 86.05,102.61 86.28,102.61 86.4,102.73 86.4,103.42 86.52,103.54 86.76,103.54 86.88,103.42 86.88,102.73 87,102.61 87.24,102.61 87.36,102.73 87.36,103.42 87.48,103.54 87.72,103.54 87.84,103.42 87.84,102.73 87.96,102.61 88.19,102.61 88.31,102.73 88.31,103.42 88.43,103.54 88.67,103.54 88.79,103.42 88.79,102.73 88.91,102.61 89.15,102.61 89.27,102.73 89.27,103.42 89.39,103.54 89.63,103.54 89.75,103.42 89.75,102.73 89.87,102.61 90.1,102.61 90.22,102.73 90.22,103.42 90.34,103.54 90.58,103.54 90.7,103.42 90.7,102.73 90.82,102.61 109.45,102.61 110.29,103.46 114.39,103.46 117.82,100.03 117.82,99.6
  BOTTOM w0.076: v1(118.43,96.57) 118.87,96.13 118.87,92.87 119.31,92.43 119.31,91.05 119.41,90.95 UC1.AN71
  BOTTOM w0.112: v1(77.32,106.04) 77.73,106.04 77.78,105.99 JDIMM1.17
DDR_A_D8: length 58
  IN1 w0.114: v1(116.85,94.55) 116.85,95.73 116.53,96.05 116.37,96.05 115.7,95.37 115.54,95.37 115.38,95.53 115.38,95.7 116.05,96.37 116.05,96.53 115.69,96.89 114.75,96.89
  IN1 w0.119: 114.75,96.89 110.99,96.89 106.8,101.08 84.45,101.08 82,103.53 81.15,103.53 80.77,103.92 75.73,103.92 75.61,103.8 v1(75.61,103.34)
  BOTTOM w0.076: v1(116.85,94.55) 117.31,94.55 118.13,93.73 118.13,92.53 118.65,92.02 118.65,90.78 118.65,90.78 118.65,90.39 118.39,90.12 UC1.AR70
  BOTTOM w0.112: JDIMM1.29 77.8,102.99 77.6,102.78 76.16,102.78 v1(75.61,103.34)
DDR_A_D9: length 59.2
  IN1 w0.119: v1(77.13,103.34) 77.37,103.58 77.71,103.58 77.84,103.45 77.97,103.32 78.34,103.32 78.47,103.45 78.6,103.58 78.98,103.58 79.11,103.45 79.24,103.32 79.61,103.32 79.74,103.45 79.87,103.58 80.63,103.58 81.02,103.19 81.86,103.19 84.31,100.75 106.66,100.75 110.85,96.56 112.02,96.56 112.14,96.44 112.14,95.89 112.26,95.78 112.5,95.78 112.62,95.89 112.62,96.44 112.74,96.56 112.97,96.56 113.09,96.44 113.09,95.86 113.21,95.74 113.45,95.74 113.57,95.86 113.57,96.44 113.69,96.56 113.93,96.56 114.05,96.44 114.05,95.49 114.17,95.37 114.41,95.37 114.53,95.49 114.53,96.44 114.65,96.56 114.98,96.56 115.1,96.44 115.1,95.41 115.81,94.7 116.16,94.7 v1(116.46,95)
  BOTTOM w0.076: UC1.AR68 118.29,88.87 118.62,89.2 118.62,89.23 118.62,89.32 118.61,89.38 118.56,89.48 118.55,89.55 118.58,89.7 118.82,89.98 118.82,90.84 118.81,90.85 118.81,92.12 118.32,92.61 118.32,93.86 117.19,95 v1(116.46,95)
  BOTTOM w0.112: v1(77.13,103.34) 77.78,103.99 JDIMM1.25
DDR_A_D10: length 56.2
  IN1 w0.114: 111.86,93.91 113.41,93.91 v1(114.3,93.03)
  IN1 w0.119: v1(77.32,100.73) 77.72,101.13 81.31,101.13 83.34,99.1 88.29,99.1 88.41,98.98 88.41,98.51 88.53,98.39 88.76,98.39 88.88,98.51 88.88,98.98 89,99.1 89.24,99.1 89.36,98.98 89.36,98.51 89.48,98.39 89.72,98.39 89.84,98.51 89.84,98.98 89.96,99.1 90.2,99.1 90.32,98.98 90.32,98.51 90.44,98.39 90.67,98.39 90.79,98.51 90.79,98.98 90.91,99.1 91.16,99.1 91.28,98.98 91.28,98.51 91.4,98.39 91.64,98.39 91.76,98.51 91.76,98.98 91.88,99.1 92.11,99.1 92.23,98.98 92.23,98.51 92.35,98.39 92.59,98.39 92.71,98.51 92.71,98.98 92.83,99.1 93.07,99.1 93.19,98.98 93.19,98.51 93.31,98.39 93.55,98.39 93.67,98.51 93.67,98.98 93.79,99.1 94.02,99.1 94.14,98.98 94.14,98.51 94.26,98.39 94.5,98.39 94.62,98.51 94.62,98.98 94.74,99.1 94.98,99.1 95.1,98.98 95.1,98.51 95.22,98.39 95.49,98.39 95.61,98.51 95.61,98.81 95.73,98.93 96.02,98.93 96.13,98.81 96.13,98.51 96.25,98.39 103.84,98.39 104.55,99.1 105.98,99.1 110.74,94.34 111.13,94.34 111.56,93.91 111.86,93.91
  BOTTOM w0.076: UC1.AU71 116.96,90.72 116.96,91.42 115.34,93.03 v1(114.3,93.03)
  BOTTOM w0.112: v1(77.32,100.73) 77.83,100.73 78.09,100.99 JDIMM1.37
DDR_A_D11: length 58.5
  IN1 w0.114: 112.14,94.28 114.05,94.28 v1(114.18,94.41)
  IN1 w0.119: v1(75.79,100.73) 76.53,101.47 81.44,101.47 83.48,99.44 96.37,99.44 96.49,99.32 96.49,98.85 96.61,98.73 96.9,98.73 97.02,98.85 97.02,99.32 97.14,99.44 97.43,99.44 97.54,99.32 97.54,98.85 97.66,98.73 97.95,98.73 98.07,98.85 98.07,99.32 98.19,99.44 98.55,99.44 98.67,99.31 98.67,98.85 98.8,98.73 103.7,98.73 104.41,99.44 106.12,99.44 110.86,94.7 111.29,94.7 111.7,94.28 112.14,94.28
  BOTTOM w0.076: UC1.AU68 117.43,88.66 117.86,88.68 117.98,88.8 118.06,88.94 118.06,89.02 118.03,89.1 117.97,89.25 117.97,89.33 117.99,89.73 117.94,89.89 117.94,90.03 118,90.25 118,90.37 117.97,90.45 117.95,90.48 117.95,90.9 118.13,91.08 118.13,91.53 117.75,91.91 117.51,91.91 117.04,92.37 117.04,93.66 115.96,94.75 v2(115.5,94.75) 114.52,94.75 v1(114.18,94.41)
  BOTTOM w0.112: JDIMM1.41 79.15,99.99 76.54,99.99 v1(75.79,100.73)
DDR_A_D12: length 56.6
  IN1 w0.114: 115.64,97.23 117.61,95.26 117.61,93.6 v1(117.62,93.6)
  IN1 w0.119: v1(74.08,103.34) 75.02,104.28 80.87,104.28 81.29,103.86 82.14,103.86 84.59,101.42 106.94,101.42 107.14,101.22 111.13,97.23 115.64,97.23
  BOTTOM w0.076: v1(117.62,93.6) 117.96,93.25 117.96,92.43 118.48,91.92 118.48,90.72 UC1.AR71
  BOTTOM w0.112: JDIMM1.24 70.95,104.24 73.88,104.24 74.08,104.04 v1(74.08,103.34)
DDR_A_D13: length 58
  IN1 w0.114: 115.42,97.56 115.71,97.56 117.99,95.27 117.99,92.7 v1(117.62,92.33)
  IN1 w0.119: v1(72.56,103.34) 72.97,103.75 74.02,103.75 74.88,104.62 81.01,104.62 81.43,104.2 82.28,104.2 84.73,101.75 107.08,101.75 107.47,101.36 111.27,97.56 115.41,97.56 115.42,97.56
  BOTTOM w0.076: UC1.AR69 118.18,89.68 118.11,89.89 118.11,90.03 118.17,90.26 118.17,90.36 118.18,90.36 118.17,90.37 118.17,90.39 118.12,90.51 118.12,90.78 118.32,90.98 118.32,91.64 117.63,92.33 v1(117.62,92.33)
  BOTTOM w0.112: v1(72.56,103.34) 72.45,103.24 70.95,103.24 JDIMM1.28
DDR_A_D14: length 56.9
  IN1 w0.114: v1(115.15,92.2) 113.97,92.2 112.63,93.53 111.68,93.53
  IN1 w0.119: v1(74.27,100.72) 74.27,100.44 74.39,100.32 78.45,100.32 78.57,100.44 78.57,100.68 78.69,100.8 78.93,100.8 79.05,100.68 79.05,100.44 79.17,100.32 79.4,100.32 79.52,100.44 79.52,100.68 79.64,100.8 79.88,100.8 80,100.68 80,100.44 80.12,100.32 81.65,100.32 83.7,98.26 84.28,98.26 84.4,98.38 84.4,98.65 84.52,98.77 84.76,98.77 84.88,98.65 84.88,98.38 85,98.26 85.24,98.26 85.36,98.38 85.36,98.65 85.48,98.77 85.72,98.77 85.83,98.65 85.83,98.38 85.95,98.26 86.19,98.26 86.31,98.38 86.31,98.65 86.43,98.77 86.67,98.77 86.79,98.65 86.79,98.18 86.91,98.06 87.35,98.06 87.47,98.18 87.47,98.65 87.59,98.77 87.83,98.77 87.95,98.65 87.95,98.18 88.07,98.06 106.45,98.06 106.98,97.52 110.56,93.95 110.84,93.95 111.26,93.53 111.68,93.53
  BOTTOM w0.076: UC1.AU70 116.78,90.25 116.78,91.34 115.92,92.2 v1(115.15,92.2)
  BOTTOM w0.112: v1(74.27,100.72) 74.27,100.31 73.7,99.74 JDIMM1.42
DDR_A_D15: length 57
  IN1 w0.114: v1(115.56,91.67) 113.01,91.67 111.45,93.23 111.09,93.23
  IN1 w0.119: v1(72.75,100.73) 72.65,100.83 72.48,100.83 71.37,99.71 71.37,99.54 72.31,98.6 72.51,98.6 73.02,99.11 73.02,99.28 72.66,99.63 72.66,99.8 72.83,99.97 73,99.97 73.36,99.61 73.53,99.61 73.89,99.98 81.51,99.98 83.76,97.72 106.31,97.72 106.84,97.19 110.42,93.61 110.71,93.61 111.09,93.23
  BOTTOM w0.076: v1(115.56,91.67) 116.2,91.67 116.6,91.26 116.6,90.17 116.68,90.09 116.68,89.91 117.06,89.52 UC1.AU69
  BOTTOM w0.112: JDIMM1.38 70.96,100.73 v1(72.75,100.73)
DDR_A_D16: length 51.7
  IN1 w0.114: v1(111.67,91.91) 111.28,92.3 110.34,92.3
  IN1 w0.119: 110.34,92.3 109.46,92.3 109.25,92.5 109.25,93.09 106.48,95.86 103.14,95.86 103.02,95.98 103.02,96.41 102.9,96.53 102.66,96.53 102.54,96.41 102.54,95.98 102.42,95.86 102.18,95.86 102.06,95.98 102.06,96.41 101.94,96.53 101.71,96.53 101.59,96.41 101.59,95.98 101.47,95.86 101.23,95.86 101.11,95.98 101.11,96.41 100.99,96.53 83.21,96.53 80.96,98.77 77.94,98.77 77.87,98.7 76.4,98.7 v1(75.85,98.15)
  BOTTOM w0.076: v1(111.67,91.91) 111.67,91.11 111.89,90.88 111.89,89.32 112.19,89.02 112.19,87.81 113.03,86.97 113.82,86.97 UC1.BB65
  BOTTOM w0.112: v1(75.85,98.15) 76.69,98.99 JDIMM1.45
DDR_A_D17: length 52.9
  IN1 w0.114: v1(111.15,89.55) 112.4,89.55 112.52,89.67 112.52,90.53 111.67,91.37 111.51,91.37 111,90.86 110.84,90.86 110.68,91.03 110.68,91.19 111.19,91.7 111.19,91.86 110.97,92.07 110.1,92.07
  IN1 w0.119: v1(77.37,98.15) 77.54,97.98 78.5,97.98 78.96,98.44 80.83,98.44 83.07,96.19 100.2,96.19 100.87,95.53 106.34,95.53 108.87,92.99 108.87,92.21 109.02,92.07 110.1,92.07
  BOTTOM w0.076: UC1.AW65 115.87,86.15 115.68,85.97 115.08,85.97 115.05,85.93 114.81,85.93 114.65,85.99 114.51,85.99 114.29,85.92 114.17,85.92 114.06,85.97 113.68,85.97 113.55,85.84 113.29,85.84 111.59,87.54 111.59,88.81 111.15,89.24 v1(111.15,89.55)
  BOTTOM w0.112: v1(77.37,98.15) 77.79,98.15 77.95,97.99 79.15,97.99 JDIMM1.49
DDR_A_D18: length 54.2
  IN1 w0.114: v1(107.83,90.21) 107.83,90.61 106.2,92.24
  IN1 w0.119: 106.2,92.24 105.22,93.21 96.5,93.21 95.87,93.85 77.06,93.85 76.94,93.97 76.94,94.36 76.82,94.48 76.58,94.48 76.47,94.36 76.47,93.97 76.35,93.85 76.11,93.85 75.99,93.97 75.99,94.36 75.87,94.48 75.63,94.48 75.51,94.36 75.51,93.97 75.39,93.85 74.87,93.85 74.65,94.07 74.65,94.94 74.77,95.05 75.67,95.05 75.79,95.17 v1(75.79,95.48)
  BOTTOM w0.076: v1(107.83,90.21) v2(108.65,89.39) 109.19,88.85 110.33,88.85 110.92,88.26 110.92,87.12 112.93,85.11 114.57,85.11 114.8,85.33 114.93,85.34 115.06,85.34 115.19,85.32 115.35,85.32 115.36,85.33 115.36,85.33 115.67,85.64 UC1.AW63
  BOTTOM w0.112: JDIMM1.63 79.15,94.49 76.78,94.49 v1(75.79,95.48)
