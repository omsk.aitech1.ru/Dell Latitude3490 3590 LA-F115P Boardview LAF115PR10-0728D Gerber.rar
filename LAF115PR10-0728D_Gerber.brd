# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_PWR_SHR_EN_L#: length 38.5
  TOP w0.089: UU2.6 35.34,48.19 35.86,48.71 v2(35.86,50.12) RU26.2 36.2,51.43 36.66,50.97 v1(36.66,50.63) ; v1(37.45,72.92) 37.05,72.92 36.57,73.41 UE1.118
  IN3 w0.089: v1(32.8,74.28) 34.98,74.28 36.34,72.92 v1(37.45,72.92)
  BOTTOM w0.089: v1(36.66,50.63) 36.66,50.88 35.96,51.58 35.96,55.58 34,57.55 34,60.23 33.52,60.71 33.52,62.26 31.87,63.91 31.87,65.34 32.57,66.04 32.57,74.05 v1(32.8,74.28)
USBC_B2B_OVP: length 2.8
  TOP w0.089: PRS13.2 57.84,133.74 v2(58.14,134.03)
  TOP w0.254: PRS13.2 57.12,133.73 PQS03.5 PQS03.6
USBC_B2B_S1: length 5.6
  TOP w0.254: PRS42.1 49.21,122.97 49.17,122.93
  BOTTOM w0.089: v2(45.51,118.19) 45.17,118.54 45.17,120.3 v1(46.1,121.23)
USBC_B2B_S1_A: length 16.4
  TOP w0.254: v1(50.38,125.57) 50.32,125.63 PQS08.1 49.5,125.72 PRS12.2 ; PQS03.3 58.76,130.87 PRS14.1 PCS11.1 58.47,132.11 55.48,132.11 v2(55.3,131.94) 55.11,131.75 55.11,130.72 53.87,129.47 PQS04.2 v1(53.15,129.22)
  IN2 w0.254: v1(53.15,129.22) 53.15,128.64 50.38,125.88 v1(50.38,125.57)
USBC_B2B_S2: length 1.1
  TOP w0.089: v2(55.52,127.99) 55.91,128.38 56.42,128.38
USBC_B2B_S2_G: length 17.9
  TOP w0.089: v2(66.2,140.47) PRS09.2
  TOP w0.254: PQS02.4 65.2,139.61 PCS10.2 66.19,139.46 PRS09.2 66.79,138.87 66.79,138.01 66.57,137.79 66.57,136.95 v1(66.18,136.56) ; PQS06.1 61.45,130.26 PRS16.1 61.45,131.24 v1(61.83,131.62)
  IN2 w0.254: v1(61.83,131.62) 61.83,135.48 62.91,136.56 v1(66.18,136.56)
USBC_B2B_S3: length 3.6
  TOP w0.089: PRS18.1 61.1,126.5 v2(61.1,127.47)
  TOP w0.254: PQS07.2 62.96,126.76 62.43,126.22 PCS17.1 61.38,126.22 PRS18.1
USBC_SW_PROCHOT: length 9.8
  TOP w0.089: v2(61.22,123.03) 61.66,123.47 PRS28.2
  TOP w0.254: PCS20.1 62.7,118.49 62.7,119.17 62.54,119.32 62.54,120.38 62.86,120.7 62.86,122.88 62.32,123.42 PRS28.2 62.36,123.47 PCS19.1 63.37,124.06 PQS10.6
USBCOMP: length 2.3
  TOP w0.305: v1(125.86,53.12) 126.26,53.12 v2(126.36,53.02) 126.4,52.98 RC66.1
  BOTTOM w0.254: v1(125.86,53.12) 125.77,53.03 125.67,53.03 UC1.AB6
VCI_IN1: length 6.2
  TOP w0.102: RE70.1 33.93,66.78 34.17,67.03 34.17,68.66 v2(34.27,68.77) 34.35,68.84 34.35,69.62 34.94,70.21 UE1.126
VCIN0_PH: length 251.9
  TOP w0.089: RH1.1 124.66,44.13 124.66,43.3 C33.1 124.65,42.82 124.66,42.81 124.66,42.67 123.13,41.14 122.82,41.14 v1(122.4,41.57) ; R42.2 110.4,108.53 C32.1 110.49,108.62 R43.2 111.75,109.07 111.75,109.79 v1(111.73,109.82) ; RE37.2 37.9,88.95 38.26,89.31 38.54,89.31 38.76,89.53 v1(38.76,89.77) ; v1(74.75,31.4) 74.75,29.36 76.26,27.85 95.94,27.85 96.18,28.08 102.23,28.08 103.99,29.84 107.06,29.84 107.15,29.93 107.15,32.08 v1(106.78,32.44) ; v1(57.55,112.49) 56.45,112.49 55.09,111.13 55.09,106.15 54.36,105.43 54.36,95.83 v1(53.14,94.62) ; v1(88.88,112.58) 88.88,112.07 v2(88.65,111.84)
  IN1 w0.089: v1(38.76,89.77) 39,90.02 40.5,90.02 40.94,89.58 44.28,89.58 44.49,89.79 48.37,89.79 53.14,94.56 v1(53.14,94.62)
  IN2 w0.089: v1(111.73,109.82) 111.13,109.22 103.93,109.22 103.67,109.48 91.98,109.48 v1(88.88,112.58) ; v1(38.76,89.77) 38.76,89.53 37.39,88.16 37.39,86.26 38.57,85.08 38.57,84.46 38.57,83.52 39.24,82.86 39.24,79.04 39.46,78.81 39.46,77.96 43.91,73.51 43.91,68.58 44.46,68.03 46.18,68.03 47.55,66.66 47.55,62.97 47.83,62.69 47.83,61.76 47.61,61.54 47.61,53.82 47.07,53.27 47.07,48.53 47.08,48.52 47.08,47.71 46.67,47.3 46.67,44.41 49.37,41.71 49.37,40.59 52.99,36.97 56.64,36.97 61.42,32.19 65.92,32.19 66.52,31.59 70.95,31.59 71.33,31.21 74.56,31.21 v1(74.75,31.4)
  IN3 w0.089: v1(88.88,112.58) 87.41,111.11 77.7,111.11 75.94,112.86 73.38,112.86 72.34,111.82 63.53,111.82 63.23,112.12 59.84,112.12 59.47,112.49 v1(57.55,112.49) ; v1(122.4,41.57) 121.27,40.44 121.27,36.45 118.9,34.09 114.35,34.09 113.8,33.54 112.68,33.54 112.2,34.02 111.29,34.02 110.48,33.2 107.54,33.2 v1(106.78,32.44)
VCONN_MON_P1: length 2
  BOTTOM w0.254: TP89.1 34.21,119.45 34.64,119.88 UT1.19
VCREF0:
  vias: v2(47.46,65.91)
VD_IN1_C: length 191.9
  TOP w0.089: C32.2 111.57,106.54 113.84,106.54 120.52,99.86 131.09,99.86 134.54,96.4 137.03,96.4 137.04,96.38 140.49,96.38 142.07,97.96 v2(144.97,97.96) 147.71,97.96 v1(147.95,97.72) ; C33.2 123.74,43.27 123,43.27 R45.1 ; C33.2 123.74,43.3 123.73,43.31 123.73,44.16 RH1.2 ; C33.2 123.96,43.06 123.96,42.54 v1(122.98,41.55)
  IN1 w0.089: v1(155.45,98.67) 154.08,100.05 150.49,100.05 150.1,99.66 149.87,99.66 148.65,98.44 148.2,98.44 147.95,98.19 v1(147.95,97.72)
  IN2 w0.089: v1(122.38,36.14) 122.66,35.86 128.77,35.86 129.25,36.34 130.93,36.34 133.29,38.71 133.29,40.77 136.06,43.54 138.49,43.54 140.76,41.27 140.76,39.7 141.94,38.52 143.51,38.52 144.22,37.81 148.88,37.81 149.7,36.99 152.1,36.99 152.38,36.7 154.35,36.7 155.09,35.97 158.33,35.97 159.08,36.72 159.08,39.84 157.47,41.45 157.47,46.87 158.09,47.48 160.02,47.48 162.84,50.31 162.84,54.49 164.05,55.7 164.56,55.7 166.06,57.2 166.06,59.26 170.58,63.78 170.58,69.44 168.31,71.71 168.31,81.46 166.18,83.59 166.18,88.59 167.14,89.56 167.14,92.85 164.41,95.58 160.86,95.58 158.94,93.66 158.16,93.66 157.59,94.23 156.49,94.23 155.06,95.65 155.06,96.2 155.49,96.63 155.49,98.63 v1(155.45,98.67)
  IN3 w0.089: v1(122.38,36.14) 121.72,36.8 121.72,39.48 122.11,39.86 122.11,40.68 v1(122.98,41.55)
VGA_CBL_DET#: length 126.4
  TOP w0.089: v1(222.5,39.52) 222.79,39.52 223.25,39.06 223.25,36.74 222.26,35.75 JVGA.7 216.53,35.75 216.28,35.49 216.28,32.81 RC207.1 ; v1(132.93,44.31) v2(132.19,44.31)
  IN2 w0.089: v1(132.93,44.31) 132.93,45.22 133.71,46.01 138.57,46.01 139.61,44.97 139.61,44.02 142.85,40.79 143.14,40.79 143.95,39.98 146.54,39.98 147.69,38.83 151.11,38.83 152.65,37.29 154.35,37.29 v1(154.71,37.65)
  IN3 w0.089: v1(154.71,37.65) 154.71,36.7 155.71,35.7 159.98,35.7 160.75,36.47 164.18,36.47 164.72,37 169.13,37 169.81,36.32 176.46,36.32 177.22,37.09 178.04,37.09 178.3,37.36 179.83,37.36 180.83,38.35 186.64,38.35 187.29,37.7 195.5,37.7 195.92,37.28 210.3,37.28 210.56,37.55 214.87,37.55 215.45,38.13 216.87,38.13 217.79,39.05 222.03,39.05 v1(222.5,39.52)
  BOTTOM w0.076: UC1.U4 128.02,51.65 128.02,51.04 127.95,50.96 127.59,50.96 127.48,50.85 127.48,50.75 127.48,50.74 127.48,50.54 127.48,50.54 127.48,50.49 127.52,50.45 127.52,50.18 127.48,50.15 127.48,50.1 127.48,50.09 127.48,49.58 127.97,49.08 129.5,49.08 129.9,48.68
  BOTTOM w0.089: v1(132.93,44.31) 132.93,44.61 132.5,45.04 132.5,47.11 131.31,48.3 130.28,48.3 129.9,48.68
VGA_DP2_N0: length 269.3
  TOP w0.112: JVGA.3 218.35,37.75 218.49,37.89 218.65,37.89 219.12,37.42 219.82,37.42 v1(219.85,37.4) ; v1(41.03,102.36) 41.93,102.36 v4(42.29,102.71) 42.52,102.95 42.52,104.13 42.43,104.22 42.43,104.54 42.34,104.63 UT5.49
  IN3 w0.135: v1(43.8,54.69) 43.8,54.68 43.95,54.84 44.14,54.84 44.29,54.68 44.29,48.24 45.81,46.73 45.81,42.26 49.79,38.27 50.48,38.27 52.68,36.07 55.41,36.07 57.79,33.69 58.04,33.69 59.78,31.95 65.5,31.95 67.03,30.42 72.49,30.42 75.29,27.62 92.37,27.62 94.01,29.27 95.68,29.27 96.61,28.34 98.86,28.34 99.11,28.09 107.3,28.09 107.78,27.6 111.56,27.6 112.74,28.78 117.99,28.78 117.99,28.79 118.88,28.79 119.25,28.42 128.71,28.42 130.08,29.79 130.6,29.79 132.62,31.8 132.62,32.98 133.88,34.25 142.45,34.25 145.99,30.7 149.4,30.7 150.2,31.5 152.64,31.5 152.88,31.74 164.06,31.74 165.53,33.21 166.94,33.21 167.37,33.64 177.66,33.64 179.14,35.12 183.67,35.12 183.79,35 190.4,35 190.92,34.49 192.05,34.49 192.22,34.67 192.4,34.67 193.2,35.47 194.01,35.47 194.55,34.93 201.51,34.93 201.8,35.23 206.27,35.23 206.83,34.67 207.53,34.67 208.19,34 209.34,34 209.78,34.43 209.78,35.38 211.15,36.75 215.13,36.75 215.6,37.22 217.48,37.22 217.83,37.56 219.19,37.56 219.22,37.52 219.72,37.52 v1(219.85,37.4)
  BOTTOM w0.112: v1(43.8,54.69) 43.8,54.68 43.6,54.88 43,54.88 42.66,55.22 42.66,57.07 41.84,57.89 41.27,57.89 40.82,58.33 39.78,58.33 38.8,59.31 38.8,60.03 37.48,61.35 37.27,61.35 35.88,62.73 35.88,63.39 34.19,65.08 34.19,69.71 35.56,71.08 35.56,79.33 35.16,79.73 35.16,81.73 36.93,83.5 36.93,84.69 36.55,85.07 36.55,89.4 36.94,89.8 36.94,91.29 37.54,91.88 37.54,95.43 38.26,96.15 38.26,100.61 39.8,102.15 40.82,102.15 v1(41.03,102.36)
VGA_DP2_N1: length 279.9
  TOP w0.112: UT5.46 41.14,104.56 41.32,104.38 41.32,103.56 38.83,101.07 38.83,100.38 38.6,100.15 38.1,100.15 38.01,100.25 38.01,100.5 37.91,100.6 v1(37.68,100.6) ; JVGA.6 218.35,36.25 218.49,36.39 219.21,36.39 219.47,36.65 220.21,36.65 220.92,37.35 221.16,37.35 221.3,37.22 221.3,37.11 v1(220.94,36.75)
  IN1 w0.119: v1(37.09,53.72) 36.72,54.08 36.59,54.08 36.57,54.09 36.49,54.09 36.26,54.32 36.26,56.89 35.85,57.31 35.85,58.14 35.27,58.72 35.27,59.6 33.63,61.23 33.63,62.22 32.95,62.9 30.32,62.9 29.41,63.81 29.41,66.88 29.17,67.12 29.17,72.22 29.66,72.71 29.66,77.04 29.83,77.2 29.83,85.2 30.87,86.24 30.87,87.41 30.04,88.23 30.04,91.22 36.18,97.36 36.18,99.57 36.77,100.16 37.23,100.16 37.33,100.26 37.33,100.53 37.41,100.6 v1(37.68,100.6)
  IN3 w0.135: v1(220.94,36.75) 220.94,36.71 221.26,36.39 221.26,36.23 221.08,36.05 212.26,36.05 209.76,33.56 208,33.56 207.49,34.07 206.8,34.07 206.12,34.76 204.35,34.76 203.91,34.31 194.52,34.31 193.85,34.98 193.34,34.98 192.58,34.23 192.43,34.23 192.1,33.9 189.12,33.9 188.88,34.15 182.29,34.15 181.76,34.68 179.32,34.68 177.81,33.17 169.3,33.17 168.13,32 164.94,32 164.25,31.3 153.16,31.3 152.91,31.05 150.36,31.05 149.58,30.26 145.81,30.26 142.26,33.81 134.14,33.81 133.06,32.73 133.06,31.62 130.69,29.26 130.21,29.26 128.5,27.55 117.81,27.55 117.01,28.34 112.92,28.34 111.74,27.16 107.6,27.16 107.12,27.64 98.93,27.64 98.67,27.9 93.37,27.9 92.65,27.18 75.03,27.18 72.23,29.99 66.84,29.99 65.32,31.51 59.6,31.51 57.85,33.26 57.55,33.26 55.18,35.63 52.34,35.63 50.14,37.83 49.61,37.83 45.37,42.07 45.37,46.54 39.89,52.03 37,52.03 36.55,52.48 36.55,53.81 36.69,53.95 36.86,53.95 v1(37.09,53.72)
VGA_DP2_P0: length 269.3
  TOP w0.112: v1(219.85,37.98) 219.51,37.64 219.21,37.64 218.75,38.11 218.49,38.11 218.35,38.25 JVGA.2 ; v1(41.03,101.77) 41.39,102.14 42.02,102.14 42.25,102.36 42.26,102.36 42.64,102.74 42.64,102.75 42.74,102.86 42.74,104.22 42.65,104.32 42.65,104.58 42.74,104.68 UT5.50
  IN3 w0.135: v1(219.85,37.98) 219.63,37.77 219.32,37.77 219.29,37.8 217.72,37.8 217.38,37.46 215.5,37.46 215.03,36.99 211.05,36.99 209.54,35.48 209.54,34.53 209.24,34.24 208.29,34.24 207.63,34.91 206.93,34.91 206.37,35.47 201.7,35.47 201.41,35.17 194.65,35.17 194.11,35.71 193.1,35.71 192.3,34.91 192.12,34.91 191.95,34.73 191.02,34.73 190.5,35.24 183.89,35.24 183.77,35.36 179.04,35.36 177.56,33.88 167.27,33.88 166.84,33.45 165.43,33.45 163.96,31.99 152.78,31.99 152.54,31.75 150.1,31.75 149.3,30.95 146.09,30.95 142.55,34.49 133.78,34.49 132.38,33.09 132.38,31.9 130.5,30.03 129.98,30.03 128.61,28.66 119.35,28.66 118.98,29.03 117.89,29.03 117.89,29.02 112.64,29.02 111.46,27.85 107.88,27.85 107.4,28.33 99.21,28.33 98.96,28.58 96.71,28.58 95.78,29.51 93.91,29.51 92.27,27.86 75.39,27.86 72.59,30.67 67.13,30.67 65.6,32.19 59.88,32.19 58.14,33.94 57.89,33.94 55.51,36.31 52.78,36.31 50.58,38.51 49.89,38.51 46.05,42.36 46.05,46.83 44.53,48.34 44.53,54.78 44.24,55.08 43.99,55.08 43.8,55.27 v1(43.8,55.27)
  BOTTOM w0.112: v1(43.8,55.27) 43.8,55.27 43.63,55.1 43.1,55.1 42.88,55.31 42.88,57.16 41.93,58.11 41.36,58.11 40.91,58.56 39.87,58.56 39.02,59.4 39.02,60.12 37.57,61.57 37.36,61.57 36.1,62.83 36.1,63.48 34.41,65.18 34.41,69.62 35.78,70.99 35.78,79.42 35.38,79.82 35.38,81.64 37.15,83.41 37.15,84.78 36.77,85.16 36.77,89.31 37.16,89.71 37.16,91.2 37.76,91.79 37.76,95.33 38.48,96.05 38.48,100.52 39.89,101.93 40.88,101.93 v1(41.03,101.77)
VGA_DP2_P1: length 279.8
  TOP w0.112: UT5.47 41.54,103.46 39.05,100.98 39.05,100.29 38.69,99.93 v1(37.66,99.93) ; v1(221.52,36.75) 221.52,37.31 221.26,37.57 220.83,37.57 220.12,36.87 219.37,36.87 219.11,36.61 218.49,36.61 218.35,36.75 JVGA.5
  IN1 w0.119: v1(37.66,99.93) 36.85,99.93 36.39,99.47 36.39,97.27 30.26,91.13 30.26,88.32 31.09,87.5 31.09,86.15 30.04,85.11 30.04,77.11 29.88,76.94 29.88,72.62 29.39,72.13 29.39,67.21 29.63,66.98 29.63,63.9 30.41,63.12 33.04,63.12 33.85,62.31 33.85,61.32 35.48,59.69 35.48,58.81 36.06,58.23 36.06,57.4 36.48,56.98 36.48,54.41 36.58,54.31 v1(37.09,54.31)
  IN3 w0.135: v1(221.52,36.75) 221.5,36.72 221.5,36.13 221.18,35.81 212.36,35.81 209.86,33.32 207.9,33.32 207.39,33.83 206.7,33.83 206.02,34.51 204.45,34.51 204.01,34.07 194.42,34.07 193.75,34.74 193.44,34.74 192.68,33.99 192.53,33.99 192.2,33.66 189.02,33.66 188.78,33.9 182.19,33.9 181.66,34.44 179.42,34.44 177.91,32.93 169.4,32.93 168.23,31.76 165.04,31.76 164.35,31.06 153.26,31.06 153.01,30.81 150.46,30.81 149.68,30.02 145.71,30.02 142.16,33.57 134.24,33.57 133.3,32.63 133.3,31.52 130.79,29.01 130.31,29.01 128.61,27.31 117.71,27.31 116.91,28.1 113.02,28.1 111.84,26.92 107.5,26.92 107.02,27.4 98.83,27.4 98.57,27.66 93.47,27.66 92.75,26.94 74.93,26.94 72.13,29.74 66.74,29.74 65.22,31.27 59.5,31.27 57.75,33.01 57.45,33.01 55.08,35.39 52.24,35.39 50.04,37.59 49.51,37.59 45.13,41.97 45.13,46.44 39.79,51.79 36.9,51.79 36.31,52.38 36.31,53.91 36.69,54.29 37.07,54.29 v1(37.09,54.31)
VGA_DP_AUXN: length 279.8
  TOP w0.112: JVGA.9 218.2,34.75 218.34,34.89 218.41,34.89 218.47,34.83 218.47,34.23 218.68,34.02 219.11,34.02 219.24,34.15 219.46,34.15 v1(219.5,34.11) ; v1(31.98,101.65) 31.99,101.65 31.85,101.51 30.54,101.51 v4(29.85,102.2) 29.29,102.75 29.29,104.96 RT93.2 29.27,105.93 29.27,106.27 30.33,107.33 33,107.33 33.36,106.97 UT5.27
  IN1 w0.119: v1(31.98,101.65) 31.99,101.65 31.81,101.47 31.46,101.47 31.07,101.08 31.07,93.29 29.4,91.62 29.4,87.48 29.17,87.25 29.17,77.48 29.01,77.33 29.01,72.99 28.52,72.5 28.52,66.86 28.75,66.63 28.75,63.57 30.05,62.26 32.68,62.26 32.99,61.95 32.99,60.97 34.25,59.71 34.25,58 34.89,57.36 34.89,54.18 35.15,53.92 35.31,53.92 35.54,53.69 v1(35.54,53.69)
  IN3 w0.135: v1(219.5,34.11) 219.51,34.41 219.71,34.6 219.71,34.97 219.43,35.25 218.18,35.25 217.84,34.91 212.08,34.91 209.98,32.81 204.78,32.81 204.05,33.55 192.71,33.55 192.33,33.17 186.05,33.17 185.76,33.46 181.99,33.46 181.45,34 179.6,34 178.07,32.47 174.35,32.47 173.12,31.24 166.53,31.24 165.22,29.92 150.36,29.92 150.02,29.58 145.52,29.58 141.98,33.13 135.53,33.13 130.91,28.51 130.91,28.14 129.64,26.87 117.52,26.87 116.73,27.66 113.21,27.66 112.01,26.46 98.32,26.46 97.56,27.22 93.65,27.22 92.93,26.5 74.75,26.5 72.81,28.44 66.38,28.44 63.99,30.83 59.32,30.83 57.57,32.57 57.27,32.57 54.89,34.95 51.87,34.95 49.67,37.15 49.33,37.15 44.69,41.79 44.69,42.88 43.66,43.91 43.66,44.95 43.93,45.22 43.93,47.02 39.63,51.32 36.75,51.32 35.08,52.99 35.08,53.64 35.24,53.8 35.43,53.8 v1(35.54,53.69)
VGA_DP_AUXP: length 279.9
  TOP w0.112: v1(219.1,34.54) 219.1,34.39 218.95,34.24 218.77,34.24 218.69,34.32 218.69,34.92 218.5,35.11 218.25,35.11 218.11,35.25 JVGA.8 ; UT5.26 33.99,107.37 33.81,107.19 33.45,107.19 33.09,107.55 30.24,107.55 29.05,106.36 29.05,105.87 RT98.2 29.07,104.97 29.07,102.66 29.47,102.26 29.47,102.24 29.95,101.77 29.96,101.77 30.44,101.29 31.76,101.29 31.99,101.06 v1(31.98,101.06)
  IN1 w0.119: v1(31.98,101.06) 31.99,101.06 31.8,101.25 31.56,101.25 31.29,100.99 31.29,93.2 29.61,91.52 29.61,87.39 29.38,87.16 29.38,77.39 29.23,77.24 29.23,72.9 28.74,72.41 28.74,66.95 28.96,66.72 28.96,63.66 30.14,62.48 32.77,62.48 33.21,62.04 33.21,61.06 34.47,59.8 34.47,58.1 35.11,57.45 35.11,54.27 35.24,54.14 35.41,54.14 v1(35.54,54.27)
  IN3 w0.135: v1(219.1,34.54) 219.29,34.54 219.47,34.7 219.47,34.87 219.33,35 218.28,35 217.94,34.67 212.18,34.67 210.08,32.57 204.68,32.57 203.95,33.31 192.81,33.31 192.43,32.93 185.95,32.93 185.66,33.22 181.89,33.22 181.35,33.76 179.7,33.76 178.17,32.23 174.45,32.23 173.22,31 166.63,31 165.32,29.68 150.46,29.68 150.12,29.34 145.42,29.34 141.88,32.89 135.63,32.89 131.15,28.41 131.15,28.04 129.74,26.63 117.42,26.63 116.63,27.42 113.31,27.42 112.11,26.22 98.22,26.22 97.46,26.98 93.75,26.98 93.03,26.26 74.65,26.26 72.71,28.2 66.28,28.2 63.89,30.59 59.22,30.59 57.47,32.33 57.17,32.33 54.79,34.71 51.77,34.71 49.57,36.91 49.23,36.91 44.45,41.69 44.45,42.78 43.42,43.81 43.42,45.06 43.68,45.32 43.68,46.92 39.53,51.07 36.65,51.07 34.84,52.89 34.84,53.74 35.14,54.04 35.32,54.04 v1(35.54,54.27)
VGA_DP_HPD: length 270.1
  TOP w0.089: JVGA.13 218.43,32.75 218.59,32.6 v1(218.59,32.2)
  TOP w0.102: v1(42.02,104.25) 41.94,104.34 UT5.48
  IN2 w0.089: v1(218.59,32.2) 218.23,32.56 215.98,32.56 215.18,31.76 215.18,30.23 214.85,29.9 213.74,29.9 213.39,30.25 183.79,30.25 183.37,30.67 181.74,30.67 179.38,28.32 175.18,28.32 174.63,27.77 169.85,27.77 169.57,27.49 166.67,27.49 165.65,28.51 163.78,28.51 162.94,27.68 156.1,27.68 155.93,27.86 148.19,27.86 145.2,30.85 144.37,30.85 143.44,31.78 138.91,31.78 136.67,29.54 129.87,29.54 129.72,29.69 119.06,29.69 117.96,28.58 114.25,28.58 113.29,27.62 105.04,27.62 104.27,26.85 99.64,26.85 99.06,26.28 97.78,26.28 97.22,26.84 94.61,26.84 94.12,26.36 76.18,26.36 75.44,27.1 60.19,27.1 59.2,28.09 59.2,30.15 57.32,32.03 57.03,32.03 54.82,34.24 51.7,34.24 44.99,40.94 44.99,42.22 43.29,43.93 43.29,45.04 43.74,45.49 43.74,53.81 44.48,54.54 44.84,54.91 44.84,59.42 42.28,61.98 41.3,61.98 40.61,62.66 40.61,64.96 v1(40.72,65.07)
  IN3 w0.089: v1(42.02,104.25) 42.11,104.16 46.02,104.16 46.38,103.81 46.38,103.11 47.13,102.35 47.13,97.01 46.41,96.29 46.41,92.63 45.36,91.58 44.91,91.58 43.66,90.33 43.66,87.8 39.43,83.58 39.43,77.86 41.05,76.25 41.05,73.62 40.24,72.81 40.24,68.47 40.62,68.09 40.62,65.17 v1(40.72,65.07)
  BOTTOM w0.089: v1(218.59,32.2) 217.18,32.2 v2(216.81,31.83)
VGA_SMB_CK3: length 7
  TOP w0.102: v1(122.63,125.56) 122.83,125.37 122.83,125.36 122.83,125.36 122.83,125.06 123.15,124.74 123.15,123.62 v2(123.01,123.48) 123.01,122.19
  TOP w0.112: RV6.2 123.48,120.59 123.66,120.77 QV1.1 123.66,120.89 122.97,121.58 122.97,122.12 123.01,122.16 123.01,122.19
  BOTTOM w0.102: UV1.U7 122.87,125.8 v1(122.63,125.56)
VGA_SMB_DA3: length 6.4
  TOP w0.102: 124.02,124.19 124.31,124.48 v2(124.42,124.48) 124.57,124.48 124.86,124.19 RV5.2 124.96,123.43 ; 123.06,125.46 123.06,125.15 123.38,124.84 123.38,124.39 123.58,124.19
  TOP w0.112: v1(122.63,126.24) 123.06,125.82 123.06,125.46 ; 124.96,123.43 QV1.4 ; 124.02,124.19 123.58,124.19
  BOTTOM w0.102: v1(122.63,126.24) 122.79,126.24 UV1.U8
VIDALERT_N: length 53.6
  TOP w0.112: PRZ41.2 176.97,62.23 v1(176.97,62.68) 176.97,62.87 v2(176.67,63.18)
  IN1 w0.119: v1(141.38,85.89) 141.48,85.89 146.52,80.85 149.13,80.85 152.37,77.61 157.13,77.61 158.5,76.24 159.12,75.62 159.35,75.39 165.45,75.39 170.27,70.57 170.27,69.49 170.62,69.14 170.62,68.02 172.23,66.41 172.23,62.49 172.91,61.8 176.57,61.8 176.97,62.2 v1(176.97,62.68)
  BOTTOM w0.112: RC153.2 v1(141.38,85.89) 142.22,85.89 RC152.2 ; PRZ47.2 176.71,62.42 v1(176.97,62.68)
VIDSCLK: length 57.8
  TOP w0.112: v1(177.73,62.68) 177.73,62.36 PRZ40.2
  IN1 w0.119: v1(177.73,62.68) 177.73,62.08 176.94,61.3 172.71,61.3 171.73,62.28 171.73,66.21 170.12,67.81 170.12,68.93 169.77,69.28 169.77,70.36 165.29,74.84 159.19,74.84 159.14,74.89 158.92,75.12 158.91,75.12 158,76.04 156.92,77.11 152.17,77.11 148.92,80.35 146.26,80.35 v1(141.39,85.23)
  BOTTOM w0.089: 138.94,85.44 138.28,85.44 137.91,85.81 136.63,85.81 UC1.A63
  BOTTOM w0.112: v1(177.73,62.68) 177.49,62.44 PRZ46.2 ; v1(141.39,85.23) 141.37,85.24 139.15,85.24 138.94,85.44
VIDSOUT: length 57.8
  TOP w0.112: v1(176.12,62.71) 176.28,62.55 PRZ42.2
  IN1 w0.119: v1(176.12,62.71) 175.71,62.3 173.12,62.3 172.73,62.69 172.73,66.62 171.12,68.23 171.12,69.35 170.77,69.7 170.77,70.78 165.5,76.05 159.4,76.05 159.33,76.12 159,76.45 157.34,78.11 152.58,78.11 149.34,81.35 146.78,81.35 141.58,86.55 v1(141.38,86.55)
  BOTTOM w0.076: UC1.D64 135.42,86 135.48,85.98 135.7,85.98 135.88,86.15 137.77,86.15 137.78,86.16
  BOTTOM w0.102: 137.78,86.16 138.95,86.16 139.18,86.39
  BOTTOM w0.112: v1(176.12,62.71) 175.92,62.51 PRZ48.2 ; 139.18,86.39 139.35,86.55 v1(141.38,86.55) 141.73,86.9 RC154.2
VL: length 3.4
  TOP w0.089: v2(24.95,96.87) 24.63,96.56 PC515.1
  TOP w0.508: PC515.1 24.63,95.6 24.29,95.26 v1(24.29,94.75)
  BOTTOM w0.254: PU501.15 24.66,95.11 v1(24.29,94.75)
VR_CAP: length 4.5
  TOP w0.089: TP44.1 42.82,64.6 CE24.1
  TOP w0.102: UE1.18 44.15,66.81 43.54,66.2 CE24.1
VR_HOTL#: length 2.4
  BOTTOM w0.203: PRZ49.1 175.43,60.84 v2(175.43,60.08) 175.43,59.84 175.63,59.64 PUZ01.31
VRALERT#: length 8.7
  TOP w0.089: v2(119.45,49.32) 119.67,49.32 120.95,50.6 120.95,51.03 RC92.1 121.37,51.52 121.37,54.74 121.24,54.86 121.24,55.82 120.9,56.17 v1(120.77,56.17)
  BOTTOM w0.076: UC1.AM11 120.63,56.31 v1(120.77,56.17)
VRAM_ID1: length 22.9
  TOP w0.089: v1(118.64,54.02) 118.7,53.96 118.7,52.75 118.54,52.6 118.54,52.45 118.19,52.1 117.69,52.1 117.25,51.66 117.25,50.43 v2(116.81,50) 116.71,49.89 114.71,49.89 114.03,49.21 112.06,49.21 111.53,48.68
  TOP w0.102: 111.53,48.68 111.5,48.64 111.5,47 110.53,46.03 110,46.03 108.51,44.54 108.51,43.86 107.74,43.1 107.48,43.1 106.66,42.28 106.66,42.17 105.87,41.38 RC59.2 105.36,41.25 RC60.1
  BOTTOM w0.089: v1(118.64,54.02) 118.64,54.14 UC1.AP8
VRAM_ID2: length 21
  IN2 w0.089: v1(134.43,44.21) 134.19,44.21 133.46,43.48 133.46,42.79 133.05,42.38 129.63,42.38 128.16,43.85 127.87,43.85 v1(127.74,43.72)
  BOTTOM w0.076: 131.7,48.71 131.53,48.88 130.47,48.88 129.31,50.04 129.31,50.07 129.31,50.14 129.12,50.33 128.84,50.33 128.53,50.64 UC1.U2
  BOTTOM w0.089: 131.7,48.71 131.85,48.56
  BOTTOM w0.102: 131.85,48.56 133.09,47.32 133.09,45.49 134.35,44.23 134.42,44.23 v1(134.43,44.21) ; RC61.2 RC62.1 128.07,44.05 v1(127.74,43.72)
VRMP_CPU: length 3.5
  BOTTOM w0.203: PUZ01.12 173.23,52.5 172.99,52.27 172.99,52.27 172.47,51.74 v2(172.47,51.6) PCZ23.1 171.6,50.54 PRZ35.2
VSA_SEN+: length 70.8
  TOP w0.203: v1(151.27,57.77) 151.27,58.16 150.56,58.86 147.46,58.86 147.05,58.46 RC159.2
  TOP w0.254: v1(182.33,58.12) v2(183.28,58.12) 183.82,58.12 184.64,57.3 184.64,54.09 183.85,53.3 182.67,53.3 PRZ03.1 ; v1(132.23,61.34) 132.23,61.38 132.67,61.83 135.75,61.83 136.64,60.94 143.21,60.94 144.53,59.62 145.49,59.62 145.78,59.91 146.33,59.91 146.59,59.66 RC159.2
  IN3 w0.203: v1(182.33,58.12) 182.65,57.81 182.65,57.29 182.08,56.71 178.99,56.71 178.58,56.31 178.58,53.18 178.12,52.72 172.22,52.72 171.98,52.47 169.01,52.47 167.36,54.12 166.55,54.12 165.13,55.54 159.86,55.54 159.65,55.33 158,55.33 157.75,55.08 153.8,55.08 153.34,55.54 152.91,55.54 151.47,56.98 151.47,57.56 v1(151.27,57.77)
  BOTTOM w0.254: v1(132.23,61.34) 132.23,61.24 UC1.H20
VSA_SEN-: length 68.1
  TOP w0.203: 147.55,59.19 150.66,59.19 151.85,58 v1(151.85,57.77)
  TOP w0.254: PRZ07.1 183.18,53.68 183.74,53.68 184.26,54.2 v2(184.26,56.87) 184.26,57.15 183.93,57.48 v1(182.18,57.48) ; v1(132.19,62.25) 132.59,62.65 132.6,62.65 132.66,62.72 134.3,62.72 134.81,62.21 135.86,62.21 136.76,61.3 144.28,61.3 RC160.1 144.44,60.22 144.69,59.97 145.34,59.97 145.63,60.26 146.48,60.26 147.55,59.19
  IN3 w0.203: v1(151.85,57.77) 151.77,57.68 151.77,57.11 153.04,55.84 153.47,55.84 153.93,55.38 157.63,55.38 157.88,55.63 159.52,55.63 159.74,55.84 165.35,55.84 166.75,54.44 167.47,54.44 169.14,52.77 171.85,52.77 172.1,53.01 177.97,53.01 178.28,53.33 178.28,56.43 178.87,57.01 181.2,57.01 181.67,57.48 v1(182.18,57.48)
  BOTTOM w0.254: UC1.H21 132.19,62.12 v1(132.19,62.25)
VSN_1A_CPU: length 6.5
  BOTTOM w0.089: v2(169.43,60.89) 168.8,60.27 168.8,59.39 PRZ52.1
  BOTTOM w0.203: PUZ01.25 173.03,59.15 170.37,59.15 PCZ28.1 PRZ52.1
VSN_1A_CPU_R: length 4.8
  TOP w0.254: v1(170.8,59.8) 171.02,59.58 171.34,59.58 v2(171.4,59.64) 171.47,59.72 171.47,60.23 171.53,60.29 PCZ29.1 171.53,61.89 PRZ53.1
  BOTTOM w0.254: PRZ52.2 PCZ28.2 170.75,59.85 v1(170.8,59.8)
VSN_1B_CPU: length 3.8
  TOP w0.089: v2(180.34,54.81) 180.22,54.92 v1(179.76,54.92)
  BOTTOM w0.203: v1(179.76,54.92) 179.57,54.92 179.2,55.3 PUZ01.44
  BOTTOM w0.254: PCZ07.2 180.49,54.61 PRZ08.2 179.89,54.92 v1(179.76,54.92)
VSN_2PH_CPU: length 6.1
  TOP w0.089: v2(182.46,51.34) 182.33,51.34 181.27,52.4 PCZ11.2
  TOP w0.254: PCZ11.2 PRZ19.2 179.76,51.8 v1(179.65,51.8)
  BOTTOM w0.203: v1(179.65,51.8) 179.56,51.8 178.91,52.45 178.91,53.51 178.73,53.7 PUZ01.48
VSN_2PH_CPU_R: length 4.8
  TOP w0.254: v1(180.58,49.87) 181.21,50.5 181.26,50.5 v2(181.27,50.52) PCZ11.1 PRZ19.1
  BOTTOM w0.254: v1(180.58,49.87) 180.41,50.04 PCZ10.2 181.13,50.8 PRZ18.2
VSNN_1B_CPU_R: length 6.1
  TOP w0.089: v2(183.55,54.06) 183.17,54.44 v1(183.16,54.44)
  TOP w0.254: PRZ07.2 181.45,54.89 181.66,55.1 182.89,55.1 183.16,54.83 v1(183.16,54.44)
  BOTTOM w0.254: v1(183.16,54.44) 183.14,54.46 PCZ06.2 181.27,54.46 PRZ08.1 181.26,55.24 PCZ07.1
VSP_1A_CPU: length 4.1
  TOP w0.254: v1(171.83,58.72) 171.63,58.52 v2(170.79,58.52) 170.39,58.52 PCZ35.2 169.8,59.11 PRZ58.2
  BOTTOM w0.203: v1(171.83,58.72) 171.83,58.35 172.09,58.1 PUZ01.24
VSP_1A_CPU_R: length 5
  TOP w0.089: PRZ59.2 168.91,62.01 v2(168.79,61.88) ; v2(167.9,60.76) PRZ61.1
  TOP w0.254: PRZ58.1 170.54,60.76 PCZ29.2 ; PRZ58.1 PRZ61.1 ; PRZ58.1 PRZ59.2
VSP_1B_CPU: length 6.1
  TOP w0.089: v1(179.66,53.04) 179.28,53.04 v2(178.93,53.4)
  IN1 w0.254: v1(179.74,54.34) 179.48,54.34 179.13,53.99 179.13,53.38 179.46,53.04 v1(179.66,53.04)
  BOTTOM w0.203: PUZ01.45 178.9,54.9 179.25,54.55 179.54,54.55 179.74,54.35 v1(179.74,54.34)
  BOTTOM w0.254: PCZ04.2 PRZ04.2 179.99,52.72 v1(179.66,53.04)
VSP_2PH_CPU: length 5.1
  TOP w0.089: v1(179.64,52.41) 179.32,52.41 v2(178.95,52.04)
  BOTTOM w0.203: PCZ10.1 180.41,51.74 179.74,52.41 v1(179.64,52.41) 179.23,52.81 179.23,53.72 178.85,54.1 PUZ01.47
  BOTTOM w0.254: PCZ10.1 181.22,51.72 PRZ14.2
VSPP_1B_CPU_R: length 5.1
  TOP w0.254: v1(182.74,52.38) 182.51,52.38 v2(182.23,52.66) 181.45,53.44 PRZ03.2
  BOTTOM w0.254: PRZ04.1 PCZ04.1 182.02,53.61 PCZ06.1 182.08,53.04 v1(182.74,52.38)
VSUM+_VGA: length 14.2
  TOP w0.203: PUV01.14 73.58,126.31 73.54,126.28 v1(73.54,126.27)
  TOP w0.254: PRV07.2 68.36,122.14 PCV30.1 69.58,122.99 PRV30.1 PCV28.1 v1(70.96,122.79) 70.96,122.09 PRV28.1 70.65,121.78 70.38,121.78 v2(69.9,121.3) 69.2,120.59 68.88,120.59 68.14,119.86 PRV24.2
  IN3 w0.254: v1(73.54,126.27) 73.54,125.37 v1(70.96,122.79)
VSUM-_VGA: length 33.3
  TOP w0.254: PRV33.1 PRV35.1 ; PRV35.1 71.85,122.82 PRV25.2 72.63,122.04 v1(72.99,122.04) ; PRV35.1 71.07,124.4 PCV28.2 PRV30.2 69.43,124.4 PCV32.1 ; PCV32.1 68.87,124.53 PCV22.2 68.94,125.79 PCV23.2 ; PCV32.1 68.02,122.99 PCV30.2 67.09,122.99 PRV08.2
  IN2 w0.254: v1(72.99,122.04) 73.37,121.66 76.31,121.66 76.62,121.36 81.87,121.36 83.27,119.95 90.57,119.95 v1(90.85,120.23)
  BOTTOM w0.254: v1(90.85,120.23) 91.03,120.41 v2(91.45,120.41) 93.47,120.41 PHV02.2
VTTREF_1.2V: length 2
  TOP w0.203: PUM01.4 36.45,30.95 36.41,30.98 36.41,31.82 PCM19.1
WAKEB: length 7.1
  TOP w0.089: v2(109.95,139.58) 110.4,140.03 v1(110.4,140.03)
  BOTTOM w0.102: RV162.2 RV163.1 v1(110.4,140.03) 110.87,140.5 112.92,140.5 113.36,140.94 113.36,141.19 113.67,141.49 113.83,141.49 UV1.AJ27
WHITE_LED_BAT: length 74.5
  TOP w0.089: C62.1 47.19,98.15 47.5,98.47 Q19.1 48.36,99.81 v1(48.43,99.88)
  IN1 w0.102: v1(48.43,99.88) 47.3,101.02 41.11,101.02 39.79,102.34 32.36,102.34 29.85,104.85 23.65,104.85 21.21,107.29 15.14,107.29 12.69,109.74 12.69,118.37 14.12,119.8 15.28,119.8 16.8,121.33 16.8,121.54 16.81,121.55 16.81,122.93 19.67,125.8 20.13,125.8 21.09,126.76 21.09,127.48 20.58,127.99 19.24,127.99 17.6,129.62 17.6,130.25 18.47,131.13 18.47,131.6 17.71,132.36 v1(17.71,132.38)
  BOTTOM w0.089: v1(17.71,132.38) v2(18.45,132.38)
  BOTTOM w0.102: v1(17.71,132.38) R69.2
WHITE_LED_PWR: length 219.9
  TOP w0.089: 51.57,33.84 49.49,33.84 49.18,34.15 49.18,35.72 49.56,36.1 50.48,36.1 50.81,36.43 Q20.1 49.98,37.07 v3(49.02,38.03)
  TOP w0.102: 51.57,33.84 51.9,33.51 v1(51.9,33.08)
  IN1 w0.089: v1(60.31,28.56) 56.37,32.49 54.59,32.49 54.36,32.72 52.26,32.72 v1(51.9,33.08)
  IN2 w0.089: v1(220.24,61.81) 220.02,61.58 217.57,61.58 216.63,60.64 216,60.64 214.53,59.17 214.53,57.55 215.26,56.82 215.26,45.29 215.96,44.59 215.96,39.53 215.61,39.18 215.61,33.19 213.52,31.1 196.75,31.1 195.46,32.4 193.39,32.4 192.54,31.55 188.11,31.55 187.43,32.23 180.85,32.23 178.91,30.29 178.04,30.29 177.33,29.58 175.08,29.58 174.52,29.02 173.7,29.02 173.09,29.02 172.68,29.43 169.05,29.43 168.76,29.71 166.05,29.71 165.88,29.54 155.77,29.54 155.21,28.98 148.44,28.98 145.66,31.77 144.75,31.77 143.12,33.39 136.09,33.39 133.3,30.6 117.09,30.6 116.18,29.69 115.29,29.69 115.29,29.69 113.34,29.69 112.19,28.54 107.9,28.54 107.13,29.31 105.69,29.31 104.17,27.79 94.26,27.79 93.74,27.27 76.56,27.27 75.82,28.01 60.85,28.01 v1(60.31,28.56)
  BOTTOM w0.089: JPWR2.2 220.2,61.85 v1(220.24,61.81)
WIFI_RF_EN: length 223.2
  TOP w0.089: v1(47.62,46.24) 47.34,46.24 46.92,45.82 46.92,44.81 46.31,44.19 45.47,44.19 44.6,43.31 44.6,40.33 v2(43.75,39.48) 42.69,38.42 42.04,38.42 v1(41.69,38.77) ; DW1.1 45.99,101.01 RW13.1 44.95,101.02 RC225.1 43.72,101.51 42.86,101.51 42.36,101.01 40.51,101.01 40.32,100.82 40.32,98.89 39.83,98.4 38.07,98.4 v1(37.65,98.81)
  IN3 w0.089: v1(33.89,41.73) 34.27,41.35 35.34,41.35 35.56,41.56 39.26,41.56 41.69,39.14 v1(41.69,38.77)
  IN3 w0.102: v1(47.62,46.24) 47.34,46.24 46.83,45.73 46.83,43.61 48.76,41.68 48.76,41.33 53.16,36.93 55.77,36.93 58.15,34.55 58.39,34.55 60.14,32.81 65.86,32.81 67.38,31.28 72.84,31.28 75.65,28.48 91.8,28.48 93.55,30.22 97.46,30.22 97.83,29.86 98.99,29.86 99.3,29.54 103.04,29.54 103.74,30.24 107.53,30.24 108.53,29.24 110.27,29.24 111.67,30.64 112.29,30.64 112.7,31.05 118.06,31.05 118.62,30.49 127.4,30.49 128.37,31.46 129.95,31.46 130.98,32.49 130.98,33.7 132.2,34.93 132.2,36.92 134.52,39.24 134.52,41.11 137.01,43.61 138.99,43.61 139.7,44.32 139.7,47.62 v1(140.46,48.38)
  BOTTOM w0.076: 137.3,52.09 137.3,52.16 136.37,53.09 136.32,53.09 UC1.B7
  BOTTOM w0.089: v1(33.89,41.73) 35.09,42.93 35.09,45 35.92,45.83 35.92,50.52 34.76,51.68 34.76,56.01 33.45,57.32 33.45,59.83 32.96,60.32 32.96,62.04 31.32,63.69 31.32,65.57 32.02,66.28 32.02,78.25 32.51,78.73 32.51,82.32 31.23,83.6 31.23,85.3 32.65,86.72 33.66,86.72 35.05,88.12 35.05,90.76 36.56,92.27 36.56,97.72 v1(37.65,98.81)
  BOTTOM w0.102: RC3.1 141.18,48.38 v1(140.46,48.38)
  BOTTOM w0.112: 137.3,52.09 137.3,51.78 138.07,51.01 139.44,51.01 139.87,50.58 139.87,49.93 140.09,49.71 140.09,49.43 140.28,49.24 140.28,48.72 140.29,48.71 140.29,48.48 140.39,48.38 v1(140.46,48.38)
WWAN_CBL_DET#: length 139.8
  TOP w0.089: v1(150.68,30.35) v2(150.68,31.02) 150.68,31.37 149.53,32.52 149.53,33.96 148.43,35.07 147.15,35.07 146.88,35.34 144.47,35.34 144.27,35.54 136.34,35.54 136.11,35.78 133.13,35.78 131.35,37.55 131.35,38.11 129.65,39.81 129.65,41.77 128.79,42.63 v1(128.22,42.63) ; JWWAN.26 216.68,60.24 216.06,59.62 214.58,59.62 RC208.1 213.59,59.19 v1(213.46,59.32)
  IN1 w0.076: v1(125.84,56.42) 125.84,56.31 127.17,54.97 128.09,54.97 128.57,54.49 128.57,51.95 129.51,51.02 129.51,48.68 129.5,48.68
  IN1 w0.089: v1(199.25,35.72) 198.1,35.72 197.01,36.8 192.56,36.8 192.19,36.43 186.33,36.43 186.11,36.21 183.93,36.21 183.35,36.78 178.45,36.78 177.32,35.65 173.84,35.65 173.35,35.16 167.98,35.16 167.94,35.2 163.92,35.2 162.99,34.27 161.75,34.27 161.66,34.37 157.63,34.37 154.42,31.15 153.2,31.15 152.94,30.89 151.13,30.89 150.68,30.45 v1(150.68,30.35) ; 129.5,48.68 128.92,48.09 128.92,46.4 128.58,46.07 128.58,42.99 v1(128.22,42.63)
  IN2 w0.089: v1(199.25,35.72) 199.64,35.32 201.42,35.32 201.64,35.54 205.65,35.54 206.39,36.29 207.81,36.29 209.54,38.02 209.54,41.22 210.77,42.45 210.77,42.93 209.41,44.29 209.41,47.58 209.88,48.05 209.88,50.64 210.69,51.46 210.69,53.84 212.36,55.51 212.36,57.77 213.46,58.87 v1(213.46,59.32)
  BOTTOM w0.076: UC1.AB11 125.61,55.97 125.84,56.21 v1(125.84,56.42)
XCLK_BIASREF: length 16.5
  BOTTOM w0.076: UC1.E42 133.52,73.38 133.52,72.57
  BOTTOM w0.089: 133.52,72.57 133.52,71.63 133.61,71.54 134.55,71.54 134.71,71.7 134.79,71.7 134.8,71.71 135.04,71.71 135.05,71.7 135.13,71.7 135.13,71.7 135.36,71.7 135.36,71.7 135.44,71.7 135.45,71.71 137.12,71.71
  BOTTOM w0.102: 137.12,71.71 137.42,71.42
  BOTTOM w0.112: 137.42,71.42 137.83,71 139.58,71 139.72,70.86 140.42,70.86 140.84,71.29 140.84,74.77 v2(141.45,75.38) RC76.1
XDP_HOOK0: length 0.8
  BOTTOM w0.112: TPC32.1 99.95,39.21 RC148.2
XDP_ITP_PMODE: length 6.6
  TOP w0.089: RC143.2 129.68,51.36 130.51,52.2 130.51,53.01 130.97,53.46 131.82,53.46 TPC7.1
  TOP w0.102: TPC7.1 132.22,53.53 132.26,53.57 133.14,53.57 v1(133.51,53.93)
  BOTTOM w0.076: v1(133.51,53.93) 133.82,54.25 UC1.E8
XDP_OBS0_R: length 3.8
  BOTTOM w0.076: UC1.C55 135.69,81.45 138.67,81.45 TP15.1
XDP_OBS1_R: length 5.5
  BOTTOM w0.076: UC1.D55 135.16,81.34 135.45,81.05 135.69,81.05 135.93,81.28 138.86,81.28
  BOTTOM w0.102: 138.96,81.17 138.86,81.28
  BOTTOM w0.112: TP16.1 138.96,81.17
XDP_OBS2_R: length 2.9
  BOTTOM w0.076: UC1.B54 136.22,81.1 137.76,81.1 138.07,80.79 TP17.1
XDP_OBS3_R: length 5.8
  BOTTOM w0.076: UC1.C56 135.53,81.62 138.34,81.62 138.57,81.85 138.57,82.05
  BOTTOM w0.112: TP18.1 140.11,82.43 140.05,82.49 139.01,82.49 138.57,82.05
XDP_PRDY#: length 4.7
  BOTTOM w0.076: UC1.D56 135.02,82.18 135.54,82.18 135.61,82.25 135.94,82.25 135.98,82.3 136.33,82.3 136.4,82.33 136.77,82.33 136.93,82.17 137.24,82.17 137.97,82.9 138.42,82.9
  BOTTOM w0.102: 138.44,82.92 138.42,82.9
  BOTTOM w0.112: 138.44,82.92 138.5,82.92 TPC31.1
XDP_PREQ#: length 1.1
  TOP w0.102: TPC30.1 134.61,84.39 v1(134.23,84.01)
  BOTTOM w0.076: v1(134.23,84.01) 134.22,84.01 UC1.D61
XDP_PRSENT_CPU: length 2.8
  TOP w0.112: RC175.2 RC144.1 125.02,94.1 TPC33.1
XDP_SPI_IO2: length 13.4
  TOP w0.112: v1(112.59,45.14) 112.18,45.55 111.33,45.55 110.9,45.13 110.43,45.13 110.2,44.9 110.2,44.9 109.79,44.48 TPC9.1 109.44,44.16 109.44,43.54 107.59,41.69 107.45,41.69 107.04,41.28 107.04,38.36 106.41,37.73 106.03,37.73 RC145.1
  BOTTOM w0.112: RC41.1 112.56,45.33 112.56,45.17 v1(112.59,45.14)
XDP_SPI_SI: length 2.2
  BOTTOM w0.112: RC40.1 RC139.2 107.29,38.86 TPC8.1
XTAL24_IN: length 10.5
  BOTTOM w0.076: 138.4,70.37 137.12,70.37 136.95,70.54 134.22,70.54 UC1.E37
  BOTTOM w0.102: 139.16,70.37 v2(138.81,70.37) 138.4,70.37
  BOTTOM w0.112: RC23.1 141.35,72.61 141.35,71.05 140.66,70.37 139.16,70.37
XTAL24_IN_R: length 6
  BOTTOM w0.112: YC1.3 146.38,76.54 145.45,75.61 143.84,75.61 143.26,75.02 CC6.1 RC80.2 RC23.2
XTAL24_OUT: length 10.5
  BOTTOM w0.076: UC1.E35 134.16,70.03 134.32,69.87 134.32,69.39 134.48,69.23 134.49,69.23 134.49,69.23 137.34,69.23 137.99,69.87
  BOTTOM w0.102: 137.99,69.87 139.18,69.87
  BOTTOM w0.112: RC24.1 142.27,71.18 142.27,70.87 141.28,69.87 v2(140.19,69.87) 139.18,69.87
XTAL24_OUT_R: length 4.1
  BOTTOM w0.112: YC1.1 144.1,74.44 142.9,73.24 RC80.1 142.88,72.86 142.97,72.77 142.97,72.48 CC7.1 RC24.2
XTALIN: length 7.3
  BOTTOM w0.102: 112.45,142.92 112.62,142.92 UV1.AM28
  BOTTOM w0.112: RV20.1 109.7,145.33 CV17.1 ; RV20.1 112.04,142.92 112.45,142.92 ; RV20.1 109.53,145.16 YV1.1
XTALOUT: length 9.3
  BOTTOM w0.102: UV1.AK28 113.54,142.6 113.1,142.15 112.45,142.15
  BOTTOM w0.112: YV1.3 107.69,144 109.03,144 109.41,144.38 RV20.2 109.67,143.51 CV18.1 110.54,143.5 111.89,142.15 112.45,142.15
N16741477: length 2
  TOP w0.102: TP61.1 119.57,125.82 v1(119,126.39)
  BOTTOM w0.102: UV1.AB8 119.33,126.39 v1(119,126.39)
N16741489: length 1.4
  TOP w0.102: v1(118.14,125.4) 118.27,125.27 TP57.1
  BOTTOM w0.102: UV1.AD7 v1(118.14,125.4)
N16741505: length 5
  BOTTOM w0.102: UV1.AB4 119.34,123.49 118.84,123 118.84,122.35 117.33,120.84 TP63.1
N16741517: length 1.5
  TOP w0.102: v1(117.37,127.81) 116.78,128.39 TP55.1
  BOTTOM w0.102: v1(117.37,127.81) 117.37,127.77 UV1.AD9
N16741525: length 1.8
  TOP w0.102: v1(121.34,126.11) 121.95,125.51 TP65.1
  BOTTOM w0.102: UV1.Y8 120.86,126.6 v1(121.34,126.11)
N16741803: length 1.9
  TOP w0.102: v1(118.23,138.11) v2(118.23,137.51)
  TOP w0.508: v1(118.23,138.11) 118.23,138.19 118.14,138.27 RV29.2
  BOTTOM w0.254: UV1.AC22 118.23,137.91 v1(118.23,138.11)
N16741825: length 1.5
  TOP w0.508: v1(119,138.38) 119.18,138.56 RV59.2
  BOTTOM w0.305: v1(119,138.38) 119,138.13 UV1.AB22
N16751828: length 1.9
  TOP w0.102: TP58.1 118.46,125.9 118.58,126.02 118.58,126.56 v1(118.12,127.01)
  BOTTOM w0.102: UV1.AC8 v1(118.12,127.01)
N16751830: length 1.1
  TOP w0.102: v1(117.29,126.2) 116.98,125.89 TP54.1
  BOTTOM w0.102: UV1.AE8 116.94,126.55 v1(117.29,126.2)
N16751834: length 1.1
  TOP w0.102: v1(116.54,127.02) 116.89,127.02 TP52.1
  BOTTOM w0.102: v1(116.54,127.02) 116.93,127.4 UV1.AE9
N16751836: length 1.6
  TOP w0.102: TP50.1 125.67,127.63 v1(126.19,127.63)
  BOTTOM w0.102: UV1.N9 126.51,127.63 v1(126.19,127.63)
N16751838: length 3.1
  BOTTOM w0.102: UV1.AB2 119.12,122.78 119.05,122.71 119.05,122.27 118.07,121.29 118.07,120.76 TP64.1
N16751842: length 1.5
  TOP w0.102: v1(119,127.18) 119.55,126.63 119.55,126.61 TP60.1
  BOTTOM w0.102: UV1.AB9 119.22,127.4 v1(119,127.18)
N16751844: length 1.3
  TOP w0.102: TP56.1 118.47,127.38 v1(118.99,127.9)
  BOTTOM w0.102: v1(118.99,127.9) 118.84,127.9 UV1.AC10
N16751848: length 1.3
  TOP w0.102: TP51.1 127.25,127.29 v1(127.35,127.19)
  BOTTOM w0.102: v1(127.35,127.19) 127.39,127.24 127.78,127.24 UV1.L9
N16751852: length 1.6
  TOP w0.102: v1(120.07,125.51) 120.48,125.1 TP62.1
  BOTTOM w0.102: UV1.AB7 119.83,125.51 v1(120.07,125.51)
N16751854: length 3.3
  TOP w0.102: TP59.1 118.75,122.98 118.74,122.99 118.74,124.88 118.88,125.01 v1(118.88,125.39)
  BOTTOM w0.102: v1(118.88,125.39) 118.54,125.73 UV1.AC7
N16751856: length 2.7
  TOP w0.102: TP53.1 119.76,127.78 120.94,127.78 v1(121.34,128.18)
  BOTTOM w0.102: UV1.Y11 121.34,128.18 v1(121.34,128.18)
N16751858: length 2
  TOP w0.102: v1(120.53,124.64) 120.44,124.56 TP66.1
  BOTTOM w0.102: UV1.Y7 120.74,125.54 120.53,125.33 v1(120.53,124.64)
N16808781: length 5.1
  TOP w0.089: v2(110.7,127.28) 111.41,128 v1(111.57,128)
  BOTTOM w0.102: UV1.AJ11 113.96,129 113.51,128.54 112.48,128.54 111.93,128 v1(111.57,128) 111.07,128 RV157.1
N16808782: length 4.6
  BOTTOM w0.089: v2(110.16,131.3) 110.16,130.67 RV155.1
  BOTTOM w0.102: RV155.1 111.13,130.1 111.21,130.18 113.36,130.18 UV1.AK12
N16808783: length 4.1
  TOP w0.089: v1(111.37,128.55) v2(110.36,128.55)
  BOTTOM w0.102: UV1.AL11 112.5,129 112.06,128.55 v1(111.37,128.55) 111.37,128.59 RV156.1
N17003752: length 3
  TOP w0.102: v1(69.53,76.67) 69.57,76.62 v2(70.06,76.62) RD23.2
  BOTTOM w0.102: JDIMM1.134 69.6,76.74 v1(69.53,76.67)
N17004366: length 2.5
  TOP w0.102: RD24.2 57.09,77.13 v1(56.9,76.94)
  BOTTOM w0.102: v1(56.9,76.94) 57.1,76.74 JDIMM2.134
N17213597: length 3.5
  BOTTOM w0.089: v2(36.64,127.69) 35.93,127.69 CT8.1
  BOTTOM w0.254: CT8.1 34.96,127.71 34.96,126.98 35.14,126.8 UT1.33
N17283936: length 35.7
  TOP w0.089: v2(37.93,16.49) 37.67,16.75 QA1.3
  TOP w0.381: v1(36.66,18.3) QA1.3 ; v1(22.04,5.95) RA5.1 21.46,6.7 21.28,6.51 RA6.1
  BOTTOM w0.381: v1(36.66,18.3) 36.66,17.43 38.03,16.06 38.03,7.73 35.01,4.71 32.37,4.71 31.02,6.05 26.01,6.05 25.23,5.28 25.23,4.9 24.85,4.52 22.87,4.52 22.04,5.35 v1(22.04,5.95)
N17389450: length 14.4
  TOP w0.102: v1(27.86,90.08) v2(27.19,90.08)
  IN3 w0.254: v1(27.39,86.66) 27.39,89.61 v1(27.86,90.08)
  BOTTOM w0.254: v1(27.86,90.08) 27.86,90.84 27.2,91.5 PR508.1 PC516.1 26.86,93.05 PR503.2 ; v1(27.39,86.66) 27.11,86.94 25.13,86.94 24.55,86.36 PD501.2 22.94,86.36 22.59,86 PR502.2 PR506.2
N17433967: length 4.2
  BOTTOM w0.089: v2(133.41,113.47) 132.88,114 CZ14.2
  BOTTOM w0.102: UZ4.6 132.58,115.91 132.17,115.49 132.17,114.65 132.34,114.48 CZ14.2
N17442062: length 3.2
  TOP w0.102: UZ1.6 161.73,34.94 162.01,35.21 162.59,35.21 162.82,34.98 162.96,34.98 163.18,34.77 CZ3.1
N17462309: length 5.7
  TOP w0.089: v2(41.84,92.24) v1(40.53,92.24)
  TOP w0.102: RE58.2 40.46,92.31 v1(40.53,92.24)
  BOTTOM w0.102: v1(40.53,92.24) 40.95,91.82 40.95,89.94 41.24,89.65 JDEG1.9
N17462311: length 6
  TOP w0.089: RE59.2 45.63,92.95 v1(45.73,93.05) 45.73,93.38 v3(46.19,93.84)
  BOTTOM w0.102: JDEG1.1 45.24,89.39 45.73,89.87 v1(45.73,93.05)
N17462343: length 3.3
  TOP w0.089: v1(43.82,98.1) 43.82,98.55 44.01,98.74 RE65.2 45.25,98.74 v3(45.53,99.03)
  BOTTOM w0.102: JESPI1.8 44.05,97.87 v1(43.82,98.1)
N17569402: length 12.3
  TOP w0.089: v1(37.25,15.43) 36.58,16.09 v2(36.58,16.37)
  TOP w0.102: v1(31.15,12.06) 30.96,12.25 UA1.4 ; RA9.1 38.28,15.22 37.45,15.22 v1(37.25,15.43)
  IN1 w0.102: v1(31.15,12.06) 35.08,12.06 37.25,14.23 v1(37.25,15.43)
N17847259: length 1.2
  TOP w0.102: TP72.1 112.92,127.07 v1(112.84,127.16)
  BOTTOM w0.102: v1(112.84,127.16) 113.07,127.4 UV1.AL9
N17877344: length 2.4
  BOTTOM w0.102: UV1.R1 124.94,122.29 124.94,121.71 TP69.1
N17877347: length 8.4
  BOTTOM w0.102: TP70.1 123.1,116.92 122.56,117.46 122.56,119.82 123.17,120.43 123.17,120.76 124.45,122.04 124.45,122.57 124.88,122.99 124.88,123.33 UV1.R3
N18330820: length 1.6
  BOTTOM w0.102: UZ5.10 124.65,110.7 124.6,110.64 124.04,110.64 124.02,110.62 CZ19.2
N18330832: length 2.8
  BOTTOM w0.089: CZ18.2 123.57,111.96 v2(123.05,112.49)
  BOTTOM w0.102: UZ5.12 124.69,111.5 124.67,111.52 CZ18.2
N18346546: length 5.6
  TOP w0.089: R37.1 135.68,24.99 136.22,24.99 v2(136.61,25.38)
  TOP w0.102: R37.1 135.29,28.42 Q13.1
N18346552: length 7.7
  TOP w0.089: C18.2 131.68,31.3 130.72,32.27 v2(130.56,32.27)
  TOP w0.102: C18.2 132.42,31.28 R38.2 132.55,31.16 132.55,30.55 132.25,30.26 Q12.2 132.84,29.47 134.32,27.99 Q13.2
N18346555: length 4.5
  TOP w0.089: v2(128.71,30.32) 128.88,30.32 129.84,31.28 R35.2 C18.1 130.77,30.84 130.32,30.4 Q12.3
N18618528: length 7.5
  BOTTOM w0.076: UC1.AY4 115.04,52.03 114.6,51.6 114.23,51.6 114.04,51.41 113.72,51.41 113.7,51.39
  BOTTOM w0.112: TP28.1 111.76,47.79 111.76,50.01 112.81,51.06 113.19,51.06 113.52,51.39 113.7,51.39
N18618529: length 5.5
  BOTTOM w0.112: TP29.1 111.99,47.31 111.99,49.78 113.01,50.81 113.46,50.81 113.75,51.11 UC1.BB3
N18618530: length 3.7
  BOTTOM w0.076: UC1.BB5 112.96,52.52 111.06,50.62 TP27.1
N18855880: length 3.7
  TOP w0.089: v2(207.4,50.48) 208.42,50.48 208.8,50.1 R57.2
  TOP w0.102: R57.2 208.42,49.67 v1(208.42,48.93)
  BOTTOM w0.089: 208.51,48.81 208.42,48.9 v1(208.42,48.93)
  BOTTOM w0.102: U1.3 208.51,48.81
N18983262: length 0.9
  TOP w0.102: CE35.2 54.89,79.73 RE67.1
N18984098: length 1.9
  TOP w0.089: v2(34.49,16.46) RA43.1
  TOP w0.102: CA38.2 35.23,15.41 RA43.1
N19136586: length 3.1
  TOP w0.089: QS1.5 195.28,34.63 RS3.2 ; QS1.6 195.93,34.62 RS3.2 ; RS3.2 195.23,33.92 v2(194.65,33.92)
N19719023: length 1.9
  BOTTOM w0.102: UT2.29 16.6,120.46 16.34,120.2 TP84.1
N20135010: length 3.7
  TOP w0.203: PCV33.2 73.19,125.84 73.91,125.84 74.13,126.05 74.13,126.32 73.98,126.47 PUV01.15
  TOP w0.254: PRV33.2 72.68,125.33 PCV33.2
N20135022: length 0.8
  TOP w0.254: PRV35.2 71.78,124.61 PCV33.1
N20135024: length 4.3
  TOP w0.178: PRV13.2 79.57,129.63 78.68,129.63 v2(78.34,129.29) 77.52,129.29 77.31,129.5 PUV01.25
  TOP w0.254: PRV13.2 79.66,129.73 PCV11.1
N20135039: length 5.7
  TOP w0.203: PUV01.11 72.38,126.82 72.23,126.68 71.81,126.68 70.78,127.71 70.02,127.71 v2(69.81,127.49) 69.4,127.08 68.44,127.08 PRV19.1
N20135040: length 4.5
  TOP w0.203: PUV01.16 74.38,126.69 74.52,126.55 74.52,125.48 PCV25.1
  TOP w0.254: PCV25.1 74.66,124.61 PRV29.1 74.72,124.39 PCV27.1 PRV34.2
N20135043: length 4.1
  TOP w0.203: PCV34.1 75.94,125.84 75.07,125.84 74.82,126.09 74.82,126.67 74.78,126.71 PUV01.17
  TOP w0.254: PRV36.2 77.55,125.34 PCV34.1
N20135091: length 1
  TOP w0.089: v2(80.63,128.46) 80.5,128.33 PCV21.1
N20135096: length 35.2
  TOP w0.254: PRV24.1 68.18,118.46 69.43,119.71 69.71,119.71 PRV22.1 70.25,120.26 70.27,120.28 70.27,120.3 70.33,120.37 70.91,120.37 71.71,119.57 71.71,119.48 72.57,118.62 74.32,118.62 77.2,121.51 v2(79.54,121.51) 81.16,121.51 82.31,120.37 89.91,120.37 94.11,124.57 95.03,124.57 95.47,125.01 v1(95.47,125.03)
  BOTTOM w0.254: PLV01.3 94.63,125.53 94.97,125.53 95.02,125.48 95.03,125.48 95.3,125.22 95.3,125.2 v1(95.47,125.03)
N20135098: length 31.8
  TOP w0.254: PRV25.1 71.67,121.84 71.42,121.59 71.42,120.4 72.06,119.76 72.06,119.62 72.71,118.97 74.17,118.97 77.09,121.89 81.28,121.89 82.42,120.75 v2(88.71,120.75) 89.8,120.75 94.08,125.03 v1(94.84,125.03)
  BOTTOM w0.254: v1(94.84,125.03) 94.84,124.9 95.35,124.39 95.78,124.39 PLV01.2
N20135126: length 36.4
  TOP w0.254: PRV19.2 PRV18.1 v1(67.15,125.03)
  IN3 w0.254: v1(67.15,125.03) 67.01,125.17 67.01,125.22 66.67,125.56 65.9,125.56 65.51,125.17 65.51,123.53 66.71,122.33 71.91,122.33 74.72,125.15 74.72,126.36 75.09,126.73 75.54,126.73 78.02,124.24 78.02,122.98 78.44,122.57 81.98,122.57 83.22,121.33 87.85,121.33 v1(88.35,121.83)
  BOTTOM w0.089: v1(88.35,121.83) 88.24,121.83 v2(87.55,121.14)
  BOTTOM w0.254: v1(88.35,121.83) 88.5,121.68 PHV01.1
N20135134: length 9.6
  TOP w0.203: v1(75.33,126.27) 75.18,126.43 PUV01.18
  TOP w0.254: PCV26.1 73.76,122.88 PRV26.2 PRV29.2 ; PCV26.1 73.68,122 PRV32.1 PRV31.1 ; PCV26.1 73.2,122.8 v1(73.02,122.62)
  IN3 w0.254: v1(73.02,122.62) 73.02,122.64 73.05,122.67 73.05,122.98 75.33,125.27 v1(75.33,126.27)
N20135137: length 0.8
  TOP w0.254: PCV25.2 73.74,124.54 PRV26.1
N20135139: length 2.3
  TOP w0.089: PCV31.1 72.82,120.04 v2(72.55,119.77)
  TOP w0.254: PRV32.2 73.64,121.03 PCV31.1
N20135141: length 10
  TOP w0.203: PUV01.19 75.58,126.66 76.4,125.84 77.92,125.84 78.08,125.69 78.08,123.62 v2(78.01,123.55) 77.94,123.48 77.89,123.48 77.05,122.64 PRV27.1
  TOP w0.254: PRV27.1 76.84,122.61 76.29,122.06 75.94,122.06 75.87,121.99 PCV29.2 PCV26.2
N20135144: length 2.1
  TOP w0.089: v2(76.35,121.69) 75.74,121.08 PCV29.1
  TOP w0.254: PRV31.2 PCV29.1
N20135171: length 31.5
  TOP w0.254: v1(69.01,119.96) 69.06,119.96 69.83,120.73 70.52,120.73 PRV28.2
  IN2 w0.254: v1(91.29,119.85) 91.04,119.6 85.18,119.6 85.12,119.54 74.93,119.54 73.72,118.33 71.93,118.33 71.12,117.52 68.78,117.52 68.49,117.81 68.49,119.44 v1(69.01,119.96)
  BOTTOM w0.254: v1(91.29,119.85) v2(92.69,119.85) PHV02.1
N20135184: length 50.2
  TOP w0.089: v1(94.97,135.55) v2(95.48,135.05)
  TOP w0.254: PRV03.1 67.01,120.99 67.01,121.74 PRV07.1 66.9,121.79 66.35,122.33 66.35,124.09 66.43,124.16 66.43,124.37 v1(66.46,124.37)
  IN3 w0.254: v1(66.46,124.37) 66.46,124.23 66.94,123.76 70.61,123.76 72.13,125.28 72.13,131.34 72.46,131.68 75.78,131.68 79.4,135.3 79.4,138.32 80.41,139.34 83.07,139.34 83.65,139.92 89.05,139.92 89.36,139.61 89.36,138.59 90.69,137.26 93.76,137.26 94.94,136.08 94.94,135.58 v1(94.97,135.55)
  BOTTOM w0.254: PLV02.3 94.97,135.53 v1(94.97,135.55)
N20135212: length 1.4
  TOP w0.089: v2(79.79,134.04) 79.54,133.79 PRV01.2
N20135219: length 46.6
  TOP w0.089: v1(95.4,135.95) v2(95.4,136.81)
  TOP w0.254: v1(67.05,124.37) 66.99,124.37 67.02,124.33 67.02,123.97 66.89,123.83 PRV08.1
  IN3 w0.254: v1(67.05,124.37) 67.25,124.16 70.52,124.16 71.78,125.42 71.78,131.49 72.32,132.03 75.63,132.03 79.05,135.44 79.05,138.47 80.27,139.69 82.92,139.69 83.51,140.27 89.2,140.27 89.71,139.76 89.71,138.74 90.85,137.61 93.9,137.61 95.4,136.11 v1(95.4,135.95)
  BOTTOM w0.254: v1(95.4,135.95) PLV02.2
N20135251: length 2.4
  TOP w0.089: v2(72.93,135.82) 72.68,135.57 72.68,134.31 73.21,133.78
N20135257: length 3.6
  TOP w0.089: v2(70.82,134.63) 70.87,134.63 PRV10.1
  TOP w0.203: PUV01.1 71.63,133.55 PRV10.1
N20135258: length 3.9
  TOP w0.089: v2(70.77,133.28) 70.62,133.28 69.95,132.61 PRV09.1
  TOP w0.203: PUV01.2 71.1,131.1 70.9,131.3 70.9,131.78 70.35,132.33 PRV09.1
N20135263: length 1.8
  TOP w0.203: PUV01.34 74.78,132.66 73.96,133.47 PRV04.1
N20558038: length 6.2
  BOTTOM w0.089: v2(146.52,86.95) 146.52,87.51 RC103.2
  BOTTOM w0.102: 147.07,89.7 DZ4.2 148.29,90.92 CC14.1 ; 147.07,89.7 147.07,88.94 146.1,87.98 RC103.2 ; 147.07,89.7 UC6.2
N20834517: length 6.6
  TOP w0.089: v2(40.12,132.61) 39.85,132.88 38.32,132.88 RT62.1 37.88,131.94 38.06,131.76 UT7.4 36.74,131.26 36.52,131.48 QT5.3
N20835268: length 8.5
  TOP w0.089: v3(27.28,121.47) 27.85,120.9 29.07,120.9 RT121.1
  TOP w0.508: DT2.2 31.78,121.11 UT4.5 29.89,121.11 RT121.1 29.59,122.03 CT17.1
N20835276: length 13.7
  TOP w0.089: UT4.4 33.97,121.74 v2(34.67,121.74) ; UT4.4 33.77,120.7 33.77,119.38 33.35,118.96 UT4.3 ; UT4.4 32.55,120.31 CT53.1 30.1,119.43 RT59.2 29.65,118.73 29.65,118.47 28.95,117.77 QT4.1
N20835295: length 162.8
  TOP w0.089: 29.73,116.81 30.09,116.81 RT6.1 30.31,116.58 31.07,116.58 31.43,116.23 v1(31.43,116.03)
  TOP w0.102: QT4.2 29.73,116.81
  IN2 w0.089: v1(31.43,116.03) 31.05,115.66 30.35,115.66 28.99,114.3 28.99,113.21 29.68,112.52 29.68,110.35 30.57,109.47 38.61,109.47 38.81,109.26 38.81,103.88 38.53,103.61 38.53,102.35 36.84,100.66 36.84,92.45 35.09,90.69 35.09,88.56 34.72,88.19 34.72,85.74 36.61,83.85 36.61,81.89 35.52,80.8 35.52,77.59 34.09,76.16 34.09,74.4 34.86,73.63 34.86,67.35 35.07,67.15 36.01,67.15 36.16,67.3 41.44,67.3 42.44,66.3 42.44,65.58 42.26,65.4 42.26,64.88 42.55,64.59 43,64.59 43.35,64.24 43.35,61.94 45.57,59.72 45.57,54.6 45.21,54.24 44.47,53.5 44.47,44.97 44.64,44.81 44.64,43.61 45.73,42.53 45.73,41.25 52,34.97 55.33,34.97 57.41,32.89 57.69,32.89 59.93,30.65 59.93,28.4 60.51,27.83 75.74,27.83 76.48,27.09 93.82,27.09 94.34,27.61 97.83,27.61 v1(98.2,27.24)
  BOTTOM w0.089: CT54.1 98.62,27.65 v1(98.2,27.24)
N21269026: length 1.7
  TOP w0.089: PRI23.2 v2(160.25,89.66)
N21273981: length 1.8
  TOP w0.089: PRG03.2 v2(154.79,89.82)
N21379353: length 2
  TOP w0.089: v2(23.16,95.65) 23.86,95.65 v1(23.96,95.75) 23.95,95.77 PC508.1
N21484820:
  vias: v1(171.03,43.45) v1(171.65,43.14) v1(171.67,43.73) v2(171.53,44.5)
N21562772: length 2.8
  TOP w0.089: PRB44.2 169.73,32.44 v2(170.35,31.82)
  TOP w0.254: PDB05.2 169.4,33.43 169.73,33.1 PRB44.2
N21562775: length 10.5
  TOP w0.089: v2(169.68,38.15) 169.4,37.86 PDB05.1
  TOP w0.254: v1(168.68,35.75) 169.12,35.75 169.4,36.02 PDB05.1 ; v1(166.03,35.79) 166.47,36.23 PDB04.1 166.99,35.46 166.62,35.1 165.53,35.1 165.07,34.65 PUB02.1
  IN2 w0.254: v1(166.03,35.79) 168.63,35.79 v1(168.68,35.75)
N21599913: length 2.1
  TOP w0.102: RL7.2 20.51,88.72 20.35,88.56 v2(20.34,88.56) UL2.3
N21620369: length 4.6
  TOP w0.089: v2(61.71,33.49) 61.95,33.26 R67.1 R65.2 61.95,30.93 61.21,30.2 Q15.2
N21620701: length 3.3
  TOP w0.089: v2(60.89,34.58) 59.98,33.66 Q4.1 59.98,32.97 60.51,32.43 R67.2
N21664134: length 14.8
  TOP w0.089: v2(175.89,46.67) 175.52,46.3 175.52,45.3 RS5.1 175.71,44.52 175.62,44.43 175.62,41.85 176.89,40.58 178.98,40.58 179.19,40.38 180.1,40.38 181,39.48 181.54,39.48 182.63,38.39 183.31,38.39 183.44,38.25 US2.3
