# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
POWER_SW_IN#: length 7.2
  TOP w0.102: UE1.127 34.91,69.81 34.59,69.49 34.59,67.51 v2(34.48,67.39) 34.48,66.96 34.06,66.54 33.57,66.54 CE33.1 32.43,66.11 RE41.2 RE43.1
PRIM_PWRGD: length 168.3
  TOP w0.089: UE1.30 48.95,66.63 v1(48.55,66.23) ; PR1803.2 167.21,44.77 v2(168.06,44.77)
  TOP w0.254: PR1803.2 166.9,45.08 v1(166.23,45.08)
  IN2 w0.089: v1(166.23,45.08) 166.47,44.84 166.47,41.89 162.29,37.71 160.59,37.71 158.44,35.57 155.64,35.57 155.1,35.03 153.29,35.03 151.71,36.61 149.56,36.61 148.75,37.42 144.09,37.42 143.36,38.16 141.51,38.16 140.32,39.34 140.32,41 138.56,42.76 136.06,42.76 133.86,40.56 133.86,38.76 131.08,35.97 129.4,35.97 128.79,35.37 116.28,35.37 115.74,34.83 114.84,34.83 114.58,35.09 111.18,35.09 110.53,34.43 107.54,34.43 106.81,33.71 100.37,33.71 100.04,34.04 96.22,34.04 96.05,34.21 87.46,34.21 86.97,34.7 84.13,34.7 83.14,33.71 82.44,33.71 81.51,32.78 74.04,32.78 73.65,32.39 71.8,32.39 71.43,32.75 69.11,32.75 68.52,33.34 61.65,33.34 57.05,37.95 53.66,37.95 47.04,44.57 47.04,47.14 47.46,47.55 47.46,48.68 47.45,48.69 47.45,53.12 47.99,53.66 47.99,61.27 48.8,62.09 48.8,63.53 48.55,63.79 v1(48.55,66.23)
  BOTTOM w0.254: v1(166.23,45.08) 166.39,44.92 PU1801.4
PROCHOT: length 12.4
  TOP w0.089: v2(36.71,91.58) 37.19,91.09 RE53.2 37.3,90.47 UE2.2
  TOP w0.102: UE1.83 42.55,84.38 42.77,84.59 42.77,85.21 42.69,85.29 v1(42.69,85.29) ; v1(39.22,90.86) 39.22,90.86 38.76,90.86 38.36,90.47 UE2.2
  IN2 w0.102: v1(39.22,90.86) 40.52,89.56 40.52,87.46 42.69,85.29 v1(42.69,85.29)
PROJECT_ID0: length 12.9
  TOP w0.089: v2(120.32,47.77) 120.67,47.42 v1(120.67,47.32)
  IN1 w0.102: v1(120.67,47.32) 120.67,46.93 121.14,46.45 121.14,44.44 v1(121.45,44.13)
  BOTTOM w0.076: UC1.AK6 121.22,52.22 121.38,52.06 121.38,51.83 121.29,51.73 121.29,51.51 121.36,51.44 121.36,51.09 121.21,50.94 121,50.94 120.85,50.79 120.85,50.53 120.69,50.37 120.69,50.22 120.68,50.21 120.68,49.51 120.66,49.48 120.6,49.33 120.6,49.03 120.51,48.95 120.51,48.68
  BOTTOM w0.102: RC53.2 120.65,47.3 v1(120.67,47.32) 120.64,47.34 120.64,47.51 120.46,47.69 120.46,48.19 120.51,48.24 120.51,48.68 ; RC54.1 121.45,43.42 v1(121.45,44.13)
PROJECT_ID1: length 17.2
  IN1 w0.076: v1(121.73,52.93) 121.73,52.93 121.73,52.68 120.97,51.92 120.58,51.92 120.33,51.66 120.33,48.68
  IN1 w0.102: 120.33,48.68 120.33,48.17 119.6,47.45 119.6,45.44 122.08,42.96 v1(122.08,42.09)
  BOTTOM w0.076: v1(121.73,52.93) 121.59,52.93 121.22,53.29 UC1.AK7
  BOTTOM w0.102: RC52.1 RC51.2 124.33,42.78 123.83,42.27 123.58,42.27 123.25,41.94 122.62,41.94 122.47,42.09 v1(122.08,42.09)
PS_0: length 3.5
  TOP w0.102: v1(118,135.8) 118,135.69 CV29.1 RV9.1 115.7,135.17 RV8.2
  BOTTOM w0.102: UV1.AC19 118.54,135.26 v1(118,135.8)
PS_1: length 4.7
  TOP w0.102: v1(117.33,135.95) 117.12,136.16 CV28.1 116.15,135.64 114.86,135.64 RV12.1 114.77,135.69 RV11.2
  BOTTOM w0.102: v1(117.33,135.95) 117.33,135.61 UV1.AD19
PS_2: length 5
  TOP w0.102: v1(116.6,133.54) 116.6,133.46 116.17,133.03 v2(115.91,133.03) 115.66,133.03 CV11.1 RV13.1 112.82,133.91 RV28.2
  BOTTOM w0.102: UV1.AE17 116.6,133.66 v1(116.6,133.54)
PS_3: length 6.6
  TOP w0.102: CV15.1 RV16.1 113.99,139.01 RV15.2 114.39,139.57 v2(115.34,138.63) 115.82,138.15 115.82,137.84 116.67,136.98 v1(116.67,136.95)
  BOTTOM w0.102: v1(116.67,136.95) 116.67,136.67 UV1.AE20
PS_ID: length 63.2
  TOP w0.089: v1(53.61,92.83) 53.13,92.83 v2(52.97,93)
  TOP w0.102: UE1.36 50.54,70.61 49.82,71.33 v1(49.78,71.33)
  TOP w0.254: PD2.1 v1(59.91,120.81) 59.57,121.15 59.55,121.15 58.62,122.08 PR5.1 PR1.2
  IN3 w0.102: v1(49.78,71.33) 49.4,71.33 47.89,72.84 47.89,74.43 50.97,77.51 50.97,77.52 51.53,78.09 51.53,85.34 54.42,88.23 54.42,92.02 v1(53.61,92.83)
  BOTTOM w0.102: v1(53.61,92.83) 54.12,93.35 54.12,114.65 58.07,118.6 58.07,119.44 59.44,120.81 v1(59.91,120.81)
PSID: length 52.8
  TOP w0.254: v1(56.76,116.2) 56.49,116.48 PL3.1
  IN2 w0.254: v1(56.76,116.2) 56.49,116.48 56.49,118.11 55.37,119.22 55.37,120.98 53.87,122.47 53.87,126.99 54.34,127.46 54.34,130.06 54.1,130.3 54.1,136 56.92,138.82 64.4,138.82 64.78,139.2 71.67,139.2 72.76,138.12 74.7,138.12 78.4,141.81 v1(78.81,141.81)
  BOTTOM w0.089: v1(56.76,116.2) v2(57.27,116.2)
  BOTTOM w0.254: v1(78.81,141.81) 78.81,142.46 79.2,142.85 PJPDC1.3
PSID-1: length 5.1
  TOP w0.254: PQ2.2 57.63,116.15 56.67,115.19 v2(56.43,115.19) 55.26,115.19 54.69,115.76 PR6.1 PR3.2
PSID-3: length 3.6
  TOP w0.089: PR1.1 56.97,122.13 57.34,122.51 57.34,122.56 57.88,123.1 v2(58.42,123.1)
  TOP w0.254: PQ1.3 56.98,121.51 56.97,121.52 PR1.1
PTP_DIS#: length 131.9
  TOP w0.089: v1(40.81,79.92) 40.39,80.34 40.39,81.03 39.75,81.68 UE1.90
  IN3 w0.089: v1(33.58,64.33) 35.14,64.33 35.72,63.75 40.99,63.75 41.53,64.29 41.53,65.08 41.02,65.59 41.02,68.12 40.43,68.71 40.43,72.73 41.23,73.54 41.23,79.5 v1(40.81,79.92)
  BOTTOM w0.089: D6.1 108.72,26.63 108.15,26.06 100.47,26.06 v2(100.28,26.26) 99.65,26.26 98.84,25.45 77.4,25.45 71.22,31.62 66.52,31.62 65.6,32.54 57.53,32.54 55.77,34.3 55.25,34.3 54.08,35.47 47.8,35.47 43.42,39.85 43.42,42.58 42.6,43.4 40.61,43.4 39.22,44.79 39.22,55.42 38.06,56.58 36.62,56.58 35.68,57.53 35.68,58.06 34.96,58.78 34.96,60.63 34.49,61.1 34.49,62.8 33.58,63.7 v1(33.58,64.33)
PWM1_2PH_CPU: length 25.5
  TOP w0.089: v1(161.36,70.89) v2(161.36,71.52)
  IN1 w0.254: v1(171.1,54.49) 170.69,54.49 170.39,54.78 170.39,55.46 170.54,55.61 170.54,58.38 169.49,59.44 169.49,65.27 164.35,70.41 161.84,70.41 v1(161.36,70.89)
  BOTTOM w0.203: v1(171.1,54.49) 171.51,54.9 PUZ01.16
  BOTTOM w0.254: PUI01.1 162.02,70.36 161.49,70.89 v1(161.36,70.89)
PWM2_2PH_CPU: length 44.8
  TOP w0.089: v1(166.99,88.33) 166.91,88.24 v3(166.3,88.24)
  IN1 w0.254: v1(170.85,55.03) 171.27,55.03 171.64,55.39 171.64,58.25 171.1,58.78 170.63,58.78 169.84,59.57 169.84,65.42 166.08,69.18 166.08,69.19 165.46,69.81 165.46,71.6 164.85,72.21 163.6,72.21 v1(163.08,71.69)
  IN3 w0.254: v1(166.99,88.33) 166.65,87.98 166.65,81.2 166.24,80.8 166.24,74.07 163.86,71.69 v1(163.08,71.69)
  BOTTOM w0.203: v1(170.85,55.03) 170.85,55.03 171.1,55.03 171.36,55.3 PUZ01.17
  BOTTOM w0.254: v1(166.99,88.33) 166.92,88.26 PUI02.1
PWM_1A_CPU: length 54.7
  TOP w0.089: v1(158.07,96.02) 158.07,96.14 158.5,96.58 v2(158.53,96.58)
  IN2 w0.254: v1(158.07,96.02) 159.86,97.81 164.4,97.81 168.69,93.52 168.86,90.83 168.98,88.94 168.98,88.86 168.98,88.86 168.98,86.98 168.72,86.72 168.72,83.26 169.87,82.11 169.87,72.37 170.09,72.16 170.09,72.15 172.32,69.92 172.32,63.15 170.16,60.99 170.16,58.93 v1(171.07,58.02)
  BOTTOM w0.203: v1(171.07,58.02) 171.79,57.3 PUZ01.22
  BOTTOM w0.254: PUG01.1 157.84,95.79 v1(158.07,96.02)
PWM_1B_CPU: length 15
  TOP w0.089: v1(178.09,59.36) 178.08,59.35 177.98,59.35 v2(177.52,58.89)
  IN3 w0.254: v1(178.09,59.36) 177.45,58.72 172.47,58.72 172.02,59.17 171.61,59.17 171.35,58.91 169.53,58.91 169.1,59.34 168.06,59.34 v1(167.74,59.02)
  BOTTOM w0.203: PUZ01.36 177.63,59.27 177.72,59.36 v1(178.09,59.36)
  BOTTOM w0.254: PUA01.2 166.54,59.19 166.84,59.49 167.51,59.49 167.74,59.26 v1(167.74,59.02)
PWR_LED_R#: length 11.2
  TOP w0.089: 52.43,35.75 52.18,36 50.86,36 Q20.2 ; Q21.1 55.48,30.82 v2(56.14,30.16)
  TOP w0.102: 52.43,35.75 52.43,34.36 52.93,33.87 52.93,32.98 53.16,32.75 54.82,32.75 Q21.1
PWR_SE1: length 50.5
  TOP w0.089: v2(43.11,127.02) 43.04,127.02 v1(42.67,126.65)
  TOP w0.254: PR63.1 42.73,126.65 v1(42.67,126.65) ; PD11.1 80.87,140.03 v1(80.87,140.42)
  IN1 w0.254: v1(80.87,140.42) 80.41,139.96 77.45,139.96 75.84,138.35 56.8,138.35 52.17,133.72 49.98,133.72 48.77,132.51 48.77,128.91 46.77,126.9 42.92,126.9 v1(42.67,126.65)
PWR_SE2: length 6.5
  TOP w0.127: v2(43.36,120.8) PQS30.6
  TOP w0.254: PRS45.1 41.75,126 PR63.2 42.79,125.67 42.79,124.51 43.01,124.29 PQS30.5 PQS30.6
PWR_SELECT: length 88.4
  TOP w0.089: RE89.2 28.94,72.54 28.48,73 28.48,74.98 29.24,75.74 v2(29.66,75.74) 30.2,75.74 v1(30.55,75.4) ; v1(40.33,75.36) 41.78,76.81 v1(44,76.81)
  TOP w0.254: v1(46.62,122.86) 47.06,123.3 PR66.1 PR65.2 47.74,124.29 PR64.2
  IN3 w0.089: v1(38.13,70.04) 37.57,70.6 33.24,70.6 30.91,72.93 30.33,72.93 30,73.26 30,74.48 30.19,74.67 30.19,75.04 v1(30.55,75.4) ; v1(44,76.81) 45.86,78.66 45.86,80.21 46.5,80.86 46.5,82.94 49.75,86.19 49.75,88.32 51.33,89.9 v1(51.33,90.9)
  IN3 w0.102: v1(45.59,100.33) 45.41,100.5 45.41,103.01 44.47,103.94 42.33,103.94 v1(42.05,103.67)
  BOTTOM w0.089: v1(40.33,75.36) 39.77,74.8 39.77,72.3 38.13,70.65 v1(38.13,70.04)
  BOTTOM w0.102: v1(51.33,90.9) 50,90.9 49.71,91.19 49.71,96.95 47.3,99.36 46.55,99.36 v1(45.59,100.33) ; v1(42.05,103.67) 42.74,104.36 42.74,109.66 43.51,110.43 43.51,115.24 44.71,116.44 44.71,122.04 45.53,122.86 v1(46.62,122.86)
PWR_SELECT1: length 80.9
  TOP w0.102: v1(97.23,147.52) 97.49,147.79 v2(97.49,148.66)
  TOP w0.254: v1(97.23,147.52) 97.01,147.73 PU2.1
  TOP w0.457: PR65.1 PQS30.2
  TOP w0.508: PR65.1 46.15,124.47 46.64,124.96 v1(46.64,125.07)
  IN1 w0.508: v1(46.64,125.07) 46.64,124.77 47.05,124.37 49.51,124.37 50.78,123.1 52.22,123.1 v1(52.7,123.58)
  IN2 w0.254: v1(89.07,147.1) 89.07,146.49 87.66,145.08 81.93,145.08 79.95,143.09 79.95,141.36 79.3,140.72 78.65,140.72 75.1,137.17 72.36,137.17 71.28,138.25 66.18,138.25 65.62,137.69 62.7,137.69 60.03,135.02 60.03,128.16 59.41,127.54 59.41,123.83 60.68,122.56 v1(60.68,121.47)
  IN3 w0.254: v1(97.23,147.52) 93.44,147.52 92.73,148.23 90.2,148.23 v1(89.07,147.1)
  IN3 w0.508: v1(52.7,123.58) 53.37,123.58 55.36,121.6 58.06,121.6 58.61,122.15 60.32,122.15 60.68,121.79 v1(60.68,121.47)
PWR_SELECT2: length 19.5
  TOP w0.254: v1(95.39,150.15) v2(94.88,150.15) 94.79,150.06 94.79,149.21 94.61,149.03 PU2.4 93.07,149.03 92.87,149.23 PR46.2 PR21.2
  IN3 w0.254: v1(88.49,147.01) 88.49,147.21 89.85,148.58 92.88,148.58 93.59,147.87 95,147.87 95.39,148.25 v1(95.39,150.15)
  BOTTOM w0.254: v1(95.39,150.15) 95.39,149.55 PQ15.2 ; v1(88.49,147.01) 88.49,146.12 87.22,144.85 PR49.1
PWRGD_VGA: length 16.7
  TOP w0.089: PRV20.1 78.59,124.66 79.14,124.11 v2(79.22,124.11)
  TOP w0.203: v1(69.76,128.58) 70.04,128.3 PUV01.9 ; PRV17.2 78.26,126.17 76.74,126.17 v1(76.56,126.35) 76.4,126.35 75.98,126.77 PUV01.20
  TOP w0.254: PRV17.2 78.58,125.06 PRV20.1
  IN1 w0.254: v1(76.56,126.35) 75.57,125.36 71.67,125.36 71.15,125.88 71.15,127.19 v1(69.76,128.58)
PX_EN: length 1.2
  TOP w0.102: TP73.1 118.82,132.92 v1(118.82,133.36)
  BOTTOM w0.102: v1(118.82,133.36) 118.98,133.36 UV1.AB16
REGOUT:
  vias: v2(21.07,84.56)
RESET_OUT#: length 130.6
  TOP w0.089: v1(50.55,85.63) 50.55,85.38 v3(50.28,85.1)
  TOP w0.102: UE1.73 46.55,82.21 46.64,82.12 46.64,80.31 v1(47.68,79.26) ; v1(50.55,85.63) 50.88,85.96 50.88,86.23 RE16.1 CE31.1
  IN3 w0.102: v1(50.55,85.63) 50.55,85.21 48.07,82.73 48.07,81.2 48.06,81.18 48.06,79.63 v1(47.68,79.26)
  BOTTOM w0.089: 51.31,74.83 47.68,78.45 v1(47.68,79.26)
  BOTTOM w0.112: 51.31,74.83 51.31,65.6 52.34,64.57 52.34,63.59 52.36,63.57 52.36,49.18 55.54,46 55.54,43.47 58.51,40.5 61.97,40.5 62.15,40.32 68.48,40.32 68.92,39.89 70.9,39.89 71.82,38.97 72.92,38.97 73.62,38.27 75.09,38.27 76.86,36.51 79.86,36.51 82.31,38.95 89.28,38.95 89.99,39.66 92.19,39.66 93.42,40.89 93.42,42.72 94.48,43.78 94.48,44.32 99.26,49.1 99.26,54.81 102.17,57.72 104.84,57.72 104.85,57.72 105.32,57.72 107.53,59.93 112.12,59.93 113.42,61.23 114.3,61.23 UC1.BA20
RING2:
  vias: v2(27.62,18.7)
RING2_R: length 43.1
  TOP w0.127: v3(15.07,11.04) 16.53,11.04 16.57,11.01
  IN1 w0.508: 15.17,7.53 14.08,7.53 13.58,7.02 5.73,7.02 JHP1.4
  IN2 w0.508: 15.17,7.53 13.97,7.53 13.46,7.02 5.73,7.02 JHP1.4
  IN3 w1.016: 16.09,10.98 15.23,11.84 15.23,13.71 15.9,14.39 15.9,17.8 18.53,20.42 18.53,21.07 19.69,22.23 19.69,22.23 20.94,23.48 21.37,23.48 21.38,23.49 25.13,23.49 25.4,23.22
  vias: v1(15.99,8.01) v1(16.57,8.01) v1(16.95,10.9) v1(17.53,10.9) v1(26.26,23.25) v1(26.26,22.66)
ROSC_COREGT_CPU: length 4
  BOTTOM w0.089: PRZ64.1 170.16,54.47 170.35,54.67 v2(170.35,55.25)
  BOTTOM w0.203: PUZ01.14 172,54.1 171.38,53.47 170.84,53.47 170.19,54.12 PRZ64.1
ROSC_SAUS_CPU: length 3.3
  TOP w0.089: v2(170.39,53.2) 170.39,53.27 171.02,53.9 171.1,53.9 v1(171.1,53.9)
  TOP w0.254: v1(171.1,53.9) 171.2,53.8 PRZ60.1
  BOTTOM w0.203: PUZ01.15 171.86,54.5 171.26,53.9 v1(171.1,53.9)
RSET: length 3.5
  TOP w0.089: v2(20.66,78.71) RL2.2 20.66,79.79
  TOP w0.254: 20.66,79.79 21.36,80.49 21.36,81.02 21.6,81.26 UL1.31
RTC_DET#: length 123.2
  TOP w0.089: v1(134.4,43.02) 133.84,43.02 v2(133.68,42.86) ; 45.14,51.49 45.14,52.23 44.92,52.46 44.55,52.46
  TOP w0.102: 44.55,52.46 Q1.1 ; v1(49.09,46.35) 48.07,46.35 47.42,47 47.42,49.22 45.14,51.49
  IN2 w0.089: v1(49.09,46.35) 49.09,46.01 48.37,45.28 48.37,44.31 54.08,38.6 57.25,38.6 61.86,33.99 68.65,33.99 68.76,34.11 71.48,34.11 71.97,33.62 75.94,33.62 76.4,34.08 82.01,34.08 82.54,34.61 83.24,34.61 84.52,35.89 84.73,35.89 85.37,36.53 86.64,36.53 88.36,34.81 96.63,34.81 96.69,34.75 100.48,34.75 100.94,34.29 106.47,34.29 107.22,35.03 110.04,35.03 110.66,35.66 114.83,35.66 115.3,36.13 121.07,36.13 122.01,37.07 124.47,37.07 125.07,36.47 128.6,36.47 129.02,36.89 129.97,36.89 130.67,37.59 131.17,37.59 131.39,37.8 131.39,38.48 132.61,39.7 132.61,41.17 134.17,42.73 134.17,42.79 v1(134.4,43.02)
  BOTTOM w0.089: UC1.P1 129.12,49.99 130.4,48.71 131.43,48.71 132.9,47.25 132.9,45.35 134.06,44.19 134.06,44.05 134.4,43.71 v1(134.4,43.02) 133.57,42.2 RC46.1
RTC_PWR: length 7.1
  TOP w0.089: Q1.2 42.39,50.38 41.92,49.91 D1.3 40.13,48.98 40.13,48.38 v2(40.39,48.12) 40.61,48.12 40.89,48.4 41.5,48.4 R1.1 42.34,48.08 R2.1
RTCRST_ON: length 149.9
  TOP w0.089: v1(68,32.34) 68.32,32.02 v2(69.31,32.02) 69.76,32.02 70.53,31.25 70.53,30.23 70.13,29.83 R78.2 67.93,29.83 D7.1 67.32,29.83 C61.1 66.59,29.1 R79.2 66.3,28.29 65.41,29.18 63.47,29.18 63.25,28.96 Q23.2 60.02,28.16 v1(58.98,27.13) ; v1(97.75,36.15) 97.93,36.34 97.93,37.9 98.55,38.52 98.55,39.94 98.09,40.4 98.09,41.64 97.01,42.71 97.01,45.08 96.01,46.08 96.01,46.47 RC164.1 97.21,46.4 99.79,46.4 99.96,46.57 QC2.2
  TOP w0.102: v1(49.77,70.74) 49.35,70.33 UE1.31
  IN1 w0.102: v1(38.93,63.11) 38.93,63.39 39.1,63.56 42.05,63.56 42.35,63.25 42.35,63.03 42.6,62.78 43.81,62.78 44.63,63.61 50.5,63.61 51.52,62.59 v1(51.95,62.59)
  IN2 w0.102: v1(38.93,63.11) 39.48,62.56 40.44,62.56 41.22,61.79 42.21,61.79 44.29,59.7 44.29,57.2 43.37,56.28 43.37,45.65 42.91,45.19 42.91,43.77 44.62,42.06 44.62,40.79 51.63,33.78 53.48,33.78 54.81,32.44 55.79,32.44 58.65,29.59 58.65,27.47 v1(58.98,27.13)
  IN3 w0.102: v1(49.77,70.74) 49.82,70.74 50.64,69.92 50.64,69.51 51.49,68.66 51.49,63.05 v1(51.95,62.59)
  BOTTOM w0.089: v1(68,32.34) 68.54,31.81 71.29,31.81 76.28,26.82 94.47,26.82 95.93,28.27 95.93,32.69 96.75,33.51 96.75,34.73 97.26,35.25 97.26,35.67 v1(97.75,36.15)
RUNPWROK: length 3.5
  TOP w0.102: RE42.2 54.42,75.17 54.28,75.32 52.33,75.32 52.25,75.41 UE1.48
SATA3_CRX_C_HDDTX_N0: length 4.6
  TOP w0.112: EU3101.4 EU3101.7 187.87,35.3 187.64,35.07 187.64,34.89 v1(187.97,34.57) 187.97,34.56 187.76,34.36 187.76,34.11 187.6,33.95 187.6,33.81 CS3.2
  BOTTOM w0.112: JHDD.16 188.2,34.8 187.97,34.57 v1(187.97,34.57)
SATA3_CRX_C_HDDTX_P0: length 4.4
  TOP w0.112: EU3101.5 EU3101.6 187.37,35.02 187.38,35.01 v1(187.38,34.57) 187.38,34.56 187.54,34.41 187.54,34.2 187.38,34.05 187.38,33.82 CS4.2
  BOTTOM w0.112: JHDD.15 187.7,34.92 187.38,34.6 v1(187.38,34.57)
SATA3_CRX_HDDTX_N0: length 100.3
  TOP w0.112: v1(191.02,35.53) 191.17,35.38 191.17,35.12 191.38,34.9 191.38,33.87 191.01,33.49 191.01,31.63 190.43,31.04 188.66,31.04 187.61,32.09 187.61,32.25 CS3.1
  IN1 w0.076: 134.75,60.78 133.99,60.78 133.81,60.96 133.81,61.5 133.73,61.57 133.51,61.57 133.4,61.46 v1(133.4,61.34)
  IN1 w0.114: 135.45,51.68 135.45,52.02 135.45,52.03 135.45,52.2 135.57,52.32 135.58,52.32 136.13,52.87 136.13,57.08 135.05,58.15 135.05,60.49 134.76,60.78 134.75,60.78
  IN1 w0.119: v1(132.8,36.66) 132.8,36.9 132.8,36.91 132.8,36.92 132.44,37.29 132.44,37.75 133.2,38.51 133.2,41.84 133.51,42.15 133.51,45.51 134.46,46.46 134.46,48.77 134.47,48.78 134.47,50.36 135.45,51.34 135.45,51.68
  IN3 w0.135: v1(132.8,36.66) 133.07,36.66 133.84,35.89 142.8,35.89 143.27,36.36 145.05,36.36 145.24,36.17 146.43,36.17 146.89,36.63 147.31,36.63 147.31,36.63 148.21,36.63 149.54,35.3 151.57,35.3 152.86,34.01 162.72,34.01 163.14,34.43 164.27,34.43 164.9,35.06 167.7,35.06 167.94,34.82 173.97,34.82 174.4,34.4 177.45,34.4 178.86,35.8 183.96,35.8 184.08,35.68 189.61,35.68 189.99,36.06 191.03,36.06 191.17,35.93 191.17,35.68 v1(191.02,35.53)
  BOTTOM w0.076: UC1.F20 133.1,61.09 133.19,61.27 v1(133.4,61.34)
SATA3_CRX_HDDTX_P0: length 100.4
  TOP w0.112: v1(191.6,35.53) 191.39,35.31 191.39,35.21 191.61,34.99 191.61,33.77 191.23,33.4 191.23,31.53 190.52,30.82 188.57,30.82 187.39,32 187.39,32.22 CS4.1
  IN1 w0.076: v1(134.17,61.34) 133.97,61.14 133.97,61.03 134.05,60.96 134.65,60.96 134.67,60.98 134.83,60.98 134.87,60.94 134.89,60.94 134.9,60.93
  IN1 w0.114: 135.66,51.68 135.66,51.71 135.66,51.71 135.66,51.76 135.65,51.77 135.65,52.11 135.65,52.11 135.65,52.12 135.65,52.12 135.66,52.12 136.33,52.79 136.33,57.16 135.26,58.23 135.26,60.57 134.9,60.93
  IN1 w0.119: 135.66,51.68 135.66,51.25 134.68,50.27 134.68,46.37 133.73,45.42 133.73,42.06 133.42,41.75 133.42,38.42 132.66,37.66 132.66,37.38 132.96,37.08 v1(133.22,37.08)
  IN3 w0.135: v1(133.22,37.08) 133.22,36.86 133.94,36.13 142.7,36.13 143.17,36.6 145.15,36.6 145.34,36.41 146.33,36.41 146.79,36.87 147.31,36.87 148.31,36.87 149.64,35.55 151.67,35.55 152.96,34.25 162.62,34.25 163.04,34.67 164.17,34.67 164.8,35.3 167.8,35.3 168.04,35.06 174.07,35.06 174.5,34.64 177.35,34.64 178.76,36.05 184.06,36.05 184.18,35.93 189.51,35.93 189.89,36.3 191.13,36.3 191.41,36.03 191.41,35.72 v1(191.6,35.53)
  BOTTOM w0.076: UC1.E20 v1(134.17,61.34)
SATA3_CTX_C_HDDRX_N0: length 4.5
  TOP w0.112: EU3101.2 EU3101.8 188.87,35.35 189.28,34.95 189.28,34.72 v1(189.14,34.57) 189.29,34.42 189.29,33.82 CS2.2
  BOTTOM w0.112: v1(189.14,34.57) 189.28,34.71 189.28,34.96 189.2,35.03 JHDD.18
SATA3_CTX_C_HDDRX_P0: length 4.5
  TOP w0.112: EU3101.1 EU3101.9 189.37,35.18 189.51,35.05 189.51,34.78 v1(189.72,34.57) 189.51,34.36 189.51,33.81 CS1.2
  BOTTOM w0.112: JHDD.19 189.7,35.09 189.51,34.9 189.51,34.78 v1(189.72,34.57)
SATA3_CTX_HDDRX_N0: length 89.9
  TOP w0.112: CS2.1 188.95,31.69 189.18,31.46 190.08,31.46 190.58,31.97 190.58,33.66 190.92,33.99 190.92,34.76 190.42,35.26 190.42,36.87 189.7,37.6 185.72,37.6 184.87,38.45 v4(184.87,39.76) 184.87,41.03 183.95,41.95 183.95,42.36 183.29,43.01 182.69,43.01 182.67,43.02 182.09,43.02 182.08,43.01 181.73,43.01 180.67,41.95 179.86,41.95 179.71,42.1 177.78,42.1 177.67,42.21 177.67,42.36 v1(177.85,42.55)
  IN3 w0.135: v1(147.3,63.94) 147.41,64.05 148.33,64.05 148.46,63.92 148.46,53.83 149.68,52.61 149.68,49.01 152.28,46.41 155.8,46.41 156.77,47.39 160.16,47.39 160.94,48.17 164.09,48.17 166.13,46.13 170.55,46.13 170.67,46.01 173.47,46.01 175.76,43.71 175.76,42.57 176.49,41.84 177.4,41.84 177.68,42.12 177.68,42.37 v1(177.85,42.55)
  BOTTOM w0.076: UC1.B21 136.03,62.1 136.45,61.8 137.34,61.8 137.95,62.41 137.95,62.54 138.58,63.17 138.75,63.17 138.79,63.13 138.8,63.13
  BOTTOM w0.112: 138.8,63.13 141.79,63.13 143.74,65.08 145.58,65.08 146.61,64.05 147.19,64.05 v1(147.3,63.94)
SATA3_CTX_HDDRX_P0: length 89.7
  TOP w0.112: CS1.1 189.84,32.13 189.74,32.04 189.27,32.04 189.17,31.94 189.17,31.79 189.27,31.68 189.99,31.68 190.36,32.06 190.36,33.75 190.7,34.08 190.7,34.67 190.2,35.17 190.2,36.78 189.6,37.38 185.63,37.38 184.65,38.35 184.65,39.48 184.64,39.49 184.64,40.03 184.65,40.04 184.65,40.94 183.73,41.86 183.73,42.27 183.2,42.79 v4(182.38,42.79) 181.82,42.79 180.76,41.73 179.77,41.73 179.62,41.88 177.69,41.88 177.45,42.12 177.45,42.36 v1(177.27,42.55)
  IN3 w0.135: v1(147.32,64.81) 147.27,64.75 147.27,64.56 147.54,64.29 148.5,64.29 148.7,64.09 148.7,53.93 149.93,52.71 149.93,49.11 152.38,46.66 155.7,46.66 156.67,47.63 160.06,47.63 160.84,48.41 164.19,48.41 166.23,46.37 170.65,46.37 170.77,46.25 173.57,46.25 176.01,43.81 176.01,42.67 176.59,42.08 177.3,42.08 177.44,42.22 177.44,42.37 v1(177.27,42.55)
  BOTTOM w0.076: UC1.A21 136.55,62.04 136.62,61.96 137.27,61.96 137.78,62.47 137.78,62.61 138.52,63.35 138.8,63.35
  BOTTOM w0.112: 138.8,63.35 141.7,63.35 143.65,65.3 145.67,65.3 146.7,64.27 147.05,64.27 147.13,64.35 147.37,64.35 147.5,64.48 147.5,64.67 147.36,64.81 v1(147.32,64.81)
SATA_CRX_C_ODDTX_N1: length 4.7
  TOP w0.112: CS10.1 189.59,65.18 189.59,65.62 v1(189.41,65.81)
  BOTTOM w0.112: JODD1.9 189.2,64.98 189.59,65.37 189.59,65.62 v1(189.41,65.81) 189.59,65.99 189.59,66.23 189.2,66.62 JODD1.10
SATA_CRX_C_ODDTX_P1: length 4.7
  TOP w0.112: CS9.1 189.81,65.19 189.81,65.62 v1(189.99,65.81)
  BOTTOM w0.112: JODD1.11 190.2,64.96 189.81,65.35 189.81,65.62 v1(189.99,65.81) 189.81,65.99 189.81,66.21 190.2,66.6 JODD1.12
SATA_CRX_ODDTX_N1: length 100.6
  TOP w0.112: CS10.2 189.7,63.37 189.7,62.35 189.41,62.05 v1(189.37,62.05)
  IN3 w0.076: v1(132.84,62.27) 132.89,62.22 133,62.22 133.13,62.35 133.13,62.54 133.02,62.65 131.71,62.65 131.26,62.2 131.26,61.44 131.26,61.44 131.26,58.65 131.64,58.27 131.64,56.9 132.24,56.29 135.45,56.29 135.83,56.67 137.58,56.67 137.63,56.72 137.66,56.72
  IN3 w0.135: v1(189.37,62.05) 189.75,61.67 189.75,59.09 186.61,55.95 185.6,55.95 183.72,54.07 183.5,54.07 182.08,52.65 182.08,51.44 182.36,51.17 182.36,43.47 178.72,39.84 174.18,39.84 173.61,40.4 165.83,40.4 165.53,40.1 164.03,40.1 163.09,39.16 158.96,39.16 158.13,39.99 151.16,39.99 150.5,40.66 148.82,40.66 148.31,41.16 148.31,46.93 148.04,47.2 146.54,47.2 145.48,48.27 145.48,50.48 144.88,51.08 144.88,53.05 141.21,56.72 137.66,56.72
  BOTTOM w0.076: v1(132.84,62.27) 132.95,62.27 133.05,62.18 133.05,62.07 132.7,61.72 132.6,61.72 UC1.G21
SATA_CRX_ODDTX_P1: length 100.8
  TOP w0.112: CS9.2 189.92,63.58 189.92,62.11 v1(189.99,62.05)
  IN3 w0.076: 137.66,56.48 135.88,56.48 135.52,56.12 132.17,56.12 131.47,56.83 131.47,58.2 131.09,58.58 131.09,61.5 131.1,61.51 131.1,62.27 131.64,62.82 133.09,62.82 133.48,62.43 v1(133.48,62.27)
  IN3 w0.135: 137.66,56.48 141.11,56.48 144.64,52.95 144.64,50.98 145.24,50.38 145.24,48.17 146.44,46.96 147.94,46.96 148.07,46.83 148.07,41.06 148.72,40.42 150.4,40.42 151.06,39.75 158.03,39.75 158.86,38.91 163.19,38.91 164.13,39.86 165.63,39.86 165.93,40.16 173.51,40.16 174.08,39.6 178.82,39.6 182.6,43.37 182.6,51.27 182.32,51.54 182.32,52.55 183.6,53.83 183.82,53.83 185.7,55.71 186.71,55.71 189.99,58.99 v1(189.99,62.05)
  BOTTOM w0.076: UC1.F21 133.48,62.1 v1(133.48,62.27)
SATA_CTX_C_ODDRX_N1: length 4.7
  TOP w0.112: v1(187.01,65.81) 186.83,65.62 186.83,65.19 CS11.1
  BOTTOM w0.112: JODD1.5 187.2,64.98 186.81,65.36 186.81,65.61 v1(187.01,65.81) 186.83,65.99 186.83,66.24 187.2,66.61 JODD1.6
SATA_CTX_C_ODDRX_P1: length 4.7
  TOP w0.112: CS12.1 186.61,65.18 186.61,65.62 v1(186.43,65.81)
  BOTTOM w0.112: JODD1.3 186.2,64.98 186.59,65.37 186.59,65.64 v1(186.43,65.81) 186.61,65.99 186.61,66.31 186.2,66.72 JODD1.4
SATA_CTX_ODDRX_N1: length 100.6
  TOP w0.112: v1(188.49,62.08) 188.46,62.11 188.46,62.57 187.87,63.17 187.45,63.17 187.23,63.38 CS11.2
  IN3 w0.135: v1(147.32,66.09) 147.15,65.92 146.78,65.92 146.51,65.65 146.51,60.4 147.78,59.13 147.78,53.49 148.99,52.29 148.99,48.21 149.54,47.66 149.54,43.19 150.12,42.61 150.12,41.65 151.35,40.43 158.31,40.43 159.15,39.6 162.9,39.6 163.86,40.55 165.35,40.55 165.66,40.86 173.87,40.86 174.45,40.28 178.3,40.28 178.67,40.65 179.89,41.86 179.89,47.27 180.21,47.6 180.21,48.45 181.45,49.69 181.45,50.53 181.64,50.71 181.64,52.84 182.7,53.89 182.7,54.57 183.24,55.11 184.11,55.11 185.39,56.39 186.29,56.39 188.49,58.6 v1(188.49,62.08)
  BOTTOM w0.076: 138.8,63.99 138.79,63.99 138.76,63.96 138.42,63.96 137.45,62.99 137.45,62.61 137.25,62.4 136.95,62.4 136.86,62.49 136.77,62.49 136.76,62.5 136.33,62.5 136.32,62.49 136.12,62.49 136.11,62.5 135.73,62.5 135.54,62.41 135.53,62.4 135.17,62.4 134.85,62.08 UC1.D21
  BOTTOM w0.112: 138.8,63.99 141.38,63.99 v4(142.46,65.06) 143.49,66.09 v1(147.32,66.09)
SATA_CTX_ODDRX_P1: length 100.4
  TOP w0.112: CS12.2 186.43,63.87 187.35,62.94 187.78,62.94 188.19,62.53 188.19,62.36 187.91,62.08 v1(187.91,62.08)
  IN3 w0.135: v1(147.32,65.51) 147.15,65.68 146.88,65.68 146.75,65.55 146.75,60.5 148.02,59.23 148.02,53.59 149.23,52.39 149.23,48.31 149.78,47.76 149.78,43.29 150.36,42.71 150.36,41.75 151.45,40.67 158.41,40.67 159.25,39.84 162.8,39.84 163.76,40.79 165.25,40.79 165.56,41.1 173.97,41.1 174.55,40.52 178.2,40.52 178.5,40.82 178.5,40.82 179.65,41.96 179.65,47.37 179.97,47.7 179.97,48.55 181.21,49.79 181.21,50.63 181.4,50.81 181.4,52.94 182.46,53.99 182.46,54.67 183.14,55.35 184.01,55.35 185.29,56.63 186.19,56.63 188.25,58.7 188.25,61.64 187.91,61.98 v1(187.91,62.08)
  BOTTOM w0.076: 138.8,63.77 138.71,63.77 138.68,63.79 138.49,63.79 137.62,62.92 137.62,62.54 137.31,62.24 136.88,62.24 136.79,62.33 136.7,62.33 136.7,62.33 136.4,62.33 136.39,62.33 136.05,62.33 136.05,62.33 135.77,62.33 135.65,62.27 135.61,62.24 135.61,62.16 135.44,61.99 135.33,61.99 UC1.C21
  BOTTOM w0.112: 138.8,63.77 141.47,63.77 142.39,64.69 142.42,64.69 142.84,65.1 142.84,65.13 143.58,65.87 146.04,65.87 146.15,65.76 146.15,65.51 146.28,65.38 146.48,65.38 146.59,65.49 146.59,65.76 146.7,65.87 146.96,65.87 147.32,65.51 v1(147.32,65.51)
SATA_LED#: length 269.9
  TOP w0.089: Q25.2 52.3,106.16 52.03,105.89 50.61,105.89 R81.1 48.22,103.5 47.48,103.5 v1(47.23,103.24)
  IN1 w0.089: v1(35.45,61.74) 35.7,61.5 37.66,61.5 38.27,60.89 45.78,60.89 48.62,58.05 v1(50.33,58.05)
  IN2 w0.089: v1(35.45,61.74) 34.04,61.74 31.67,59.38 30.89,59.38 29.01,57.5 29.01,56.26 25.51,52.75 25.25,52.75 22.42,49.92 22.42,44.42 22.67,44.17 22.67,43.35 22.5,43.19 22.5,36.91 24.78,34.63 27.72,34.63 28.71,33.64 29.09,33.64 29.63,33.11 29.63,32.36 30.81,31.18 30.81,30.5 v1(30.72,30.41) ; v1(137.26,44.7) 136.66,45.3 135,45.3 133.28,43.58 133.28,42.87 132.99,42.59 129.68,42.59 128.17,44.1 125.72,44.1 124.46,42.84 124.46,41.95 124.46,41.51 123.47,40.52 121.24,40.52 120.87,40.9 120.27,40.9 120.22,40.85 119.6,40.85 119.12,41.33 118.4,41.33 117.56,40.49 117.08,40.49 114.35,43.22 112.03,43.22 109.12,40.3 109.12,39.63 109.05,39.56 107.56,38.07 105.53,38.07 105.36,37.89 98.85,37.89 98.39,38.36 97.22,38.36 96.52,37.66 94.53,37.66 94.24,37.37 91.38,37.37 90.85,37.9 87.24,37.9 87,37.67 84.9,37.67 84.29,37.06 83.38,37.06 81.54,35.21 75.93,35.21 75.47,34.75 72.44,34.75 71.83,35.36 70.12,35.36 69.69,35.8 68.68,35.8 68.03,35.14 62.32,35.14 57.72,39.73 54.68,39.73 51.63,42.78 51.63,46.83 50.41,48.05 50.41,52 51.15,52.74 51.15,55.92 50.69,56.38 50.69,57.68 v1(50.33,58.05) 50.33,58.28 50.54,58.49 50.54,63.65 51.11,64.22 51.11,67.42 50.14,68.39 49.75,68.39 48.94,69.2 48.94,72.43 46.64,74.73 46.64,87.26 49.27,89.89 49.27,96.81 47.79,98.28 47.79,102.68 v1(47.23,103.24)
  BOTTOM w0.076: UC1.H1 132.37,50.25 132.93,49.69 133.28,49.69 133.28,49.69 133.41,49.69 133.57,49.53
  BOTTOM w0.089: 133.57,49.53 134.88,48.22 134.88,47.76 135.26,47.37 135.26,46.7 v1(137.26,44.7) 137.29,44.7 137.81,45.21 139.26,45.21 142.39,42.09 142.56,42.09 143.56,41.09 v2(143.7,41.09) 143.7,40.24 RC69.1 ; v1(30.72,30.41) 30.96,30.17 30.96,28.88 31.58,28.25 34.64,28.25 36.39,30.01 40.65,30.01 41.08,29.58 41.08,24.53 R77.2
SATA_LED#_R: length 8.5
  TOP w0.089: R83.2 53.97,107.64 53.53,107.2 Q25.3 52.95,106.42 52.1,105.58 v2(51.28,105.58) 50.75,105.58 50.38,105.21 R81.2 50.38,103.37 Q22.3
SATA_ODD_DA#: length 9.2
  BOTTOM w0.089: TP46.1 199.53,62.62 196.59,62.62 196.2,63.01 JODD1.23 JODD1.24
SATA_ODD_PRSNT#: length 179.5
  TOP w0.089: v1(192.57,62.39) 192.57,63.56 RC194.1
  IN1 w0.089: v1(192.57,62.39) 192.57,61.81 192.92,61.45 194.06,61.45 197.1,58.42 203.19,58.42 203.65,57.96 208.32,57.96 208.69,58.34 214.41,58.34 215.81,56.93 218.62,56.93 220.49,55.07 220.49,47.16 220.01,46.68 220.01,41.19 218.28,39.47 218.28,38.51 215.46,35.69 215.46,33.63 214.65,32.82 212.34,32.82 210.12,30.6 193.38,30.6 192.88,31.1 185.1,31.1 184.41,31.79 182.24,31.79 180.36,29.91 180.36,28.88 179.44,27.96 177.12,27.96 176.7,28.38 173.65,28.38 172.82,27.56 165.39,27.56 v1(164.71,26.88)
  IN2 w0.089: 125.75,49.02 v1(125.45,49.02)
  IN2 w0.102: 125.75,49.02 127.24,47.53 127.24,46.31 127.54,46.01 128.08,46.01 130.25,43.83 131.7,43.83 132.26,44.4 132.26,46.74 133.04,47.52 134.86,47.52 v1(135.25,47.91)
  BOTTOM w0.076: v1(125.45,49.02) 125.3,49.17 125.3,49.77 UC1.AB1
  BOTTOM w0.089: v1(164.71,26.88) 164.17,26.34 157.85,26.34 155.7,28.49 148.55,28.49 143.78,33.26 143.78,35.24 144.6,36.05 v2(145.07,36.05) 145.07,37.18 145.25,37.36 145.25,38.55 145.17,38.63 145.17,40.65 144.13,41.68 143.27,41.68 142.68,42.27 142.47,42.27 139.34,45.4 137.77,45.4 v1(135.25,47.91) ; JODD1.16 JODD1.15 192.2,63.76 192.57,63.39 v1(192.57,62.39)
SCLK_CPU: length 2
  BOTTOM w0.203: PRZ46.1 176.97,60.18 176.97,59.79 176.83,59.64 PUZ01.34
SD_RCOMP: length 1.6
  TOP w0.089: RC130.1 123.94,53.69 v1(124.84,53.69)
  BOTTOM w0.076: v1(124.84,53.69) 125.16,53.37 UC1.AB7
SD_READ_MODE: length 128.7
  TOP w0.089: v3(125.46,39.06) 125.17,38.77 v1(124.77,38.77)
  IN1 w0.076: 120.12,48.68 120.12,51.58 120.01,51.69 v1(120.01,53.08)
  IN1 w0.102: 120.12,48.68 120.12,48.25 119.4,47.53 119.4,45.35 121.57,43.18 121.57,41.85 122.24,41.18 122.35,41.18 124.77,38.77 124.77,38.77 124.77,38.77 v1(124.77,38.77)
  IN2 w0.089: v1(213.43,34.03) 213.87,33.59 214.45,33.59 214.69,33.83 214.69,36.56 v1(213.27,37.97)
  IN3 w0.089: v1(213.43,34.03) 212.96,33.56 211.66,33.56 210.19,32.09 196.64,32.09 195.84,32.89 192.98,32.89 192.32,32.23 187.82,32.23 187.59,32.45 185.79,32.45 185.47,32.77 180.23,32.77 179.03,31.57 174.79,31.57 173.48,30.26 170.98,30.26 v1(168.83,28.11)
  BOTTOM w0.076: v1(120.01,53.08) 119.63,52.71 UC1.AN5
  BOTTOM w0.089: v1(124.77,38.77) 124.86,38.67 124.86,36.96 126.68,35.15 127.87,35.15 129.88,33.13 131.22,33.13 131.96,32.39 132.98,32.39 133.68,31.7 133.68,30.72 134.45,29.94 136.54,29.94 139.87,33.27 143.23,33.27 148.44,28.06 155.57,28.06 157.75,25.88 166.6,25.88 v1(168.83,28.11) ; JIOB1.1 213.24,37.94 v1(213.27,37.97)
SDIO_CPU: length 2.5
  BOTTOM w0.203: PRZ48.1 175.92,60.94 176.34,60.52 176.34,60.14 176.03,59.83 PUZ01.32
SIO_EXT_WAKE#: length 136.3
  TOP w0.089: v2(121.83,47.58) 122.08,47.33 v1(122.4,47.33)
  TOP w0.102: v1(37.75,74.32) 37.64,74.21 UE1.116
  IN1 w0.102: v1(37.75,74.32) 37.85,74.22 46.84,74.22 47.71,75.09 49.53,75.09 v1(49.8,74.81)
  IN2 w0.102: v1(122.4,47.33) 122.49,47.33 122.97,47.81 123.22,47.81 123.81,47.23 123.81,46.34 123.54,46.07 121.27,46.07 121.1,45.89 119.4,45.89 118.8,46.49 117.87,46.49 117.61,46.23 113.78,46.23 113.35,45.81 111.22,45.81 107.91,42.49 105.41,42.49 105.19,42.72 98.66,42.72 96.07,40.12 92.71,40.12 92.01,40.83 92.01,41.49 91.65,41.84 82.65,41.84 81.8,40.99 81.8,40.44 79.47,38.1 73.52,38.1 73.02,37.61 71.05,37.61 70.62,38.05 61.61,38.05 58.35,41.3 56.44,41.3 53.18,44.56 53.18,48.02 52.57,48.63 52.57,50.56 51.9,51.23 51.9,56.23 51.44,56.69 51.44,60.45 52.67,61.68 52.67,63.41 51.73,64.34 51.73,65.29 51.67,65.35 51.67,68.41 50.55,69.53 50.55,71.58 50.29,71.84 50.29,74.33 v1(49.8,74.81)
  BOTTOM w0.076: 123.33,49.18 123.33,50.19 123.38,50.29 123.38,50.79 123.75,51.16 UC1.AD3
  BOTTOM w0.102: 123.33,49.18 123.35,49.16 ; RC47.1 122.3,47.08 122.4,47.18 v1(122.4,47.33)
  BOTTOM w0.112: 123.35,49.16 123.35,48.14 123.26,48.05 123.26,47.99 122.6,47.34 122.4,47.34 v1(122.4,47.33)
SIO_PWRBTN#: length 114.1
  TOP w0.089: RC93.2 106.42,56.79 v2(109.79,56.79) 110.36,56.79 110.39,56.77 111.19,56.77 v1(111.25,56.83)
  TOP w0.102: v1(52.73,76.81) 52.52,77.01 UE1.52
  IN3 w0.102: v1(101.62,44.97) 101.39,44.74 101.39,43.46 100.18,42.25 98.93,42.25 97.72,42.25 96,43.97 88.51,43.97 87.88,43.34 84.94,43.34 84.21,42.6 82.82,42.6 81.55,41.33 80.73,41.33 79.92,40.52 79.77,40.37 79.33,40.37 79.21,40.49 79.21,40.88 79,41.08 77.83,41.08 77.28,40.52 76.39,40.52 75.78,39.91 73.29,39.91 72.55,40.65 69.46,40.65 68.75,41.36 62,41.36 60.99,42.37 60.56,42.37 58.61,44.33 58.61,44.49 58.16,44.94 58.16,44.94 58.15,44.95 58.15,49.11 56.93,50.33 56.85,50.33 56.55,50.63 56.55,51.24 56.02,51.77 55.6,51.77 55.38,52 55.38,52.69 54.77,53.3 54.77,65.73 52.45,68.06 52.45,69.14 52.15,69.43 52.15,76.23 v1(52.73,76.81)
  BOTTOM w0.076: UC1.BA15 114.32,58.54 114.07,58.28 113.77,58.28 113.54,58.51 113.38,58.51 112.87,58 112.41,58 111.25,56.84 v1(111.25,56.83) 110.82,56.4 109.14,56.4 108.41,55.67 107.74,55.67 105.42,53.35
  BOTTOM w0.089: 105.42,53.35 103.55,51.48 103.55,50.8 103.27,50.51 102.58,50.51 102.09,50.02 102.09,46.52 101.63,46.06 101.63,44.97 v1(101.62,44.97)
SIO_SLP_A#: length 1.9
  TOP w0.089: v1(119.19,59.52) 119.42,59.52 119.83,59.94 TPS6.1
  BOTTOM w0.102: v1(119.19,59.52) UC1.AN16
SIO_SLP_LAN#: length 31.8
  TOP w0.089: 117.6,56.31 117.27,56.31 116.98,56.6 116.98,58.11 v1(117.4,58.53) 116.85,58.53 TP10.1
  TOP w0.102: 117.6,56.31 117.67,56.23 117.73,56.09 117.73,55.83 118.31,55.25 118.86,55.25 119.11,55 119.11,53.73 118.88,53.5 118.88,52.67 118.73,52.52 118.73,52.38 118.26,51.91 117.76,51.91 117.43,51.58 117.43,50.12 116.9,49.59 114.67,49.59 114.1,49.02 112.16,49.02 111.7,48.56 111.7,46.91 110.61,45.83 110.08,45.83 108.72,44.47 108.72,43.8 107.83,42.9 107.57,42.9 106.88,42.22 106.88,42.12 105.95,41.18 105.95,40.34 RC88.1
  BOTTOM w0.076: v1(117.4,58.53) 117.4,58.53 117.4,58.52 117.34,58.58 UC1.AW15
SIO_SLP_S0#: length 278.5
  TOP w0.089: RE90.2 36.91,86.26 v1(36.13,87.04) ; 119.45,51.17 119.45,51.67 119.65,51.87 119.65,52.53 TPS2.1 119.62,53.32 119.31,53.63 119.31,55.08 119.17,55.22 119.15,55.22 118.93,55.44 118.42,55.44 118.12,55.74 118.12,56.29 v1(118.66,56.82) ; v1(113.91,34.25) 113.91,32.24 112.41,30.74 112.05,30.38 111.59,30.38 111.12,29.9 111.12,29.45 110.45,28.77 108,28.77 106.84,27.61 106.27,27.61 105.8,27.14 v1(105.8,26.88)
  TOP w0.102: 119.45,51.17 116.46,48.18 116.46,46.14 117.69,44.91 119.79,44.91 120.25,44.45 120.25,44.05 121.04,43.26 121.04,41.51 v1(121.4,41.16) ; v1(141.43,84.26) 142.53,85.36 142.53,87.96 144.02,89.45 UC9.2
  IN1 w0.102: v1(149.23,67.03) 149.23,68.18 143.77,73.64 143.77,76.38 143.01,77.14 143.01,82.46 141.46,84.01 141.46,84.23 v1(141.43,84.26) ; v1(147.45,49.51) 147.89,49.95 147.89,52.7 146.78,53.82 146.78,59.58 145.89,60.46 145.89,66.31 v1(145.3,66.91)
  IN2 w0.089: v1(105.95,32.44) 105.58,32.81 101.16,32.81 100.62,32.28 97.36,32.28 96.36,31.28 91.56,31.28 90.39,30.11 79.77,30.11 79.33,30.54 78.74,30.54 78.58,30.39 76.5,30.39 76.39,30.5 70.96,30.5 70.59,30.87 66.12,30.87 65.52,31.47 61.04,31.47 56.26,36.25 52.69,36.25 48.65,40.28 48.65,41.41 45.93,44.13 45.93,47.57 46.34,47.98 46.34,50.06 45.76,50.64 45.76,52.98 46.89,54.11 46.89,61.06 46.33,61.63 46.33,62.8 46.6,63.07 46.6,64.18 45.73,65.06 45.73,66.01 43.05,68.69 42.6,68.69 41.73,69.56 41.73,75.44 39.28,77.88 39.28,78.74 39.05,78.96 39.05,82.78 38.39,83.45 38.39,84.78 v1(36.13,87.04)
  IN2 w0.102: v1(147.45,49.51) 147.26,49.32 147.26,48.22 150.27,45.2 150.27,40.91 149.6,40.24 147.48,40.24 146.86,40.86 143.67,40.86 143.32,41.22 142.94,41.22 139.98,44.18 139.98,45.12 138.25,46.85 135.45,46.85 134.98,47.32 133.13,47.32 132.46,46.65 132.46,44.31 131.17,43.02 129.92,43.02 129.22,43.72 129.22,44.59 128.33,45.48 126.53,45.48 124.09,43.04 124.09,41.67 123.33,40.91 121.64,40.91 v1(121.4,41.16)
  IN3 w0.102: v1(105.95,32.44) 106.23,32.44 107.27,33.47 110.4,33.47 111.58,34.65 113.51,34.65 v1(113.91,34.25) 113.95,34.28 118.71,34.28 121.05,36.62 121.05,40.81 v1(121.4,41.16)
  BOTTOM w0.089: v1(105.95,32.44) 105.75,32.64 105.75,33.59 RX10.2 ; v1(105.8,26.88) 105.8,27.31 RX9.2 ; v1(149.23,67.03) 149.1,66.91 v1(145.3,66.91)
  BOTTOM w0.102: UC1.AT11 118.18,56.8 118.64,56.8 v1(118.66,56.82)
SIO_SLP_S3#: length 259.9
  TOP w0.089: v1(135.26,44.2) 135.26,44.18 136.72,45.65 139.51,45.65 141.93,43.22 141.93,42.13 145.04,39.02 146.61,39.02 v1(148.94,41.36) ; TPS3.1 118.84,59.08 119.17,58.75 119.17,58.07 119.21,58.03 v1(119.21,57.65)
  TOP w0.102: v1(146.2,94.81) 146.04,94.65 146.04,91.42 RZ2.1 145.79,90.39 145.5,90.1 UC9.1
  TOP w0.203: UZ3.5 37.31,57.63 37.25,57.57 36.71,57.57 36.5,57.78 v1(36.5,58.01) 36.5,58.23 36.74,58.47 37.23,58.47 37.27,58.43 UZ3.3
  IN1 w0.089: v1(33.02,59.57) 33.5,59.08 33.5,57.56 34.27,56.8 34.27,53.91 35.77,52.41 36.25,52.41 37.22,51.44 37.22,50.13 37.03,49.94 37.03,47.2 40.82,43.42 43.04,43.42 43.16,43.29 44.64,43.29 45.06,43.71 53.62,43.71 53.75,43.84 56.47,43.84 56.8,44.18 57.54,44.18 57.64,44.28 62.56,44.28 63.74,43.11 63.74,41.59 64.82,40.51 70.44,40.51 71.74,39.21 72.74,39.21 73.08,38.87 75.54,38.87 76.21,38.19 83.21,38.19 83.85,38.83 85.35,38.83 85.44,38.92 85.68,38.92 86.2,39.44 91.38,39.44 91.99,38.82 96.52,38.82 97.01,38.33 98.35,38.33 99.06,37.62 102.42,37.62 102.93,37.12 v1(102.93,36.89)
  IN2 w0.089: v1(135.26,44.2) 135.26,44.12 134.77,43.63 134.13,43.63 133.82,43.32 133.82,42.64 133.16,41.98 127.69,41.98 127.13,41.42 125.1,41.42 123.77,40.09 122.59,40.09 122.06,39.56 121.43,39.56 120.72,40.27 119.36,40.27 119.25,40.17 118.78,40.17 118.61,40 117.62,40 115.3,37.68 114.94,37.68 114.23,36.98 107.56,36.98 106.42,35.83 105.01,35.83 104.57,36.28 103.3,36.28 102.93,36.65 v1(102.93,36.89)
  IN3 w0.076: 111.69,48.91 111.69,48.93 112.16,49.4 112.16,49.98 112.81,50.63 113.4,50.63 113.93,51.16 116.94,51.16 118.47,52.7 118.47,53.05 120.39,54.97 120.39,57.09 120.21,57.27 119.59,57.27 v1(119.21,57.65)
  IN3 w0.089: v1(36.5,58.01) 35.98,58.01 35.26,58.73 33.85,58.73 v1(33.02,59.57)
  IN3 w0.102: v1(146.2,94.81) 146.07,94.68 146.07,92.89 149.13,89.83 149.13,88.43 148.18,87.47 v1(147.95,87.47) 147.34,87.47 147.14,87.27 147.14,81.49 147.61,81.03 149.18,81.03 149.57,80.64 149.57,71.29 147.48,69.19 146.61,69.19 144.61,67.19 144.61,62.01 144.33,61.73 144.33,59.08 145.53,57.89 145.53,57.72 145.73,57.51 146.52,57.51 146.78,57.25 146.78,53.75 145.3,52.27 145.3,51.26 145.9,50.66 145.9,48.59 146.87,47.63 148.21,47.63 148.74,47.1 148.74,41.56 v1(148.94,41.36) ; v1(102.93,36.89) 102.93,37.23 103.14,37.45 103.56,37.45 105.54,39.43 107.79,39.43 108.25,39.89 108.25,42.89 109.79,44.43 109.79,45.23 111.35,46.78 111.35,48.56 111.69,48.91
  BOTTOM w0.076: v1(119.21,57.65) 119.21,57.91 UC1.AP15
  BOTTOM w0.102: DZ4.1 147.02,88.25 RC103.1 147.45,87.93 147.91,87.47 v1(147.95,87.47)
SIO_SLP_S4#: length 313
  TOP w0.089: v1(76.51,43.14) 76.51,42.48 74.69,40.65 74.69,37.37 73.97,36.66 73.97,34.91 73.15,34.09 73.15,32.92 72.47,32.25 72.47,26.59 v1(72.68,26.39) ; v1(159.63,26.88) 159.63,27.38 159.62,27.4 TPS4.1 159.62,28.2 160.3,28.88 DZ5.1 161.07,28.88 161.12,28.93 161.12,28.93 161.23,29.05 RZ1.1
  TOP w0.254: PRM08.1 32.71,28.28 32.41,28.58 32.2,28.58 v1(31.84,28.94) ; v1(73.11,111.64) PR2501.1
  IN3 w0.089: v1(73.11,111.64) 64.75,111.64 62.98,109.86 58.63,109.86 55.79,107.02 55.79,79.54 56.24,79.09 56.24,71.61 55.41,70.77 55.41,66.49 56.08,65.82 56.08,63.27 56.73,62.62 57.62,62.62 58.19,62.04 58.19,51.53 59.59,50.13 59.59,45.55 60.2,44.94 60.6,44.94 61.19,44.35 63.26,44.35 63.81,43.81 70.01,43.81 71.54,42.28 73.65,42.28 74.51,43.14 v1(76.51,43.14) 76.75,43.37 78.48,43.37 78.69,43.58 81.68,43.58 82.25,44.15 83.72,44.15 84.35,44.78 87.22,44.78 88.03,45.59 94.99,45.59 100.11,50.71 101.95,50.71 v1(102.17,50.92) ; 32.94,29.22 32.66,28.94 v1(31.84,28.94)
  IN3 w0.102: 32.94,29.22 35.16,29.22 36.17,30.23 37.77,30.23 39.41,31.87 45.62,31.87 47.96,34.22 50.88,34.22 51.39,33.71 53.63,33.71 55.06,32.28 55.72,32.28 56.63,31.37 57.07,31.37 59.14,29.29 64.09,29.29 65.8,27.58 72.11,27.58 72.68,27.01 v1(72.68,26.39) 72.68,25.76 72.93,25.52 93.28,25.52 94.13,26.36 97.2,26.36 97.58,25.99 97.83,25.74 97.96,25.6 112.36,25.6 113.08,26.32 113.67,26.32 114.01,26.66 116.52,26.66 117.17,26.01 131.33,26.01 132.23,26.91 134.93,26.91 138.59,30.56 141.35,30.56 143.86,28.06 143.86,27.08 144.94,26 147.9,26 148.43,26.53 155.74,26.53 156.09,26.88 v1(159.63,26.88)
  BOTTOM w0.076: UC1.BA16 114.87,59.14 113.32,59.14 112.67,58.49 112.18,58.49 111.76,58.07 108.19,58.07 107.23,57.11
  BOTTOM w0.112: v1(102.17,50.92) 102.22,50.97 102.22,52.76 103.03,53.58 104.12,53.58 107.23,56.69 107.23,57.11
SIO_SLP_S5#: length 5
  TOP w0.089: TPS5.1 111.07,58.46 111.62,58.46 v1(111.62,58.46)
  BOTTOM w0.076: UC1.AY16 115.4,59.31 115.2,59.31 115.03,59.48 114.74,59.48 114.56,59.3 113.25,59.3 112.6,58.65 111.82,58.65 v1(111.62,58.46)
SIO_SLP_SUS#: length 314.4
  TOP w0.089: v1(118.73,58.61) 117.75,57.63 117.75,57.31 117.86,57.2 119.13,57.2 119.34,56.99 119.34,56.76 119.6,56.5 119.6,55.22 119.54,55.15 119.54,53.68 119.68,53.54 120.11,53.54 120.38,53.27 120.38,52.92 119.92,52.46 119.92,51.85 119.66,51.59 119.66,51.07 116.65,48.05 116.65,46.22 117.77,45.1 119.86,45.1 120.44,44.53 120.44,44.13 121.23,43.34 121.23,41.88 122.4,40.71 123.35,40.71 124.23,41.59 125.99,41.59 126.22,41.83 126.22,42.35 127.07,43.2 127.07,43.93 127.44,44.29 128.44,44.29 129.59,45.44 132.79,45.44 133.54,44.7 133.54,43.92 134.01,43.44 135.6,43.44 136.07,43.66 137.09,43.66 138.42,43.6 139.52,43.15 139.78,42.89 140.98,41.38 141.19,41.06 141.19,38.74 143.33,36.6 144.53,36.6 144.97,36.16 146.41,36.16 146.91,36.66 147.41,36.66 149.9,34.17 149.9,32.67 151.64,30.93 151.64,27.33 v1(151.25,26.93) ; v1(55.35,91.5) 53.34,91.5 v2(53.23,91.4) 52.96,91.12 51.67,91.12 v1(51.3,91.49) ; RE88.2 29.73,72.26 v1(30.16,71.83)
  IN1 w0.089: v1(41.56,87.81) 42.08,87.29 42.68,87.29 43.98,88.59 48.41,88.59 v1(51.3,91.49)
  IN2 w0.089: v1(170.8,27.14) 170.7,27.03 166.51,27.03 165.4,28.15 163.93,28.15 163.04,27.26 155.95,27.26 155.72,27.49 151.25,27.49 v1(151.25,26.93)
  IN2 w0.254: v1(166.21,45.68) 166.8,46.26 168.27,46.26 168.63,46.62 170.79,46.62 171.61,45.79 173.11,45.79 173.8,46.48 v1(175.1,46.48) 175.18,46.55 175.18,47.56 174.63,48.11 172.42,48.11 171.81,47.49 170.86,47.49 170.52,47.84 170.52,50.58 170.09,51.01 170.09,51.51 167.97,53.63 v1(167.19,53.63)
  IN3 w0.076: v1(118.73,58.61) 118.49,58.61 118.05,58.17 116.38,58.17 115.4,57.2 114.88,57.2 113.97,56.28 113.08,56.28 110.78,53.98 109.83,53.98 109.25,53.41 109.25,52.81 108.89,52.45 108.24,52.45 107.28,51.49
  IN3 w0.089: v1(30.16,71.83) 31.75,71.83 33.18,70.4 37.42,70.4 37.76,70.07 37.76,68.99 38.1,68.65 39.03,68.65 39.57,69.19 39.57,73.25 39.87,73.55 39.87,76.89 38.77,77.99 38.77,78.5 38.51,78.76 38.51,83.45 38.83,83.78 38.83,85.01 41.56,87.73 v1(41.56,87.81) ; 107.22,51.42 107.28,51.49
  IN3 w0.102: 107.22,51.42 105.97,50.18 102.68,50.18 98.88,46.38 98.88,43.68 98.71,43.5 98.24,43.5 96.34,45.4 88.11,45.4 87.3,44.59 84.43,44.59 83.8,43.96 82.42,43.96 81.03,42.58 79.51,42.58 79.45,42.64 78.38,42.64 78.28,42.54 77.55,42.54 77.51,42.58 76.69,42.58 76.65,42.55 76.64,42.55 75.37,41.28 74.76,41.28 73.96,42.09 71.46,42.09 70.08,43.47 63.88,43.47 63.19,44.16 61.11,44.16 60.52,44.75 60.12,44.75 59.4,45.47 59.4,50.05 58,51.45 58,60.96 57.12,61.84 56.51,61.84 55.89,62.47 55.89,65.74 53.98,67.65 53.98,73.92 55.31,75.25 55.31,78.89 53.12,81.09 53.12,81.34 52.38,82.08 52.38,83.54 55.35,86.51 v1(55.35,91.5)
  BOTTOM w0.076: UC1.AN15 119.17,58.61 118.74,58.61 118.74,58.61 v1(118.73,58.61)
  BOTTOM w0.089: v1(175.1,46.48) 175.1,45.04 175.57,44.57 175.57,41.9 173.81,40.13 173.81,39.15 170.81,36.16 170.81,32.14 171.04,31.91 171.04,29.76 170.34,29.06 170.34,27.59 v1(170.8,27.14)
  BOTTOM w0.254: v1(166.21,45.68) 166.21,45.84 PR1806.1 ; v1(167.19,53.63) 166.61,54.21 PRH13.1
SIO_SLP_WLAN#: length 2.7
  BOTTOM w0.076: UC1.BB17 113.06,59.73 112.44,59.11 TP11.1
SLEEVE:
  vias: v2(26.96,17.56)
SLEEVE_R: length 38.8
  IN1 w1.016: JHP1.3 4.87,17.4 6.02,18.55 13.41,18.55 13.89,19.03 14.91,19.03 15.92,18.01 15.92,11.01 16.09,10.85 16.09,10.4 17.48,9
  IN3 w1.016: 18.42,11.59 18.09,11.92 17.14,11.92 16.47,12.59 16.47,13.37 17.01,13.92 17.01,17.32 19.64,19.95 19.64,20.61 20.15,21.12 20.15,21.12 21.4,22.37 23.42,22.37
  vias: v1(17.94,8.06) v1(18.24,10.73) v1(18.53,8.06) v1(18.82,10.73) v1(24.47,22.07) v1(24.47,21.48) v2(18.54,11.16)
SM_RCOMP0: length 15
  TOP w0.254: 114.53,59.94 v2(115.45,59.94) 117.52,59.94 v1(118.03,60.45)
  TOP w0.381: RC10.1 104.25,60.49 104.91,59.83 114.41,59.83 114.53,59.94
  BOTTOM w0.254: v1(118.03,60.45) 118.03,60.28 UC1.AR18
SM_RCOMP1: length 13.7
  TOP w0.254: v1(117.34,60.43) 117.34,60.47 116.9,60.91 116.9,61
  TOP w0.381: RC11.1 105.44,61.85 106.65,61.85 107.13,61.38 v2(107.73,61.38) 116.51,61.38 116.9,61
  BOTTOM w0.254: UC1.AT18 117.68,60.08 v1(117.34,60.43)
SM_RCOMP2: length 11.5
  TOP w0.381: RC12.1 v2(110.91,60.49) 111.18,60.49 111.59,60.91 116.27,60.91 v1(116.71,60.47)
  BOTTOM w0.254: UC1.AU18 116.71,60.29 v1(116.71,60.47)
SMB_ALERT#: length 2.3
  TOP w0.089: RC37.1 127.49,56.1 v2(127.53,56.06) 127.85,55.74 v1(127.92,55.74)
  BOTTOM w0.102: v1(127.92,55.74) 127.96,55.7 128.19,55.7 UC1.R10
SML0_SMBCLK: length 2.4
  TOP w0.089: CC95.1 126.53,53.96 RC33.1 127.82,53.96 v1(128.15,54.29)
  BOTTOM w0.076: v1(128.15,54.29) 128.54,54.67 UC1.R9
SML0_SMBDATA: length 6
  BOTTOM w0.076: UC1.W2 126.29,50.53 126.15,50.08 126.15,49.84 126.48,49.52 126.48,49.06
  BOTTOM w0.102: 126.48,49.06 126.72,48.81
  BOTTOM w0.112: RC34.1 128.88,46.4 128.23,47.05 127.86,47.05 v2(127.44,47.47) 126.72,48.19 126.72,48.81
SML1_SMBCLK: length 394.9
  TOP w0.112: v1(131.04,47.13) 131.13,47.22 132.1,47.22 132.16,47.15 134.1,47.15 135.12,46.13 139.71,46.13 142.42,43.41 142.42,42.32 143.71,41.03 144.42,41.03 CC96.1 145.39,41.3 147.72,41.3 148.89,42.46 150.49,42.46 v1(151,41.95) ; RE11.1 41.77,62.49 41.77,62.84 v1(41.91,62.98) ; QV1.6 123.66,121.95 v1(123.42,121.71) ; v1(184.19,66.16) 184.02,66.34 183.83,66.34 183.56,66.07 Q11.3 ; JWWAN.14 217.61,54.24 217.75,54.38 218.04,54.38 218.26,54.6 218.5,54.6 v1(218.65,54.45) ; UE1.12 41.75,66.92 41.67,66.84 41.67,66.53 41.83,66.37 41.83,65.96 v1(42.02,65.78)
  IN1 w0.102: 128.21,122.19 128.21,122.21 128.2,122.22 128.2,122.6 127.7,123.1 125.53,123.1 124.94,122.51 124.94,122.3 124.94,122.29 124.94,122.21 124.93,122.2 124.93,122.19
  IN1 w0.119: v1(184.19,66.16) 184.37,66.34 184.83,66.34 185.17,66.68 185.17,68.75 180.01,73.91 174.91,73.91 172.26,76.56 172.26,84.48 171.28,88.16 171.17,88.67 171.01,89.82 170.7,94.65 170.57,94.77 170.53,94.8 165.83,99.5 163.8,99.5 157.38,105.93 145.17,105.93 141.18,109.92 135.89,109.92 133.61,112.21 133.61,115.59 128.37,120.82 128.37,121.65 128.21,121.81 128.21,122.19 ; v1(62.44,127.77) 62.28,127.62 62.28,127.2 64.88,124.61 65.34,124.61 67.59,122.36 71.36,122.36 72.29,123.28 73.75,123.28 74.74,122.29 76.99,122.29 77.65,121.63 78.63,121.63 78.81,121.45 80.74,121.45 83.27,118.92 86.94,118.92 88.76,117.1 93.84,117.1 94.28,117.55 108.74,117.55 110.17,118.98 112.29,118.98 113.01,118.26 113.94,118.26 114.69,117.5 119.69,117.5 120.63,118.44 121.26,118.44 123.42,120.61 v1(123.42,121.71) 124.27,120.87 124.76,120.87 124.93,121.03 124.93,122.19
  IN3 w0.135: v1(218.65,54.45) 218.49,54.61 217.64,54.61 217.27,54.98 217.27,55.82 216.63,56.46 215.36,56.46 214.26,57.56 206.53,57.56 206.25,57.84 203.14,57.84 202.22,58.76 195.13,58.76 193.5,60.39 193.5,62.5 192.44,63.56 186.32,63.56 184.82,65.05 184.82,66.11 184.61,66.32 184.35,66.32 v1(184.19,66.16) 184.03,66.32 183.79,66.32 183.43,65.97 183.43,65.25 183.85,64.83 184.26,64.83 186.5,62.59 186.5,62.04 187.32,61.21 187.32,58.53 185.94,57.15 185.06,57.15 184.13,56.22 183.26,56.22 181.89,54.84 181.89,54.15 180.88,53.15 180.88,51.03 180.67,50.81 180.67,50.59 180.09,50.02 180.09,49.51 179.45,48.87 179.45,47.91 179.09,47.55 179.09,42.2 177.92,41.03 174.78,41.03 174.2,41.61 165.35,41.61 165.05,41.31 163.55,41.31 162.59,40.35 159.46,40.35 158.63,41.19 153.52,41.19 152.59,42.11 151.16,42.11 v1(151,41.95)
  BOTTOM w0.076: UC1.W3 126.55,51.15 126.55,51.03 126.66,50.73 126.66,50.52 126.63,50.45 126.63,50.21 126.66,50.13 126.66,49.86 126.93,49.59 126.93,49.3 127.35,48.89 127.35,48.68
  BOTTOM w0.112: RC31.1 130.91,46.46 131.31,46.86 131.31,47.01 131.2,47.13 v1(131.04,47.13) 131.04,47.19 130.93,47.3 130.66,47.3 130.34,47.62 129.88,47.62 129.52,47.98 128.03,47.98 127.35,48.65 127.35,48.68 ; v1(62.44,127.77) 62.26,127.6 62.26,126.48 60.88,125.09 59.98,125.09 54.3,119.42 50.29,119.42 44.75,113.88 44.75,110.02 43.91,109.18 43.91,102.7 43.51,102.29 43.51,101.27 42.49,100.25 41.26,100.25 40.98,99.97 40.98,96.58 39.87,95.47 39.87,89.97 39.01,89.1 39.01,86.83 39.2,86.63 39.2,85.8 39.01,85.61 39.01,84.25 41.64,81.61 41.64,66.85 41.82,66.68 41.82,65.98 v1(42.02,65.78) 41.82,65.59 41.82,63.07 v1(41.91,62.98)
SML1_SMBDATA: length 396.1
  TOP w0.112: v1(218.65,55.03) 218.45,54.83 218.16,54.83 217.94,54.62 217.76,54.62 217.64,54.74 JWWAN.15 ; RE10.1 41.53,62.6 41.53,62.78 v1(41.33,62.98) ; v1(41.43,65.78) 41.6,65.94 41.6,66.27 41.43,66.43 41.43,66.83 41.35,66.91 UE1.11 ; v1(131.07,47.71) 131.33,47.45 132.2,47.45 132.26,47.39 134.2,47.39 135.22,46.37 139.81,46.37 142.66,43.51 142.66,42.42 143.81,41.27 144.93,41.27 145.2,41.54 147.63,41.54 148.79,42.7 150.59,42.7 150.88,42.41 v1(151,42.54) ; Q11.6 182.26,66.91 182.75,66.43 183.61,66.43 183.76,66.58 184.02,66.58 v1(184.19,66.75) ; QV1.3 124.96,120.24 v1(124.18,119.47)
  IN1 w0.102: 127.96,122.19 127.96,122.21 127.97,122.22 127.97,122.5 127.61,122.87 125.63,122.87 125.17,122.41 125.17,122.19
  IN1 w0.119: v1(61.85,127.77) 62.04,127.59 62.04,127.1 64.78,124.36 65.24,124.36 67.49,122.11 71.47,122.11 72.39,123.04 73.65,123.04 74.64,122.04 76.89,122.04 77.54,121.39 78.53,121.39 78.71,121.21 80.64,121.21 83.17,118.67 86.84,118.67 88.65,116.86 93.94,116.86 94.39,117.3 108.85,117.3 110.27,118.73 112.19,118.73 112.91,118.01 113.84,118.01 114.59,117.26 119.79,117.26 120.73,118.19 121.36,118.19 123.32,120.16 123.49,120.16 v1(124.18,119.47) 124.18,120.39 124.41,120.62 124.86,120.62 125.17,120.93 125.17,122.19 ; v1(184.19,66.75) 184.35,66.59 184.73,66.59 184.93,66.79 184.93,68.64 179.91,73.66 174.8,73.66 172.01,76.46 172.01,84.44 171.18,87.56 171.08,87.94 170.93,88.64 170.76,89.79 170.76,89.81 170.46,94.54 170.36,94.62 165.73,99.26 163.7,99.26 157.28,105.68 145.07,105.68 141.07,109.68 135.79,109.68 133.36,112.1 133.36,115.48 128.13,120.72 128.13,121.55 127.96,121.71 127.96,122.19
  IN3 w0.135: v1(218.65,55.03) 218.49,54.87 217.75,54.87 217.53,55.09 217.53,55.93 216.73,56.73 215.46,56.73 214.37,57.82 206.64,57.82 206.36,58.1 203.25,58.1 202.32,59.02 195.24,59.02 193.76,60.5 193.76,62.61 192.55,63.82 186.43,63.82 185.09,65.16 185.09,66.22 184.71,66.59 184.35,66.59 v1(184.19,66.75) 184.03,66.59 183.68,66.59 183.17,66.08 183.17,65.14 183.75,64.57 184.15,64.57 186.23,62.49 186.23,61.93 187.06,61.1 187.06,58.64 185.83,57.41 184.95,57.41 184.02,56.48 183.15,56.48 181.62,54.95 181.62,54.26 180.62,53.26 180.62,51.13 180.4,50.92 180.4,50.7 179.83,50.13 179.83,49.62 179.19,48.98 179.19,48.02 178.83,47.66 178.83,42.31 177.81,41.29 174.89,41.29 174.31,41.87 165.24,41.87 164.94,41.57 163.44,41.57 162.48,40.61 159.57,40.61 158.73,41.45 153.63,41.45 152.7,42.37 151.16,42.37 v1(151,42.54)
  BOTTOM w0.076: UC1.V3 127.07,51.53 126.72,51.18 126.72,51.05 126.83,50.76 126.83,50.48 126.79,50.41 126.79,50.25 126.82,50.16 126.82,49.93 127.1,49.66 127.1,49.37 127.53,48.94 127.53,48.81 127.67,48.68
  BOTTOM w0.112: RC32.1 131.56,46.63 131.56,47.23 v1(131.07,47.71) 131.07,47.65 130.96,47.54 130.76,47.54 130.44,47.86 129.98,47.86 129.62,48.21 128.13,48.21 127.67,48.68 ; v1(61.85,127.77) 62.03,127.6 62.03,126.58 60.78,125.33 59.88,125.33 54.2,119.66 50.19,119.66 44.51,113.98 44.51,110.11 43.67,109.28 43.67,102.8 43.27,102.39 43.27,101.36 42.39,100.49 41.16,100.49 40.74,100.07 40.74,96.68 39.63,95.57 39.63,90.06 38.77,89.2 38.77,86.73 38.96,86.54 38.96,85.9 38.77,85.71 38.77,84.15 41.4,81.51 41.4,66.75 41.58,66.58 41.58,65.92 v1(41.43,65.78) 41.58,65.63 41.58,63.28 41.37,63.06 41.37,63.03 v1(41.33,62.98)
