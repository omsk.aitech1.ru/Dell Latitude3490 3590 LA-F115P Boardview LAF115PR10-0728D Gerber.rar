# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Nets (continued)
+3VALW: C39.1 C40.1 C41.1 C43.1 C57.1 CC11.1 CC12.1 CC13.1 CC85.1 CL9.1 CT38.1 CX1.1 CX2.1 CZ25.1 CZ37.1 DE2.2 JP11.2 JPWR1.4 JPWR2.6 JWWAN.18 JWWAN.19 JWWAN.20 JWWAN.21 JWWAN.22 JWWAN.23 JWWAN.24 LT1.1 PJP302.2 PJP1801.1 PJP2501.1 PL1811.1 PR5.2 PR33.1 PR41.2 PR1803.1 PRB27.1 PRH03.1 PRH05.1 PRM06.1 PRS28.1 PRW03.1 Q15.3 R35.1 R43.1 R53.1 R65.1 R66.1 R70.1 RA11.2 RC63.1 RC88.2 RC92.2 RC163.1 RC225.2 RC226.1 RE2.1 RE15.2 RE17.2 RE18.2 RE21.2 RE25.1 RE46.1 RE49.1 RE55.1 RE56.1 RE57.1 RE58.1 RE59.1 RL7.1 RM1.1 RPE1.5 RPE1.6 RPE1.7 RPE1.8 RPE2.5 RPE2.6 RPE2.7 RPE2.8 RPE3.1 RPE3.2 RPE3.3 RPE3.4 RPE4.1 RPE4.2 RPE4.3 RPE4.4 RPE5.1 RPE5.2 RPE5.3 RPE5.4 RPE6.1 RPE6.2 RPE6.3 RPE6.4 RPE7.5 RPE7.6 RPE7.7 RPE7.8 RT11.1 RT14.1 RT17.1 RT20.1 RT23.1 RT26.1 RT29.1 RT52.1 RT53.1 RU26.1 RW5.1 RW12.1 RZ9.1 U4.5 UC5.5 UC6.5 UC7.5 UC9.5 UL2.5 UT3.13 UW1.5 UX1.1 UZ3.6 UZ3.7 UZ7.1 UZ7.2
+3VALW_EC: CE5.1 CE6.1 CE7.2 CE8.2 CE9.1 CE10.1 CE11.1 CE12.1 CE13.1 CE20.1 CE21.1 CE36.1 CE37.1 DE2.1 DT1.1 JESPI1.1 JESPI1.2 PR64.1 RE1.1 RE2.2 RE3.1 RE8.2 RE9.2 RE10.2 RE11.2 RE14.2 RE30.2 RE31.2 RE71.2 RE72.2 UE1.5 UE1.19 UE1.22 UE1.43 UE1.65 UE1.82 UE1.103 UE1.115
+3VALW_PCH: CC64.1 CC65.1 CC66.1 CC67.1 CC78.1 CC79.1 CC100.1 CZ32.1 L2.1 R84.2 RC17.1 RC29.2 RC30.2 RC31.2 RC32.2 RC33.2 RC34.2 RC37.2 RC38.2 RC39.2 RC44.1 RC45.2 RC46.2 RC47.2 RC128.1 RC129.1 RC227.2 RE19.2 RPC1.5 RPC1.6 RPC1.7 RPC1.8 RZ9.2 RZ10.2 UC1.AD15 UC1.AG15 UC1.AJ21 UC1.AK17 UC1.T16 UC1.V19 UC1.Y15 UC1.Y16
+3VALWP: PC310.1 PC311.1 PC312.1 PC313.1 PC314.1 PJP302.1 PL301.2 PR304.1 PR306.2 PR307.1 PR504.1 PU301.14
+3VGS: JP9.2 LV4.1 PRV14.1 QV1.2 QV1.5 RP34.1 RP34.2 RP34.3 RP34.4 RV5.1 RV6.1 RV154.1 RV162.1 RV260.2 UV2.5
+3VGS_GPU_ON: CZ13.2 RZ6.2 UZ4.3
+3VGS_OUT: CZ28.1 JP9.1 UZ4.7 UZ4.8
+3VLP: D1.2 PC308.1 PU301.16 PU301.17 R42.1 RE29.2
+3VS: C17.1 C21.1 C42.1 C55.1 C56.1 CD9.1 CD10.2 CD39.1 CD40.2 CE22.1 CS29.1 CS30.1 CT71.1 CT72.1 CT73.1 CT74.1 CT75.1 CW3.1 CW4.1 CW5.1 CX3.1 CX4.1 CZ12.1 CZ26.1 JDIMM1.255 JDIMM2.255 JIOB1.12 JP10.2 JVGA.14 JVGA.15 JWWAN.17 PRV17.1 PRW05.1 PRZ16.1 Q6.2 Q10.2 Q10.5 Q11.2 Q11.5 QA1.2 QC1.2 QC1.5 QI2.2 QI2.5 QI3.2 R5.1 R7.1 R11.1 R16.1 R24.1 R28.1 R29.1 R33.1 R34.1 R36.1 R48.1 R49.1 R50.2 R57.1 R72.1 R82.1 R83.1 RA2.1 RC1.2 RC2.2 RC3.2 RC9.1 RC27.1 RC28.1 RC35.1 RC36.1 RC42.1 RC49.1 RC55.1 RC57.1 RC59.1 RC61.1 RC69.2 RC71.1 RC72.1 RC73.1 RC86.1 RC105.1 RC114.1 RC115.1 RC116.1 RC181.1 RC188.1 RC194.2 RC200.2 RC205.2 RC206.2 RC207.2 RC208.2 RC209.1 RC212.2 RD1.1 RD2.1 RD3.1 RD13.1 RD14.1 RD15.1 RE13.2 RI15.1 RL3.1 RS3.1 RS7.2 RT66.2 RT68.2 RT70.2 RT72.2 RT74.2 RT76.2 RT77.2 RT79.2 RT80.2 RT83.2 RT93.1 RT97.1 RT115.2 RT117.1 RW3.2 RX6.1 U1.5 U2.1 UC4.5 UE2.5 US1.2 US1.3 US1.9 US1.10 UT5.5 UT5.21 UT5.30 UT5.51 UT5.57 UX1.8 UZ3.8 UZ3.9 UZ4.1 UZ4.2
+3VS_CAM: C14.1 C15.1 C49.1 JEDP1.29 R16.2
+3VS_SSD: CS24.1 CS25.1 CS26.1 CS27.1 CS33.1 CS34.1 CS35.1 CS36.1 JP10.1 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.70 JSSD1.72 JSSD1.74 RS2.2
+5V_AVDD: CA10.1 CA11.1 CA45.1 CA49.1 RA4.2 UA1.26
+5V_CONN_P1: CT2.1 CT3.1 CT78.1 UT1.8 UT6.3
+5V_HDD: CS5.1 CS6.1 CS7.1 CS32.1 JHDD.9 JHDD.10 JHDD.11 JHDD1.10 JHDD1.11 JHDD1.12 JP5.2 RS4.1 US2.1
+5V_HDMI: CI9.1 FI1.1 JHDMI1.18
+5V_KB_BL: C34.1 C51.1 EC3002.1 F3.1 JKBBL1.1
+5V_PVDD: CA1.1 CA2.1 CA3.1 CA4.1 CA43.1 CA47.1 RA1.2 UA1.41 UA1.46
+5VALW: CS8.1 CT7.1 CT91.2 CU5.1 CU16.1 CU23.1 CZ5.1 CZ22.1 CZ23.1 CZ27.1 CZ30.1 CZ40.1 PCA08.1 PCG11.1 PCI11.1 PCI31.1 PCV12.1 PD2.3 PD3.3 PJP502.2 PJP503.2 PR4.1 PR2504.1 PRG02.1 PRH11.1 PRI02.1 PRI22.1 PRM04.1 PRM05.2 PRV13.1 PRW11.1 PRZ39.1 PRZ57.1 PUA01.4 PUG01.15 PUI01.2 PUI01.15 PUI02.2 PUI02.15 PUV01.26 PUV01.31 Q18.3 Q19.3 Q20.3 US2.5 UT6.1 UT7.5 UU1.5 UU2.1 UU2.4 UU2.7 UU2.8 UU3.5 UZ1.4 UZ2.3 UZ3.1 UZ3.2 UZ3.4 UZ4.4 UZ5.4 UZ7.4
+5VALWP: PC510.1 PC511.1 PC512.1 PC513.1 PC514.1 PC519.1 PJP502.1 PJP503.1 PL501.2 PR509.2 PR510.1 PU501.14
+5VS: C30.1 C53.1 C54.1 CZ9.1 DI1.1 F3.2 FI1.2 JFAN1.1 JP5.1 JP6.1 JVGA.16 Q7.3 QI1.2 R4.1 R12.1 RA1.1 RA4.1 RS5.2 UZ3.13 UZ3.14
+5VS_ODD: CS13.1 CS14.1 CS15.1 JODD1.17 JODD1.18 JODD1.19 JODD1.20 JODD1.21 JODD1.22 JP6.2
+17.4V_BATT+: PC11.1 PJP3.1 PL4.1 PQB03.5 PRB39.1
+17.4V_BATT++: PBATT1.8 PBATT1.9 PBATT1.10 PC12.1 PC17.1 PC18.1 PJP3.2 PL4.2
+19V_ADPIN: PC1.1 PC2.1 PC15.1 PJP1.1 PJPDC1.5 PJPDC1.6 PL1.1
+19VB: F1.1 PCB10.1 PCB11.1 PCB12.1 PCB13.1 PCB14.1 PCB15.1 PCB16.1 PCB17.1 PCB21.1 PCB22.1 PCB23.1 PCB24.1 PCB46.1 PDB01.2 PJP301.1 PJP501.1 PJPG01.1 PJPH01.1 PJPI01.1 PJPM01.1 PJPV01.1 PJPW01.1 PL311.1 PL511.1 PLG11.1 PLH11.1 PLI11.1 PLM11.1 PLV11.1 PLW11.1 PQB02.2 PR302.2 PRB12.1 PRB21.2
+19VB_1.2V: PCM01.1 PCM02.1 PCM03.1 PCM04.1 PCM22.1 PCM23.1 PCM24.1 PJPM01.2 PLM11.2 PQM01.2 PQM01.3 PQM01.4 PQM01.10 PRM07.1
+19VB_+1.35VGPU: PCW01.1 PCW02.1 PCW03.1 PCW04.1 PCW15.1 PCW16.1 PCW17.1 PJPW01.2 PLW11.2 PUW01.5
+19VB_+1VALW: PCH01.1 PCH02.1 PCH03.1 PCH04.1 PCH15.1 PCH16.1 PCH17.1 PJPH01.2 PLH11.2 PUH01.5
+19VB_CPU: PCI01.1 PCI02.1 PCI03.1 PCI04.1 PCI05.1 PCI06.1 PCI07.1 PCI08.1 PCI13.1 PCI14.1 PCI21.1 PCI22.1 PCI23.1 PCI24.1 PCI25.1 PCI26.1 PCI27.1 PCI28.1 PJPA01.1 PJPI01.2 PLI11.2 PRZ35.1 PUI01.8 PUI01.9 PUI02.8 PUI02.9
+19VB_VGA: PCV01.1 PCV02.1 PCV03.1 PCV04.1 PCV05.1 PCV06.1 PCV07.1 PCV13.1 PCV14.1 PCV15.1 PCV16.1 PCV17.1 PCV18.1 PCV19.1 PCV35.1 PCV36.1 PJPV01.2 PLV11.2 PQV01.2 PQV02.2 PQV03.2 PQV04.2
+VBUS_DC_SS: PCS21.1 PDB02.2 PDS02.2 PDS02.3 PQS01.5 PQS02.5
+VCC_CORE: PCI101.1 PCI102.1 PCI103.1 PCI104.1 PCI105.1 PCI106.1 PCI107.1 PCI108.1 PCI109.1 PCI110.1 PCI111.1 PCI112.1 PCI113.1 PCI114.1 PCI115.1 PCI116.1 PCI117.1 PCI118.1 PCI119.1 PCI120.1 PCI121.1 PCI122.1 PCI123.1 PCI124.1 PCI125.1 PCI126.1 PCI127.1 PCI128.1 PCI129.1 PCI130.1 PCI131.1 PCI132.1 PCI133.1 PCI134.1 PCI135.1 PCI136.1 PCI137.1 PCI138.1 PCI139.1 PCI140.1 PCI141.1 PCI142.1 PCI143.1 PCI144.1 PCI145.1 PCI146.1 PCI147.1 PCI148.1 PCI149.1 PCI150.1 PCI151.1 PCI152.1 PCI153.1 PCI154.1 PCI155.1 PCI156.1 PCI157.1 PCI158.1 PCI159.1 PCI160.1 PCI161.1 PCI162.1 PCI163.1 PCI171.1 PCI172.1 PCI173.1 PLI01.4 PLI02.4 PRC01.1 PRC03.1 PRC04.1 PRC06.1 RC150.1 UC1.A30 UC1.A34 UC1.A39 UC1.A44 UC1.AK33 UC1.AK35 UC1.AK37 UC1.AK38 UC1.AK40 UC1.AL33 UC1.AL37 UC1.AL40 UC1.AM32 UC1.AM33 UC1.AM35 UC1.AM37 UC1.AM38 UC1.G30 UC1.G32 UC1.G33 UC1.G35 UC1.G37 UC1.G38 UC1.G40 UC1.G42 UC1.J30 UC1.J33 UC1.J37 UC1.J40 UC1.K33 UC1.K35 UC1.K37 UC1.K38 UC1.K40 UC1.K42 UC1.K43
+VCC_CORE_42: PCC01.1 PCC02.1 PRC01.2 PRC04.2 UC1.AK42 UC1.AK43 UC1.AK45 UC1.AK46 UC1.AK48 UC1.AK50 UC1.AL43 UC1.AL46 UC1.AL50 UC1.AM48 UC1.AM50 UC1.AM52
+VCC_CORE_G0: TP32.1(TP-1) UC1.K32
+VCC_CORE_G1: TP33.1(TP-1) UC1.AK32
+VCC_GT: PCG101.1 PCG102.1 PCG103.1 PCG104.1 PCG105.1 PCG106.1 PCG107.1 PCG108.1 PCG109.1 PCG110.1 PCG111.1 PCG112.1 PCG113.1 PCG114.1 PCG115.1 PCG116.1 PCG117.1 PCG118.1 PCG119.1 PCG120.1 PCG121.1 PCG122.1 PCG123.1 PCG124.1 PCG125.1 PCG126.1 PCG127.1 PCG128.1 PCG129.1 PCG130.1 PCG131.1 PCG132.1 PCG133.1 PCG134.1 PCG135.1 PCG136.1 PCG137.1 PCG138.1 PCG139.1 PCG140.1 PCG141.1 PCG142.1 PCG143.1 PCG144.1 PCG145.1 PCG146.1 PCG171.1 PCG172.1 PLG01.4 PRC02.1 PRC05.1 RC155.1 UC1.A58 UC1.A62 UC1.A66 UC1.AA63 UC1.AA64 UC1.AA66 UC1.AA67 UC1.AA69 UC1.AA70 UC1.AA71 UC1.AC64 UC1.AC65 UC1.AC66 UC1.AC67 UC1.AC68 UC1.AC69 UC1.AC70 UC1.AC71 UC1.J53 UC1.J55 UC1.J56 UC1.J58 UC1.J60 UC1.K53 UC1.K55 UC1.K56 UC1.K58 UC1.K60 UC1.L62 UC1.L63 UC1.L64 UC1.L65 UC1.L66 UC1.L67 UC1.L68 UC1.L69 UC1.L70 UC1.L71 UC1.M62 UC1.N63 UC1.N64 UC1.N66 UC1.N67 UC1.N69 UC1.N70 UC1.N71 UC1.R63 UC1.R64 UC1.R65 UC1.R66 UC1.R67 UC1.R68 UC1.R69 UC1.R70 UC1.R71 UC1.T62 UC1.U65 UC1.U68 UC1.U71 UC1.W63 UC1.W64 UC1.W65 UC1.W66 UC1.W67 UC1.W68 UC1.W69 UC1.W70 UC1.W71 UC1.Y62
+VCC_GT_42: PCC03.1 PCC04.1 PRC02.2 PRC03.2 PRC05.2 PRC06.2 RC157.1 UC1.A48 UC1.A53 UC1.J43 UC1.J45 UC1.J46 UC1.J48 UC1.J50 UC1.J52 UC1.K48 UC1.K50
+VCC_GT_K52: RC157.2 UC1.K52
+VCC_SA: PCA101.1 PCA102.1 PCA103.1 PCA104.1 PCA105.1 PCA106.1 PCA107.1 PCA108.1 PCA109.1 PCA110.1 PCA111.1 PCA112.1 PCA113.1 PCA114.1 PCA115.1 PCA116.1 PLA01.4 RC159.1 UC1.AK23 UC1.AK25 UC1.G23 UC1.G25 UC1.G27 UC1.G28 UC1.J22 UC1.J23 UC1.J27 UC1.K23 UC1.K25 UC1.K27 UC1.K28 UC1.K30
+VDD_CT: CV61.1 CV62.1 CV63.1 LV3.2 UV1.AA20 UV1.AA21 UV1.AB20 UV1.AB21
+VDDR3: CV64.1 CV65.1 CV66.1 CV123.1 LV4.2 UV1.AA17 UV1.AA18 UV1.AB17 UV1.AB18
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C12.2 C14.2 C15.2 C16.2 C17.2 C19.2 C21.2 C26.2 C27.2 C30.2 C31.2 C34.2 C35.2 C36.2 C37.1 C39.2 C40.2 C41.2 C42.2 C43.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C59.2 C60.2 C61.2 C62.2 CA1.2 CA2.2 CA3.2 CA4.2 CA5.1 CA6.2 CA9.2 CA13.1 CA14.2 CA15.1 CA16.2 CA17.2 CA22.1 CA25.1 CA27.2 CA28.2 CA29.2 CA30.2 CA38.1 CA40.2 CA43.2 CA44.2 CA45.2 CA46.2 CA47.2 CA48.2 CA49.2 CA50.2 CC1.2 CC2.1 CC3.2 CC4.2 CC5.2 CC6.2 CC7.2 CC8.2 CC9.2 CC10.2 CC11.2 CC12.2 CC13.2 CC14.2 CC15.2 CC17.2 CC18.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC57.2 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC72.2 CC73.2 CC74.2 CC75.2 CC76.2 CC77.2 CC78.2 CC79.2 CC80.2 CC81.2 CC82.2 CC83.2 CC84.2 CC85.2 CC86.2 CC87.2 CC88.2 CC90.2 CC91.2 CC94.2 CC95.2 CC96.2 CC97.2 CC98.2 CC99.2 CC100.2 CC101.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.1 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.1 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD58.2 CE3.2 CE4.2 CE5.2 CE6.2 CE7.1 CE8.1 CE9.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE19.2 CE20.2 CE22.2 CE23.2 CE24.2 CE26.2 CE28.2 CE31.2 CE32.1 CE33.2 CE34.1 CE35.1 CE36.2 CE37.2 CE38.2 CE39.2 CI9.2 CL5.2 CL6.2 CL7.2 CL8.2 CL9.2 CL10.1 CL11.1 CL12.2 CL13.2 CL15.2 CL18.2 CL19.2 CL20.2 CL22.2 CL23.2 CL24.2 CL25.2 CM1.2 CM2.2 CM3.2 CM4.2 CM5.2 CM6.2 CM7.2 CM8.1 CM9.2 CM10.2 CS5.2 CS6.2 CS7.2 CS8.2 CS13.2 CS14.2 CS15.2 CS24.2 CS25.2 CS26.2 CS27.2 CS29.2 CS30.2 CS32.2 CS33.2 CS34.2 CS35.2 CS36.2 CT1.2 CT2.2 CT3.2 CT4.2 CT5.2 CT6.2 CT7.2 CT8.2 CT9.2 CT10.2 CT11.2 CT14.2 CT15.2 CT17.2 CT19.2 CT20.2 CT21.2 CT22.2 CT23.2 CT38.2 CT39.2 CT44.2 CT45.2 CT46.2 CT47.2 CT50.2 CT53.2 CT54.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT76.2 CT77.2 CT78.2 CT79.2 CT80.2 CT91.1 CT92.2 CT93.2 CU5.2 CU6.2 CU7.2 CU8.2 CU9.2 CU10.2 CU11.2 CU12.2 CU13.2 CU14.2 CU15.2 CU16.2 CU17.2 CU19.2 CU20.2 CU21.2 CU22.2 CU23.2 CV11.2 CV15.2 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV26.2 CV27.2 CV28.2 CV29.2 CV30.2 CV33.2 CV34.2 CV35.2 CV38.2 CV39.2 CV40.2 CV41.2 CV42.2 CV43.2 CV44.2 CV45.2 CV46.2 CV47.2 CV48.2 CV49.2 CV50.2 CV51.2 CV52.2 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV62.2 CV63.2 CV64.2 CV65.2 CV66.2 CV67.2 CV68.2 CV69.2 CV70.2 CV71.2 CV72.2 CV73.2 CV74.2 CV75.2 CV76.2 CV77.2 CV78.2 CV79.2 CV80.2 CV81.2 CV82.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV92.2 CV93.2 CV94.2 CV95.2 CV96.2 CV97.2 CV100.2 CV101.2 CV102.2 CV103.2 CV104.2 CV105.2 CV106.2 CV107.2 CV108.2 CV109.2 CV110.2 CV111.2 CV112.2 CV113.2 CV114.2 CV115.2 CV116.2 CV117.2 CV118.2 CV119.2 CV120.2 CV121.2 CV122.2 CV123.2 CV124.2 CV125.2 CV126.2 CV127.2 CV153.2 CV155.2 CV157.2 CV158.2 CV160.2 CV161.2 CV162.2 CV164.2 CV165.2 CV166.2 CV169.2 CV170.2 CV173.2 CV174.2 CV175.2 CV176.2 CV177.2 CV178.2 CV179.2 CV180.1 CV181.1 CV198.2 CV210.2 CV211.2 CV213.2 CV216.2 CV219.2 CV221.2 CV225.2 CV227.2 CV230.2 CV233.2 CV235.2 CV238.2 CV242.2 CV243.2 CV247.2 CV248.2 CV333.2 CV334.2 CV335.2 CV336.2 CV341.2 CV342.2 CV343.2 CV344.2 CV390.2 CV391.2 CV394.2 CV395.2 CW3.2 CW4.2 CW5.2 CW6.2 CW7.2 CW8.2 CW9.2 CX1.2 CX2.2 CX3.2 CX4.2 CX5.2 CX6.2 CX7.2 CZ1.2 CZ2.2 CZ3.2 CZ4.2 CZ5.2 CZ6.2 CZ7.2 CZ8.2 CZ9.2 CZ10.2 CZ11.2 CZ12.2 CZ13.1 CZ14.1 CZ15.1 CZ16.1 CZ17.2 CZ18.1 CZ19.1 CZ20.1 CZ21.2 CZ22.2 CZ23.2 CZ25.2 CZ26.2 CZ27.2 CZ28.2 CZ29.2 CZ30.2 CZ31.2 CZ32.2 CZ33.1 CZ36.2 CZ37.2 CZ40.2 CZ46.1 DA1.1 DA2.1 DA4.1 DA5.1 DA6.1 DA7.1 DE1.2 DT3.2 DT4.2 DT5.2 DT6.2 DT7.2 DT8.2 DT9.2 DT10.2 EC2301.2 EC2302.2 EC2901.2 EC2902.2 EC3001.2 EC3002.2 EC3003.2 ED2901.1 EU2601.3 EU2602.1 EU2603.3 EU2604.1 EU2701.1 EU3101.3 EU4001.3 EU4002.3 EU4011.1 EU4012.1 H1.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) HCPU1.1(TP-1) HCPU2.1(TP-1) HCPU3.1(TP-1) HCPU4.1(TP-1) JCCG4.2 JCMOS1.2 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JEDP1.13 JEDP1.17 JEDP1.20 JEDP1.23 JEDP1.32 JEDP1.35 JEDP1.38 JEDP1.41 JEDP1.42 JESPI1.9 JESPI1.11 JESPI1.12 JFAN1.4 JFAN1.5 JFAN1.6 JFP.1 JFP.7 JFP.8 JFP1.1 JFP1.3 JFP1.9 JFP1.10 JHDD.3 JHDD.5 JHDD.8 JHDD.14 JHDD.17 JHDD.20 JHDD.21 JHDD.22 JHDD.23 JHDD.24 JHDD1.1 JHDD1.4 JHDD1.7 JHDD1.13 JHDD1.14 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIOB1.2 JIOB1.5 JIOB1.8 JIOB1.10 JIOB1.17 JIOB1.18 JKB1.30 JKB1.31 JKB1.32 JKBBL1.5 JKBBL1.6 JLAN1.9 JLAN1.10 JLAN1.11 JLAN1.12 JODD1.1 JODD1.2 JODD1.7 JODD1.8 JODD1.13 JODD1.14 JODD1.25 JODD1.26 JPWR1.1 JPWR1.5 JPWR1.6 JPWR2.3 JPWR2.7 JPWR2.8 JSPK1.5 JSPK1.6 JSSD1.1 JSSD1.3 JSSD1.9 JSSD1.15 JSSD1.21 JSSD1.27 JSSD1.33 JSSD1.39 JSSD1.45 JSSD1.51 JSSD1.57 JSSD1.71 JSSD1.73 JSSD1.75 JSSD1.76 JSSD1.77 JTP1.5 JTP1.9 JTP1.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JVGA.1 JVGA.4 JVGA.10 JVGA.17 JVGA.18 JWLAN1.1 JWLAN1.7 JWLAN1.18 JWLAN1.26 JWLAN1.33 JWLAN1.39 JWLAN1.45 JWLAN1.51 JWLAN1.57 JWLAN1.63 JWLAN1.69 JWLAN1.75 JWLAN1.76 JWLAN1.77 JWWAN.1 JWWAN.2 JWWAN.3 JWWAN.4 JWWAN.7 JWWAN.10 JWWAN.13 JWWAN.27 JWWAN.28 JWWAN.29 JWWAN.30 JWWAN.31 JWWAN.32 LED1.1 LED1.3 PBATT1.1 PBATT1.2 PBATT1.3 PBATT1.4 PBATT1.11 PBATT1.12 PC1.2 PC2.2 PC3.2 PC4.2 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC12.2 PC15.2 PC16.2 PC17.2 PC18.2 PC21.2 PC22.2 PC23.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC314.2 PC316.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC508.2 PC509.2 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC518.2 PC519.2 PC1801.2 PC1802.2 PC1803.2 PC1804.2 PC1805.2 PC1806.2 PC1808.2 PC1809.2 PC1810.2 PC2501.2 PC2502.2 PC2503.2 PC2504.2 PCA01.2 PCA02.2 PCA03.2 PCA04.2 PCA05.2 PCA06.2 PCA08.2 PCA09.2 PCA101.2 PCA102.2 PCA103.2 PCA104.2 PCA105.2 PCA106.2 PCA107.2 PCA108.2 PCA109.2 PCA110.2 PCA111.2 PCA112.2 PCA113.2 PCA114.2 PCA115.2 PCA116.2 PCB01.2 PCB02.2 PCB03.2 PCB04.2 PCB05.2 PCB06.2 PCB07.2 PCB08.2 PCB10.2 PCB11.2 PCB12.2 PCB13.2 PCB14.2 PCB15.2 PCB16.2 PCB17.2 PCB19.2 PCB20.2 PCB21.2 PCB22.2 PCB23.2 PCB24.2 PCB26.2 PCB27.2 PCB28.2 PCB29.2 PCB31.2 PCB32.2 PCB33.2 PCB34.2 PCB35.2 PCB36.2 PCB37.2 PCB38.2 PCB39.2 PCB40.2 PCB42.2 PCB43.2 PCB44.1 PCB45.2 PCB46.2 PCB47.2 PCC01.2 PCC02.2 PCC03.2 PCC04.2 PCG01.2 PCG02.2 PCG03.2 PCG04.2 PCG05.2 PCG06.2 PCG07.2 PCG08.2 PCG10.2 PCG11.2 PCG12.2 PCG13.2 PCG101.2 PCG102.2 PCG103.2 PCG104.2 PCG105.2 PCG106.2 PCG107.2 PCG108.2 PCG109.2 PCG110.2 PCG111.2 PCG112.2 PCG113.2 PCG114.2 PCG115.2 PCG116.2 PCG117.2 PCG118.2 PCG119.2 PCG120.2 PCG121.2 PCG122.2 PCG123.2 PCG124.2 PCG125.2 PCG126.2 PCG127.2 PCG128.2 PCG129.2 PCG130.2 PCG131.2 PCG132.2 PCG133.2 PCG134.2 PCG135.2 PCG136.2 PCG137.2 PCG138.2 PCG139.2 PCG140.2 PCG141.2 PCG142.2 PCG143.2 PCG144.2 PCG145.2 PCG146.2 PCG171.2 PCG172.2 PCH01.2 PCH02.2 PCH03.2 PCH04.2 PCH05.2 PCH06.2 PCH07.2 PCH08.2 PCH09.2 PCH10.2 PCH11.2 PCH13.2 PCH15.2 PCH16.2 PCH17.2 PCI01.2 PCI02.2 PCI03.2 PCI04.2 PCI05.2 PCI06.2 PCI07.2 PCI08.2 PCI10.2 PCI11.2 PCI12.2 PCI13.2 PCI14.2 PCI21.2 PCI22.2 PCI23.2 PCI24.2 PCI25.2 PCI26.2 PCI27.2 PCI28.2 PCI30.2 PCI31.2 PCI32.2 PCI101.2 PCI102.2 PCI103.2 PCI104.2 PCI105.2 PCI106.2 PCI107.2 PCI108.2 PCI109.2 PCI110.2 PCI111.2 PCI112.2 PCI113.2 PCI114.2 PCI115.2 PCI116.2 PCI117.2 PCI118.2 PCI119.2 PCI120.2 PCI121.2 PCI122.2 PCI123.2 PCI124.2 PCI125.2 PCI126.2 PCI127.2 PCI128.2 PCI129.2 PCI130.2 PCI131.2 PCI132.2 PCI133.2 PCI134.2 PCI135.2 PCI136.2 PCI137.2 PCI138.2 PCI139.2 PCI140.2 PCI141.2 PCI142.2 PCI143.2 PCI144.2 PCI145.2 PCI146.2 PCI147.2 PCI148.2 PCI149.2 PCI150.2 PCI151.2 PCI152.2 PCI153.2 PCI154.2 PCI155.2 PCI156.2 PCI157.2 PCI158.2 PCI159.2 PCI160.2 PCI161.2 PCI162.2 PCI163.2 PCI171.2 PCI172.2 PCI173.2 PCM01.2 PCM02.2 PCM03.2 PCM04.2 PCM05.2 PCM06.2 PCM07.2 PCM08.2 PCM09.2 PCM10.2 PCM11.2 PCM13.2 PCM14.2 PCM15.2 PCM16.2 PCM18.2 PCM19.2 PCM20.2 PCM21.2 PCM22.2 PCM23.2 PCM24.2 PCS01.1 PCS02.2 PCS03.2 PCS04.2 PCS05.2 PCS06.2 PCS07.2 PCS08.2 PCS11.2 PCS12.2 PCS13.2 PCS14.2 PCS15.2 PCS16.2 PCS17.2 PCS21.2 PCV01.2 PCV02.2 PCV03.2 PCV04.2 PCV05.2 PCV06.2 PCV07.2 PCV09.2 PCV10.2 PCV11.2 PCV12.2 PCV13.2 PCV14.2 PCV15.2 PCV16.2 PCV17.2 PCV18.2 PCV19.2 PCV20.2 PCV24.2 PCV27.2 PCV31.2 PCV32.2 PCV34.2 PCV35.2 PCV36.2 PCV171.2 PCV172.2 PCW01.2 PCW02.2 PCW03.2 PCW04.2 PCW05.2 PCW06.2 PCW07.2 PCW08.2 PCW09.2 PCW10.2 PCW11.2 PCW13.2 PCW15.2 PCW16.2 PCW17.2 PCZ02.2 PCZ03.2 PCZ05.2 PCZ12.2 PCZ14.2 PCZ19.2 PCZ22.2 PCZ23.2 PCZ24.2 PCZ25.2 PCZ30.2 PCZ32.2 PCZ33.2 PCZ34.2 PCZ36.2 PD1.1 PD2.2 PD3.2 PD5.1 PD6.1 PD12.2 PHV01.2 PHZ04.2 PHZ05.2 PJP2.2 PJPDC1.7 PJPDC1.8 PL2.2 PQ2.3 PQ5.3 PQ6.3 PQ11.3 PQ12.1 PQ12.4 PQ13.1 PQ13.4 PQ15.3 PQ16.3 PQ17.3 PQ18.3 PQ20.3 PQA01.5 PQA01.6 PQA01.7 PQB01.3 PQB01.4 PQB01.5 PQB02.3 PQB02.4 PQB02.5 PQB04.3 PQM01.5 PQM01.6 PQM01.7 PQS03.1 PQS03.4 PQS04.3 PQS05.1 PQS05.4 PQS07.3 PQS08.3 PQS10.1 PQS10.4 PQS11.3 PQS12.3 PQS14.3 PQS30.1 PQS30.4 PQV01.3 PQV01.4 PQV01.5 PQV02.3 PQV02.4 PQV02.5 PQV03.3 PQV03.4 PQV03.5 PQV04.3 PQV04.4 PQV04.5 PR6.2 PR15.2 PR16.2 PR17.2 PR38.2 PR40.2 PR43.2 PR44.1 PR45.2 PR62.2 PR66.2 PR100.2 PR303.2 PR308.2 PR508.2 PR511.2 PR1802.2 PR1805.2 PR2503.2 PRB07.2 PRB10.2 PRB20.2 PRB23.2 PRB24.2 PRB26.2 PRB33.2 PRH02.2 PRH04.2 PRH09.2 PRM11.2 PRS05.2 PRS06.2 PRS07.2 PRS14.2 PRS25.2 PRS27.1 PRS29.2 PRS30.2 PRV02.2 PRV04.2 PRV05.2 PRV09.2 PRV10.2 PRV16.2 PRV18.2 PRV27.2 PRW02.2 PRW04.2 PRW10.2 PRZ01.2 PRZ05.2 PRZ11.1 PRZ15.2 PRZ23.2 PRZ36.2 PRZ50.2 PRZ55.2 PRZ56.2 PRZ60.2 PRZ64.2 PRZ65.2 PRZ66.2 PRZ67.2 PRZ68.2 PRZ69.2 PU1.2 PU2.3 PU301.7 PU301.8 PU301.18 PU301.21 PU501.7 PU501.8 PU501.18 PU501.21 PU1801.11 PU2501.8 PU2501.9 PUA01.6 PUA01.9 PUB01.33 PUB02.3 PUG01.2 PUG01.4 PUG01.10 PUG01.14 PUG01.18 PUH01.4 PUH01.8 PUI01.4 PUI01.10 PUI01.14 PUI01.18 PUI02.4 PUI02.10 PUI02.14 PUI02.18 PUM01.1 PUM01.3 PUM01.14 PUM01.21 PUS01.4 PUS02.3 PUS03.3 PUS04.2 PUV01.41 PUW01.4 PUW01.8 PUZ01.49 Q1.3 Q4.3 Q8.3 Q13.3 Q24.3 Q25.1 Q25.4 QC2.3 QI1.3 QS1.1 QS1.4 QT3.3 QT4.3 R2.2 R10.2 R27.2 R40.2 R45.2 R79.1 R85.1 R87.1 RA9.2 RA17.2 RA18.2 RA22.2 RA24.2 RC5.1 RC6.1 RC7.2 RC8.2 RC10.2 RC11.2 RC12.2 RC48.2 RC50.1 RC52.2 RC54.2 RC56.2 RC58.2 RC60.2 RC62.2 RC64.2 RC66.2 RC67.2 RC68.2 RC87.2 RC94.1 RC102.2 RC109.2 RC110.2 RC119.2 RC120.2 RC121.2 RC122.2 RC130.2 RC131.1 RC132.1 RC133.1 RC134.2 RC136.1 RC144.2 RC145.2 RC146.2 RC147.2 RC151.2 RC156.2 RC160.2 RC164.2 RC182.2 RC201.2 RC202.2 RC211.2 RC213.2 RC224.2 RD4.2 RD5.2 RD6.2 RD11.2 RD12.2 RD16.2 RD17.2 RD18.2 RD21.2 RD22.2 RE16.2 RE20.2 RE32.2 RE48.2 RE50.1 RE53.1 RE62.2 RE68.2 RE539.1 RE541.1 RI16.2 RL2.1 RL4.2 RL6.1 RM12.1 RM13.1 RP1.1 RP1.2 RP1.3 RT2.2 RT4.2 RT12.2 RT13.2 RT15.2 RT16.2 RT18.2 RT19.2 RT21.2 RT22.2 RT24.2 RT25.2 RT27.2 RT28.2 RT30.2 RT31.2 RT32.2 RT39.2 RT40.2 RT62.2 RT63.2 RT65.2 RT67.2 RT69.2 RT71.2 RT73.2 RT75.2 RT78.2 RT81.2 RT82.2 RT84.2 RT94.1 RT98.1 RT99.1 RT100.1 RT112.2 RT113.2 RT116.1 RT121.2 RU23.2 RU24.2 RU25.2 RV2.1 RV4.2 RV9.2 RV12.2 RV13.2 RV16.2 RV17.1 RV21.1 RV29.1 RV34.2 RV35.2 RV38.2 RV39.1 RV40.1 RV41.1 RV49.2 RV51.2 RV53.2 RV55.2 RV59.1 RV83.2 RV88.1 RV89.1 RV116.2 RV118.2 RV119.2 RV120.2 RV121.2 RV123.2 RV132.2 RV133.2 RV134.2 RV135.2 RV151.1 RV163.2 RV368.1 RV369.2 RW11.1 RX5.2 RX8.2 SW1.2 SW2.2 SW3.4 SW3.5 SW3.6 SW3.7 U1.2 U2.5 U3.2 U4.3 UA1.49 UC1.A5 UC1.A67 UC1.A70 UC1.AA2 UC1.AA4 UC1.AA65 UC1.AA68 UC1.AB8 UC1.AB15 UC1.AB16 UC1.AB18 UC1.AB21 UC1.AD8 UC1.AD13 UC1.AD16 UC1.AD19 UC1.AD20 UC1.AD21 UC1.AD62 UC1.AE64 UC1.AE65 UC1.AE66 UC1.AE67 UC1.AE68 UC1.AE69 UC1.AF1 UC1.AF2 UC1.AF4 UC1.AF10 UC1.AF15 UC1.AF17 UC1.AF63 UC1.AG16 UC1.AG17 UC1.AG18 UC1.AG19 UC1.AG20 UC1.AG21 UC1.AG71 UC1.AH6 UC1.AH13 UC1.AH63 UC1.AH64 UC1.AH67 UC1.AJ4 UC1.AJ15 UC1.AJ18 UC1.AJ20 UC1.AK8 UC1.AK11 UC1.AK16 UC1.AK18 UC1.AK21 UC1.AK22 UC1.AK27 UC1.AK63 UC1.AK68 UC1.AK69 UC1.AL2 UC1.AL4 UC1.AL28 UC1.AL32 UC1.AL35 UC1.AL38 UC1.AL45 UC1.AL48 UC1.AL52 UC1.AL55 UC1.AL58 UC1.AL64 UC1.AL65 UC1.AL66 UC1.AM8 UC1.AM13 UC1.AM21 UC1.AM25 UC1.AM27 UC1.AM43 UC1.AM45 UC1.AM46 UC1.AM55 UC1.AM60 UC1.AM61 UC1.AM68 UC1.AM71 UC1.AN20 UC1.AN23 UC1.AN28 UC1.AN30 UC1.AN32 UC1.AN33 UC1.AN35 UC1.AN37 UC1.AN38 UC1.AN40 UC1.AN42 UC1.AN58 UC1.AN63 UC1.AP10 UC1.AP18 UC1.AP20 UC1.AP23 UC1.AP28 UC1.AP32 UC1.AP35 UC1.AP38 UC1.AP42 UC1.AP58 UC1.AP63 UC1.AP68 UC1.AP70 UC1.AR5 UC1.AR8 UC1.AR11 UC1.AR15 UC1.AR16 UC1.AR20 UC1.AR23 UC1.AR28 UC1.AR35 UC1.AR42 UC1.AR43 UC1.AR45 UC1.AR46 UC1.AR48 UC1.AR50 UC1.AR52 UC1.AR53 UC1.AR55 UC1.AR58 UC1.AR63 UC1.AT2 UC1.AT4 UC1.AT20 UC1.AT23 UC1.AT28 UC1.AT35 UC1.AT42 UC1.AT56 UC1.AT58 UC1.AT63 UC1.AT68 UC1.AT71 UC1.AU10 UC1.AU15 UC1.AU20 UC1.AU32 UC1.AU38 UC1.AV1 UC1.AV68 UC1.AV69 UC1.AV70 UC1.AV71 UC1.AW6 UC1.AW8 UC1.AW10 UC1.AW12 UC1.AW14 UC1.AW16 UC1.AW18 UC1.AW21 UC1.AW23 UC1.AW26 UC1.AW28 UC1.AW30 UC1.AW32 UC1.AW34 UC1.AW36 UC1.AW38 UC1.AW41 UC1.AW43 UC1.AW45 UC1.AW47 UC1.AW49 UC1.AW51 UC1.AW53 UC1.AW55 UC1.AW57 UC1.AW60 UC1.AW62 UC1.AW64 UC1.AW66 UC1.AY66 UC1.B10 UC1.B14 UC1.B18 UC1.B22 UC1.B30 UC1.B34 UC1.B39 UC1.B44 UC1.B48 UC1.B53 UC1.B58 UC1.B62 UC1.B66 UC1.B71 UC1.BA1 UC1.BA2 UC1.BA6 UC1.BA10 UC1.BA14 UC1.BA18 UC1.BA23 UC1.BA28 UC1.BA32 UC1.BA36 UC1.BA41 UC1.BA45 UC1.BA49 UC1.BA53 UC1.BA57 UC1.BA62 UC1.BA66 UC1.BA71 UC1.BB6 UC1.BB18 UC1.BB26 UC1.BB30 UC1.BB34 UC1.BB38 UC1.BB43 UC1.BB55 UC1.BB60 UC1.BB64 UC1.BB67 UC1.BB70 UC1.C1 UC1.C5 UC1.C25 UC1.D6 UC1.D10 UC1.D11 UC1.D14 UC1.D18 UC1.D22 UC1.D25 UC1.D26 UC1.D30 UC1.D34 UC1.D39 UC1.D44 UC1.D45 UC1.D47 UC1.D48 UC1.D53 UC1.D58 UC1.D62 UC1.D66 UC1.D69 UC1.E6 UC1.E11 UC1.E15 UC1.E18 UC1.E21 UC1.E46 UC1.E50 UC1.E53 UC1.E56 UC1.E65 UC1.E71 UC1.F1 UC1.F2 UC1.F4 UC1.F8 UC1.F13 UC1.F22 UC1.F23 UC1.F27 UC1.F28 UC1.F32 UC1.F33 UC1.F35 UC1.F37 UC1.F38 UC1.F40 UC1.F42 UC1.F68 UC1.G5 UC1.G6 UC1.G10 UC1.G22 UC1.G43 UC1.G45 UC1.G48 UC1.G52 UC1.G55 UC1.G58 UC1.G60 UC1.G63 UC1.G66 UC1.H15 UC1.H18 UC1.H71 UC1.J8 UC1.J11 UC1.J13 UC1.J25 UC1.J28 UC1.J32 UC1.J35 UC1.J38 UC1.J42 UC1.K16 UC1.K18 UC1.K22 UC1.K61 UC1.K63 UC1.K64 UC1.K65 UC1.K66 UC1.K67 UC1.K68 UC1.K70 UC1.K71 UC1.L2 UC1.L4 UC1.L8 UC1.L11 UC1.L16 UC1.L17 UC1.L18 UC1.L20 UC1.N6 UC1.N10 UC1.N13 UC1.N19 UC1.N21 UC1.N65 UC1.N68 UC1.P17 UC1.P19 UC1.P20 UC1.P21 UC1.R6 UC1.R13 UC1.T2 UC1.T4 UC1.T15 UC1.T17 UC1.T18 UC1.T21 UC1.U10 UC1.U63 UC1.U64 UC1.U66 UC1.U67 UC1.U69 UC1.U70 UC1.V16 UC1.V17 UC1.V18 UC1.W6 UC1.W9 UC1.W13 UC1.Y17 UC1.Y19 UC1.Y20 UC1.Y21 UC2.3 UC3.4 UC4.3 UC5.3 UC6.3 UC7.3 UC9.3 UE1.17 UE1.51 UE1.64 UE1.84 UE1.100 UE1.124 UE2.3 UL1.33 UL2.2 UM1.A6 UM1.C4 UM1.E7 UM1.E9 UM1.E10 UM1.F10 UM1.G5 UM1.H10 UM1.J5 UM1.K8 UM1.N2 UM1.N5 UM1.P4 UM1.P6 UM2.3 US1.5 US1.6 US1.7 US1.8 US2.2 UT1.41 UT2.41 UT3.5 UT3.21 UT4.2 UT5.11 UT5.19 UT5.52 UT5.61 UT6.2 UT7.2 UU1.2 UU2.14 UU2.17 UU3.2 UV1.A3 UV1.A30 UV1.AA11 UV1.AA13 UV1.AA16 UV1.AA27 UV1.AB6 UV1.AB10 UV1.AB15 UV1.AB24 UV1.AB32 UV1.AC9 UV1.AC17 UV1.AC24 UV1.AC26 UV1.AC27 UV1.AD6 UV1.AD8 UV1.AD25 UV1.AD32 UV1.AE7 UV1.AE14 UV1.AE27 UV1.AF32 UV1.AG12 UV1.AG27 UV1.AH10 UV1.AH28 UV1.AH32 UV1.B6 UV1.B8 UV1.B10 UV1.B12 UV1.B14 UV1.B16 UV1.B18 UV1.B20 UV1.B22 UV1.B24 UV1.B26 UV1.C1 UV1.C32 UV1.E28 UV1.F2 UV1.F6 UV1.F8 UV1.F10 UV1.F12 UV1.F14 UV1.F16 UV1.F18 UV1.F20 UV1.F22 UV1.F24 UV1.F26 UV1.G8 UV1.G10 UV1.G27 UV1.G31 UV1.H2 UV1.H6 UV1.H14 UV1.H17 UV1.H20 UV1.J7 UV1.J27 UV1.J31 UV1.K2 UV1.K6 UV1.K11 UV1.K22 UV1.K28 UV1.K32 UV1.L27 UV1.M6 UV1.M12 UV1.M32 UV1.N11 UV1.N13 UV1.N16 UV1.N18 UV1.N21 UV1.N25 UV1.N27 UV1.P6 UV1.P9 UV1.P25 UV1.P32 UV1.R11 UV1.R12 UV1.R15 UV1.R17 UV1.R20 UV1.R27 UV1.T6 UV1.T11 UV1.T13 UV1.T16 UV1.T18 UV1.T21 UV1.T25 UV1.T32 UV1.U9 UV1.U15 UV1.U17 UV1.U20 UV1.U25 UV1.U27 UV1.V11 UV1.V13 UV1.V16 UV1.V18 UV1.V32 UV1.W25 UV1.W26 UV1.W27 UV1.Y10 UV1.Y15 UV1.Y17 UV1.Y20 UV1.Y25 UV1.Y32 UV2.3 UV12.A1 UV12.A3 UV12.A12 UV12.A14 UV12.B5 UV12.B10 UV12.C1 UV12.C3 UV12.C4 UV12.C11 UV12.C12 UV12.C13 UV12.C14 UV12.D10 UV12.E1 UV12.E3 UV12.E12 UV12.E14 UV12.F5 UV12.F10 UV12.G5 UV12.G10 UV12.H1 UV12.H2 UV12.H13 UV12.H14 UV12.K1 UV12.K2 UV12.K13 UV12.K14 UV12.L5 UV12.L10 UV12.M5 UV12.M10 UV12.N1 UV12.N3 UV12.N12 UV12.N14 UV12.P10 UV12.R1 UV12.R3 UV12.R4 UV12.R11 UV12.R12 UV12.R14 UV12.T5 UV12.T10 UV12.U1 UV12.U3 UV12.U12 UV12.U14 UV13.A1 UV13.A3 UV13.A12 UV13.A14 UV13.B5 UV13.B10 UV13.C1 UV13.C3 UV13.C4 UV13.C11 UV13.C12 UV13.C13 UV13.C14 UV13.D10 UV13.E1 UV13.E3 UV13.E12 UV13.E14 UV13.F5 UV13.F10 UV13.G5 UV13.G10 UV13.H1 UV13.H2 UV13.H13 UV13.H14 UV13.K1 UV13.K2 UV13.K13 UV13.K14 UV13.L5 UV13.L10 UV13.M5 UV13.M10 UV13.N1 UV13.N3 UV13.N12 UV13.N14 UV13.P10 UV13.R1 UV13.R3 UV13.R4 UV13.R11 UV13.R12 UV13.R14 UV13.T5 UV13.T10 UV13.U1 UV13.U3 UV13.U12 UV13.U14 UV14.A1 UV14.A3 UV14.A12 UV14.A14 UV14.B5 UV14.B10 UV14.C1 UV14.C3 UV14.C4 UV14.C11 UV14.C12 UV14.C13 UV14.C14 UV14.D10 UV14.E1 UV14.E3 UV14.E12 UV14.E14 UV14.F5 UV14.F10 UV14.G5 UV14.G10 UV14.H1 UV14.H2 UV14.H13 UV14.H14 UV14.K1 UV14.K2 UV14.K13 UV14.K14 UV14.L5 UV14.L10 UV14.M5 UV14.M10 UV14.N1 UV14.N3 UV14.N12 UV14.N14 UV14.P10 UV14.R1 UV14.R3 UV14.R4 UV14.R11 UV14.R12 UV14.R14 UV14.T5 UV14.T10 UV14.U1 UV14.U3 UV14.U12 UV14.U14 UV15.A1 UV15.A3 UV15.A12 UV15.A14 UV15.B5 UV15.B10 UV15.C1 UV15.C3 UV15.C4 UV15.C11 UV15.C12 UV15.C13 UV15.C14 UV15.D10 UV15.E1 UV15.E3 UV15.E12 UV15.E14 UV15.F5 UV15.F10 UV15.G5 UV15.G10 UV15.H1 UV15.H2 UV15.H13 UV15.H14 UV15.K1 UV15.K2 UV15.K13 UV15.K14 UV15.L5 UV15.L10 UV15.M5 UV15.M10 UV15.N1 UV15.N3 UV15.N12 UV15.N14 UV15.P10 UV15.R1 UV15.R3 UV15.R4 UV15.R11 UV15.R12 UV15.R14 UV15.T5 UV15.T10 UV15.U1 UV15.U3 UV15.U12 UV15.U14 UW1.2 UX1.9 UX1.16 UX1.23 UX1.32 UX1.33 UZ1.5 UZ1.9 UZ2.5 UZ3.11 UZ3.15 UZ4.5 UZ4.9 UZ5.11 UZ5.15 UZ7.5 UZ7.9 YL1.2 YL1.4 YV1.2 YV1.4
V3D3_STB: RA11.1 RA12.1 UA1.20
VBAT_CHG: PCB45.1 PRB39.2 PUB01.31
VBUS_C_CTRL_P1: PRS35.2 PUS02.1 RT113.1 UT1.12
VBUS_DISCHARGE: QT3.2 RT32.1 UT1.20
VBUS_MON_P1: CT1.1 RT1.2 RT2.1 UT1.13
VBUS_P_CTRL_P1: PRS38.1 PUS03.1 QT5.1 RT112.1 UT1.11
VCC_CPU: PCZ34.1 PRZ57.2 PUZ01.13
VCC_GT_SENSE: PRZ59.1 RC155.2 UC1.J70
VCC_VCORE1: PCI10.1 PRI02.2 PUI01.3
VCC_VCORE2: PCI30.1 PRI22.2 PUI02.3
VCC_VGT1: PCG10.1 PRG02.2 PUG01.3
VCCDSW_ON: DC2.2 Q4.2 R66.2 RC442.1 RE91.1
VCCGT_B+: PCG01.1 PCG02.1 PCG03.1 PCG04.1 PCG05.1 PCG06.1 PCG07.1 PCG08.1 PCG13.1 PJPG01.2 PLG11.2 PUG01.8 PUG01.9
VCCIO_SENSE: TP38.1(TP-1) UC1.AM23
VCCSA_B+: PCA01.1 PCA02.1 PCA03.1 PCA04.1 PCA05.1 PCA06.1 PJPA01.2 PQA01.2 PQA01.3 PQA01.4 PQA01.10
VCCSENSE: PRZ14.1 RC150.2 UC1.E32
VCCSENSE_VGA: PRV34.1 RV159.2
VCCST_PWRGD: RC96.2 UC1.B65
VCCSTG_EN: DZ2.1 RZ2.2 RZ3.1 UC9.4
VCCSTG_EN_R: CZ7.1 DZ2.2 RZ3.2 UZ2.4
VDD10: CL5.1 CL6.1 CL18.1 CL19.1 CL22.1 CL23.1 RL1.2 UL1.3 UL1.8 UL1.22 UL1.30
VDD_1.2V: PCM14.1 PRM03.2 PRM04.2 PUM01.11
VDD_CHG: PCB28.1 PRB09.2 PRB11.1 PRB13.2 PUB01.18
VDDIO_VGA: PCV10.1 PRV12.2 PRV14.2 PUV01.6
VDDP_CHG: PCB29.1 PRB09.1 PUB01.8
VDDR4: UV1.U12 UV1.V12 UV1.Y12
VDDREG: CL8.1 RL5.2 UL1.23
VSS_GT_SENSE: PRZ53.2 RC156.1 UC1.J69
VSS_MECH: UV1.A32 UV1.AM1 UV1.AM32
VSSIO_SENSE: TP39.1(TP-1) UC1.AM22
VSSSENSE: PRZ18.1 RC151.1 UC1.E33
VSSSENSE_VGA: PRV36.1 RV158.2
+BIF_VDDC: CV122.1 CV180.2 CV181.2 RV31.2 UV1.R21 UV1.U21
+CCG_VBUS: CT39.1 CT44.1 CT45.1 CT46.1 CT47.1 CT80.1 CT92.1 CT93.1 EU4011.2 EU4011.3 JP14.1 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 PCS05.1 PCS06.1 PCS15.1 PLS11.1 PLS12.1 PRS26.1 PUS04.1 RT1.1 RT33.1
+CCG_VBUS_1: CT14.1 CT15.1 PCS07.1 PCS08.1 PCS09.1 PLS11.2 PLS12.2 PQS01.1 PQS01.2 PQS01.3 PQS13.3 PRS07.1 PRS08.1 PRS36.1 RT59.1 UT4.1
+CHARGER_SRC: PCB01.1 PCB02.1 PCB03.1 PCB04.1 PCB05.1 PCB06.1 PCB07.1 PCB08.1 PCB47.1 PJPB01.2 PLB11.2 PQB01.2
+DC_IN: PC3.1 PC4.1 PC5.1 PC8.1 PC16.1 PD12.1 PJP1.2 PL1.2 PQ3.1 PQ3.2 PQ3.3 PR8.1 PR13.1 PR32.1 PR34.1 PR36.1 PR61.1 PRS03.1 PU1.1
+DC_IN_SS: PD4.2 PD4.3 PDB03.2 PQ3.5 PQ4.5 PR11.1
+DCBAT_LCD: C4.1 C5.1 C47.1 F1.2 JEDP1.1 JEDP1.2 JEDP1.3 JEDP1.4
+DP_VDDC: CV30.1 CV33.1 CV34.1 RV30.2 UV1.AD14
+DP_VDDR: CV26.1 CV27.1 CV35.1 RV27.2 UV1.AF14
+EMMC_VDDI: CM5.1 UM1.C2
+FB0_VREFCL: CV395.1 RV54.2 RV55.1 UV12.J14 UV13.J14
+FB0_VREFDL: CV394.1 RV52.2 RV53.1 UV12.A10 UV12.U10 UV13.A10 UV13.U10
+FB1_VREFCL: CV391.1 RV50.2 RV51.1 UV14.J14 UV15.J14
+FB1_VREFDL: CV390.1 RV48.2 RV49.1 UV14.A10 UV14.U10 UV15.A10 UV15.U10
+LAN_VDD33: CL7.1 CL20.1 CL24.1 CL25.1 JP11.1 RL5.1 RL17.2 UL1.11 UL1.32 UL2.1
+LCDVDD: R3.2 U1.1
+LCDVDD_LCD: C2.1 C3.1 C12.1 JEDP1.7 JEDP1.8 R3.1
+LINE1_VREFO_L: RA29.1 UA1.31
+LINE1_VREFO_R: RA33.1 UA1.30
+MIC2-VREFO: RA25.1 RA26.1 UA1.29
+MPLL_PVDD: CV81.1 CV82.1 CV124.1 LV6.2 UV1.L8
+MVREFDA: CV94.1 RV33.2 RV34.1 UV1.K26
+MVREFSA: CV95.1 RV32.2 RV35.1 UV1.J26
+PCIE_VDDC: CV54.1 CV55.1 CV56.1 CV57.1 CV58.1 CV59.1 CV60.1 CV120.1 CV121.1 RV364.2 UV1.L23 UV1.L24 UV1.L25 UV1.L26 UV1.M22 UV1.N22 UV1.N23 UV1.N24 UV1.R22 UV1.T22 UV1.U22 UV1.V22
+PWR_SRC_AC: PJPB01.1 PLB11.1 PRB01.4
+RTC_CELL: C1.1 D1.1 Q23.3 RA12.2 RC91.2 RC199.2 RE7.1 RE41.1 RE70.2
+RTC_CELL_PCH: C59.1 CC70.1 CC71.1 Q23.1 R73.1 RC77.2 RC78.2 RC199.1 UC1.AK19 UC1.BB14
+RTC_CELL_VBAT: CE14.1 RE7.2 UE1.122
+RTC_VCC: JIOB1.11 R1.2
+SDC_IN: PC6.1 PCS10.1 PD4.1 PDS02.1 PQ4.1 PQ4.2 PQ4.3 PQ19.3 PQS02.1 PQS02.2 PQS02.3 PQS06.3 PR9.1 PR47.1 PRB01.1 PRB04.1 PRB05.1 PRS09.1 PRS10.1
+SPLL_PVDD: CV84.1 CV85.1 CV86.1 LV7.2 UV1.H7
+SPLL_VDDC: CV91.1 CV92.1 CV93.1 LV8.2 UV1.H8
+TP_VDD: C19.1 C52.1 JTP1.8 Q9.2 Q12.1 R31.1 R32.1 R36.2 R37.2 R39.1 R40.1 R41.1 R46.1 R47.1
+TPAN_VDD: C48.1 F2.2 JEDP1.40 R13.2 U3.1
+TPAN_VDD_F: C31.1 F2.1 R11.2 R12.2 R13.1 R30.2 U3.5
+TSVDD: CV19.1 CV20.1 CV21.1 LV2.2 UV1.AD17
+V_DDR_REFA: CD28.1 JDIMM1.164 RD9.2 RD10.2 RD12.1
+V_DDR_REFA_R: CD30.1 RD9.1 UC1.AY67
+V_DDR_REFB: CD58.1 JDIMM2.164 RD19.2 RD20.2 RD21.1
+V_DDR_REFB_R: CD59.1 RD19.1 UC1.BA67
+VCHGR: PCB31.1 PCB32.1 PQB03.1 PQB03.2 PQB03.3 PRB12.4
+VGA_CORE: CV67.1 CV68.1 CV69.1 CV70.1 CV71.1 CV72.1 CV73.1 CV74.1 CV75.1 CV76.1 CV77.1 CV78.1 CV79.1 CV80.1 CV87.1 CV88.1 CV89.1 CV90.1 CV100.1 CV101.1 CV102.1 CV103.1 CV104.1 CV105.1 CV106.1 CV107.1 CV108.1 CV109.1 CV110.1 CV111.1 CV112.1 CV113.1 CV114.1 CV115.1 CV116.1 CV117.1 CV118.1 CV119.1 CV125.1 CV126.1 CV127.1 PCV171.1 PCV172.1 PLV01.1 PLV02.1 UV1.AA12 UV1.AA15 UV1.AB11 UV1.AB12 UV1.AB13 UV1.AC11 UV1.AC13 UV1.AC14 UV1.M11 UV1.M13 UV1.M15 UV1.M16 UV1.M17 UV1.M18 UV1.M20 UV1.M21 UV1.N12 UV1.N15 UV1.N17 UV1.N20 UV1.R13 UV1.R16 UV1.R18 UV1.T10 UV1.T12 UV1.T15 UV1.T17 UV1.T20 UV1.U10 UV1.U11 UV1.U13 UV1.U16 UV1.U18 UV1.V15 UV1.V17 UV1.V20 UV1.V21 UV1.W9 UV1.W10 UV1.Y9 UV1.Y13 UV1.Y16 UV1.Y18 UV1.Y21
AC_B2B_ACOK: PD10.1 PQ16.1 PQ20.1 PR2.1
AC_B2B_S1: PC22.1 PQ15.1 PQ16.2 PQS11.1 PR22.2
AC_B2B_S1_A: PC7.1 PQ5.2 PR2.2 PR100.1
AC_B2B_S2: PC10.1 PQ6.2 PR11.2 PR17.1 PR51.1
AC_B2B_S2_A: PQ17.2 PQ18.1 PR50.2 PR60.2
AC_B2B_S2_B: PQ19.2 PR47.2 PR48.1
AC_B2B_S2_G: PC6.2 PQ4.4 PQ19.1 PR9.2 PR12.1
AC_B2B_S2_SW: PC23.1 PQ18.2 PR49.2 PR51.2 PR52.2
AC_DIS: PRB43.2 UE1.69
AC_DIS1: PQ20.2 PQB04.2 PRB23.1 PRB43.1
AC_OK: PD10.2 PR13.2 PR15.1 PRB44.1 PRS33.1 PRS41.1
AC_PRESENT: DZ1.2 RC90.1 RC211.1 UC1.AY15
AC_SW_PROCHOT: PC13.1 PQ12.6 PR33.2
ACAV_IN1: PQB04.1 PRB11.2 PRB20.1 PRB22.2 PRB41.1
ACIN_CHG: PCB26.1 PRB05.2 PRB07.1 PUB01.19
ACOK_CHG: PRB22.1 PUB01.24
ADDR_VBOOT_CPU: PRZ69.1 PUZ01.21
ADJ_2.5V: PC2505.2 PR2502.2 PR2503.1 PU2501.7
ADP_CHG: PRB04.2 PUB01.16
ALERT#: R28.2 U2.6
ALERT#_CPU: PRZ47.1 PUZ01.33
ALL_SYS_PWRGD: C35.1 RC105.2 RC106.2 RC107.1 RE42.1 UC6.4 UC7.2
ALWON: PR506.1 UE1.121
AMBER_LED_BAT: Q18.1 R68.2
AUD_AGND: CA7.2 CA10.2 CA11.2 CA12.1 CA20.1 CA21.1 CA23.2 CA26.2 CA34.2 CA35.2 CA36.2 CA37.2 CA41.2 CA42.2 EC2301.1 EC2302.1 EC3003.1 JHP1.7 RA17.1 RA18.1 RA22.1 RA30.2 RA34.2 RA40.1 RA41.1 UA1.25 UA1.38
AUD_HP1_JACK_L: RA27.1 UA1.32
AUD_HP1_JACK_L1: RA27.2 RA28.2 RA29.2 RA36.1
AUD_HP1_JACK_R: RA31.1 UA1.33
AUD_HP1_JACK_R1: RA31.2 RA32.2 RA33.2 RA37.1
AUD_PC_BEEP: CA31.2 UA1.16
AUD_PC_BEEP_C: DA3.1 RA23.1
AUD_SENSE: RA10.1 RA39.1
AUD_SENSE_A: CA7.1 RA3.1 RA10.2 UA1.13
AUD_SPK_L+: RA15.1 UA1.42
AUD_SPK_L+_C: CA28.1 DA1.2 JSPK1.3 RA15.2
AUD_SPK_L-: RA16.1 UA1.43
AUD_SPK_L-_C: CA27.1 DA1.3 JSPK1.4 RA16.2
AUD_SPK_R+: RA13.1 UA1.45
AUD_SPK_R+_C: CA30.1 DA2.2 JSPK1.1 RA13.2
AUD_SPK_R-: RA14.1 UA1.44
AUD_SPK_R-_C: CA29.1 DA2.3 JSPK1.2 RA14.2
AUD_VREF: CA23.1 UA1.28
AUX_EN_WOWL: RW11.2 UE1.34 UW1.4
AUX_ON: RL6.2 UE1.3 UL2.4
BAT1_LED#: Q17.1 RE18.1 UE1.106
BAT2_LED#: Q17.4 RE21.1 UE1.1
BATGONE_CHG: PCB34.1 PRB24.1 PRB25.1 PUB01.25
BATT_WHITE_LED_R#: Q17.3 Q19.2 Q22.1
BEEP: DA3.2 UE1.45
BGATE_CHG: PCB33.1 PQB03.4 PUB01.32
BKLT_CTRL: D3.1 R9.1 RP1.8 RP2.7
BKLT_IN_EC: RC6.2 UC1.R12 UE1.67
BLON_OUT_C: JEDP1.28 RP1.7 RP2.1
BLUETOOTH_EN: DW2.1 RC42.2 RC226.2 RW14.1 UC1.AB2
BOARD_ID: CE2.1 RE1.2 RE6.2 UE1.111
BOARD_ID1: RC57.2 RC58.1 UC1.AC1
BOARD_ID2: RC55.2 RC56.1 UC1.AB3
BOOT1_CHG: PRB06.1 PUB01.12
BOOT2_CHG: PCB30.1 PUB01.4
BOT_MUX_N: LT4.3 RT58.1 UT3.9
BOT_MUX_N_R: EU4002.2 EU4002.8 JUSBC1.B7 LT4.4 RT58.2
BOT_MUX_P: LT4.2 RT57.1 UT3.8
BOT_MUX_P_R: EU4002.4 EU4002.7 JUSBC1.B6 LT4.1 RT57.2
BP_0: RV82.1 UV1.U1
BP_1: RV81.1 UV1.U3
BREATH_LED#: Q21.3 R53.2 UE1.70
BST1_VGA: PRV21.1 PUV01.21
BST2_VGA: PRV01.1 PUV01.30
BST_1.2V: PRM02.1 PUM01.18
BST_1.2V_R: PCM12.1 PRM02.2
BST_3V: PR301.1 PU301.1
BST_5V: PR501.1 PU501.1
BST_+1.35VGPU: PRW06.1 PUW01.1
BST_+1.35VGPU_R: PCW12.1 PRW06.2
BST_+1VALW: PRH06.1 PUH01.1
BST_+1VALW_R: PCH12.1 PRH06.2
BST_VCCSA: PRA01.1 PUA01.1
BST_VCCSA_R: PCA07.1 PRA01.2
BST_VCORE1: PRI01.1 PUI01.5
BST_VCORE1_R: PCI09.1 PRI01.2
BST_VCORE2: PRI21.1 PUI02.5
BST_VCORE2_R: PCI29.1 PRI21.2
BST_VGT1: PRG01.1 PUG01.5
BST_VGT1_R: PCG09.1 PRG01.2
CAP_LED: JKB1.27 R25.2
CAP_LED#: Q6.3 R24.2 UE1.93
CAP_LED_Q: Q7.1 R25.1
CAP_LED_R#: Q6.1 Q7.2
CBN: CA24.1 UA1.35
CBP: CA24.2 UA1.37
CCG4_CC1_P1: CT11.1 EU4001.1 EU4001.9 JUSBC1.A5 UT1.9
CCG4_CC2_P1: CT10.1 EU4002.5 EU4002.6 JUSBC1.B5 UT1.7
CCG4_I2C_INT#: RE71.1 UE1.32 UT1.15
CCG4_ID1: RT3.2 RT4.1 UT1.25
CCG4_ID2: RT64.2 RT65.1 UT1.27
CCG4_SWD_CLK: JCCG4.4 UT1.2
CCG4_SWD_IO: JCCG4.5 UT1.1
CCG4_XRES: CT9.1 JCCG4.3 RT5.2 UT1.10
CFG0: RC131.2 TPC10.1(TP-1) UC1.E68
CFG1: RC132.2 TPC11.1(TP-1) UC1.B67
CFG2: TPC12.1(TP-1) UC1.D65
CFG3: RC133.2 RC175.1 TPC13.1(TP-1) UC1.D67
CFG4: RC136.2 TPC14.1(TP-1) UC1.E70
CFG5: TPC15.1(TP-1) UC1.C68
CFG6: TPC16.1(TP-1) UC1.D68
CFG7: TPC17.1(TP-1) UC1.C67
CFG8: TPC20.1(TP-1) UC1.F71
CFG9: TPC21.1(TP-1) UC1.G69
CFG10: TPC22.1(TP-1) UC1.F70
CFG11: TPC23.1(TP-1) UC1.G68
CFG12: TPC24.1(TP-1) UC1.H70
CFG13: TPC25.1(TP-1) UC1.G71
CFG14: TPC26.1(TP-1) UC1.H69
CFG15: TPC27.1(TP-1) UC1.G70
CFG16: TPC19.1(TP-1) UC1.E63
CFG17: TPC18.1(TP-1) UC1.F63
CFG18: TPC29.1(TP-1) UC1.E66
CFG19: TPC28.1(TP-1) UC1.F66
CFG_0: RT74.1 UT5.59
CFG_1: RT75.1 RT76.1 UT5.58
CFG_RCOMP: RC134.1 UC1.E60
CHG_AMBER_LED_R#: Q17.6 Q18.2
CLK_ITPXDP_N: TP8.1(TP-1) UC1.F43
CLK_ITPXDP_P: TP9.1(TP-1) UC1.E43
CLK_LAN_REQ2#_R: RL13.2 UL1.12
CLK_PCIE_LAN_N2: UC1.D41 UL1.16
CLK_PCIE_LAN_P2: UC1.C41 UL1.15
CLK_PCIE_LAN_REQ#: RC73.2 RL13.1 UC1.AT8
CLK_PCIE_NVME_N4: JSSD1.53 UC1.B40
CLK_PCIE_NVME_P4: JSSD1.55 UC1.A40
CLK_PCIE_NVME_REQ#: JSSD1.52 RC188.2 UC1.AU8
CLK_PCIE_PEG_REQ#: RC71.2 RV153.1 UC1.AR10
CLK_PCIE_WLAN_N1: JWLAN1.49 UC1.B42
CLK_PCIE_WLAN_P1: JWLAN1.47 UC1.A42
CLK_PCIE_WLAN_REQ#: RC72.2 RW9.1 UC1.AT7
CLK_PCIE_WLAN_REQ#_R: JWLAN1.53 RW9.2
CLK_PEG_VGA: UC1.D42 UV1.AK30
CLK_PEG_VGA#: UC1.C42 UV1.AK32
CLK_SMB: PBATT1.7 PR42.1
CLK_TP_SIO: C27.1 JTP1.1 R32.2 UE1.78
CMP_VIN0: RE37.1 RE52.1 UE1.20
CMP_VOUT0: PR507.1 RE49.2 RE52.2 UE1.85
COMP_1A_CPU: PCZ30.1 PCZ31.1 PUZ01.26
COMP_1B_CPU: PCZ01.1 PCZ03.1 PUZ01.43
COMP_2PH_CPU: PCZ15.2 PCZ16.2 PUZ01.4
COMP_CHG: PCB39.1 PRB30.1 PUB01.28
CPU_DP1_CTRL_CLK: QI2.1 RC1.1 UC1.L13
CPU_DP1_CTRL_DATA: QI2.4 RC2.1 UC1.L12
CPU_DP1_HPD: QI3.3 RI15.2 UC1.L9
CPU_DP2_AUXN: CT68.2 RT103.1 UC1.E48
CPU_DP2_AUXN_C: CT68.1 UT5.25
CPU_DP2_AUXP: CT67.2 RT102.1 UC1.F48
CPU_DP2_AUXP_C: CT67.1 UT5.24
CPU_DP2_CTRL_DATA: RC212.1 UC1.N8
CPU_DP2_HPD: RC5.2 RT114.2 UC1.L7 UT5.3
CPU_DP2_N0: CT56.2 RT105.1 UC1.C50
CPU_DP2_N0_C: CT56.1 UT5.7
CPU_DP2_N1: CT58.2 RT107.1 UC1.C52
CPU_DP2_N1_C: CT58.1 UT5.10
CPU_DP2_N2: CT60.2 RT109.1 UC1.A50
CPU_DP2_N2_C: CT60.1 UT5.13
CPU_DP2_N3: CT62.2 RT111.1 UC1.D51
CPU_DP2_N3_C: CT62.1 UT5.16
CPU_DP2_P0: CT55.2 RT104.1 UC1.D50
CPU_DP2_P0_C: CT55.1 UT5.6
CPU_DP2_P1: CT57.2 RT106.1 UC1.D52
CPU_DP2_P1_C: CT57.1 UT5.9
CPU_DP2_P2: CT59.2 RT108.1 UC1.B50
CPU_DP2_P2_C: CT59.1 UT5.12
CPU_DP2_P3: CT61.2 RT110.1 UC1.C51
CPU_DP2_P3_C: CT61.1 UT5.15
CPU_DP3_AUXN: TP1.1(TP-1) UC1.G46
CPU_DP3_AUXP: TP2.1(TP-1) UC1.F46
CPU_POPIRCOMP: RC119.1 UC1.AT16
CPU_XDP_TCK0: RC146.1 TPC2.1(TP-1) UC1.A59 UC1.B61
CPVEE: CA25.2 UA1.34
CS_1.2V: PRM03.1 PUM01.13
CSCOMP_2PH_CPU: PCZ17.1 PCZ18.1 PHZ02.2 PRZ27.2 PRZ28.1 PUZ01.6
CSCOMP_2PH_CPU_R: PHZ02.1 PRZ26.2 PRZ27.1
CSI2_COMP: RC7.1 UC1.E13
CSIN_CHG: PCB18.2 PCB20.1 PRB03.2 PUB01.14
CSIP_CHG: PCB18.1 PCB19.1 PRB02.2 PUB01.15
CSN1_VCORE1: PLI01.3 PRZ31.1
CSN2_VCORE2: PLI02.3 PRZ30.1
CSN_1A_VGT: PHZ03.2 PLG01.3 PRZ51.1
CSN_1A_VGT_NTC: PHZ03.1 PRZ45.1
CSN_1B_VCCSA: PHZ01.1 PLA01.3 PRZ06.1
CSON_CHG: PCB41.2 PCB43.1 PRB36.1 PUB01.1
CSOP_CHG: PCB38.1 PCB41.1 PRB32.1 PUB01.2
CSP1_2PH_CPU: PCZ20.2 PRZ32.2 PRZ37.2 PUZ01.10
CSP1_VCORE1: PLI01.2 PRZ25.1 PRZ37.1
CSP2_2PH_CPU: PCZ21.2 PRZ33.2 PRZ38.2 PRZ39.2 PUZ01.9
CSP2_VCORE2: PLI02.2 PRZ29.1 PRZ38.1
CSP_1A_VCORE: PCZ26.1 PCZ27.1 PRZ44.2 PRZ45.2 PUZ01.29
CSP_1A_VGT_R: PLG01.2 PRZ44.1
CSP_1B_VCCSA: PCZ08.2 PCZ09.2 PRZ10.2 PRZ13.2 PUZ01.40
CSP_1B_VCCSA_R: PLA01.2 PRZ13.1
CSREF_2PH_CPU: PCZ19.1 PCZ20.1 PCZ21.1 PRZ30.2 PRZ31.2 PRZ32.1 PRZ33.1 PUZ01.8
CSSUM_2PH_CPU: PCZ17.2 PCZ18.2 PRZ25.2 PRZ26.1 PRZ29.2 PUZ01.7
DAT_SMB: PBATT1.6 PR37.1
DAT_TP_SIO: C26.1 JTP1.2 R31.2 UE1.79
DBC_PANEL_EN: R6.2 UC1.AM5
DBC_PANEL_EN_R: JEDP1.11 R5.2 R6.1
DCIN_CHG: PCB27.1 PRB08.2 PUB01.17
DDC_CLK_HDMI: JHDMI1.15 QI2.6 RI13.1
DDC_DATA_HDMI: JHDMI1.16 QI2.3 RI14.1
DDR4_DRAMRST#: CD29.1 JDIMM1.108 JDIMM2.108 RD8.2
DDR_A_ACT#: JDIMM1.114 UC1.BA55
DDR_A_ALERT#: JDIMM1.116 UC1.AW50
DDR_A_BG0: JDIMM1.115 UC1.AY55
DDR_A_BG1: JDIMM1.113 UC1.AY54
DDR_A_BS0: JDIMM1.150 UC1.AU52
DDR_A_BS1: JDIMM1.145 UC1.AT48
DDR_A_CAS#: JDIMM1.156 UC1.AU48
DDR_A_CKE0: JDIMM1.109 UC1.BA56
DDR_A_CKE1: JDIMM1.110 UC1.BB56
DDR_A_CKE2: TP3.1(TP-1) UC1.AW56
DDR_A_CKE3: TP4.1(TP-1) UC1.AY56
DDR_A_CLK0: JDIMM1.137 UC1.AT53
DDR_A_CLK1: JDIMM1.138 UC1.AT55
DDR_A_CLK#0: JDIMM1.139 UC1.AU53
DDR_A_CLK#1: JDIMM1.140 UC1.AU55
DDR_A_CS#0: JDIMM1.149 UC1.AU45
DDR_A_CS#1: JDIMM1.157 UC1.AU43
DDR_A_D0: JDIMM1.4 UC1.AL71
DDR_A_D1: JDIMM1.3 UC1.AL68
DDR_A_D2: JDIMM1.20 UC1.AN68
DDR_A_D3: JDIMM1.21 UC1.AN69
DDR_A_D4: JDIMM1.8 UC1.AL70
DDR_A_D5: JDIMM1.7 UC1.AL69
DDR_A_D6: JDIMM1.16 UC1.AN70
DDR_A_D7: JDIMM1.17 UC1.AN71
DDR_A_D8: JDIMM1.29 UC1.AR70
DDR_A_D9: JDIMM1.25 UC1.AR68
DDR_A_D10: JDIMM1.37 UC1.AU71
DDR_A_D11: JDIMM1.41 UC1.AU68
DDR_A_D12: JDIMM1.24 UC1.AR71
DDR_A_D13: JDIMM1.28 UC1.AR69
DDR_A_D14: JDIMM1.42 UC1.AU70
DDR_A_D15: JDIMM1.38 UC1.AU69
DDR_A_D16: JDIMM1.45 UC1.BB65
DDR_A_D17: JDIMM1.49 UC1.AW65
DDR_A_D18: JDIMM1.63 UC1.AW63
DDR_A_D19: JDIMM1.58 UC1.AY63
DDR_A_D20: JDIMM1.50 UC1.BA65
DDR_A_D21: JDIMM1.46 UC1.AY65
DDR_A_D22: JDIMM1.59 UC1.BA63
DDR_A_D23: JDIMM1.62 UC1.BB63
DDR_A_D24: JDIMM1.67 UC1.BA61
DDR_A_D25: JDIMM1.70 UC1.AW61
DDR_A_D26: JDIMM1.79 UC1.BB59
DDR_A_D27: JDIMM1.84 UC1.AW59
DDR_A_D28: JDIMM1.66 UC1.BB61
DDR_A_D29: JDIMM1.71 UC1.AY61
DDR_A_D30: JDIMM1.83 UC1.BA59
DDR_A_D31: JDIMM1.80 UC1.AY59
DDR_A_D32: JDIMM1.174 UC1.AY39
DDR_A_D33: JDIMM1.170 UC1.AW39
DDR_A_D34: JDIMM1.187 UC1.AY37
DDR_A_D35: JDIMM1.186 UC1.AW37
DDR_A_D36: JDIMM1.169 UC1.BB39
DDR_A_D37: JDIMM1.173 UC1.BA39
DDR_A_D38: JDIMM1.182 UC1.BA37
DDR_A_D39: JDIMM1.183 UC1.BB37
DDR_A_D40: JDIMM1.195 UC1.AY35
DDR_A_D41: JDIMM1.191 UC1.AW35
DDR_A_D42: JDIMM1.207 UC1.AY33
DDR_A_D43: JDIMM1.203 UC1.AW33
DDR_A_D44: JDIMM1.194 UC1.BB35
DDR_A_D45: JDIMM1.190 UC1.BA35
DDR_A_D46: JDIMM1.208 UC1.BA33
DDR_A_D47: JDIMM1.204 UC1.BB33
DDR_A_D48: JDIMM1.211 UC1.AY31
DDR_A_D49: JDIMM1.216 UC1.AW31
DDR_A_D50: JDIMM1.229 UC1.AY29
DDR_A_D51: JDIMM1.228 UC1.AW29
DDR_A_D52: JDIMM1.215 UC1.BB31
DDR_A_D53: JDIMM1.212 UC1.BA31
DDR_A_D54: JDIMM1.224 UC1.BA29
DDR_A_D55: JDIMM1.225 UC1.BB29
DDR_A_D56: JDIMM1.237 UC1.AY27
DDR_A_D57: JDIMM1.233 UC1.AW27
DDR_A_D58: JDIMM1.236 UC1.AY25
DDR_A_D59: JDIMM1.232 UC1.AW25
DDR_A_D60: JDIMM1.245 UC1.BB27
DDR_A_D61: JDIMM1.249 UC1.BA27
DDR_A_D62: JDIMM1.246 UC1.BA25
DDR_A_D63: JDIMM1.250 UC1.BB25
DDR_A_DQS0: JDIMM1.13 UC1.AM69
DDR_A_DQS1: JDIMM1.34 UC1.AT70
DDR_A_DQS2: JDIMM1.55 UC1.AY64
DDR_A_DQS3: JDIMM1.76 UC1.BA60
DDR_A_DQS4: JDIMM1.179 UC1.AY38
DDR_A_DQS5: JDIMM1.200 UC1.BA34
DDR_A_DQS6: JDIMM1.221 UC1.AY30
DDR_A_DQS7: JDIMM1.242 UC1.BA26
DDR_A_DQS#0: JDIMM1.11 UC1.AM70
DDR_A_DQS#1: JDIMM1.32 UC1.AT69
DDR_A_DQS#2: JDIMM1.53 UC1.BA64
DDR_A_DQS#3: JDIMM1.74 UC1.AY60
DDR_A_DQS#4: JDIMM1.177 UC1.BA38
DDR_A_DQS#5: JDIMM1.198 UC1.AY34
DDR_A_DQS#6: JDIMM1.219 UC1.BA30
DDR_A_DQS#7: JDIMM1.240 UC1.AY26
DDR_A_MA0: JDIMM1.144 UC1.AY50
DDR_A_MA1: JDIMM1.133 UC1.BB50
DDR_A_MA2: JDIMM1.132 UC1.AY51
DDR_A_MA3: JDIMM1.131 UC1.BA50
DDR_A_MA4: JDIMM1.128 UC1.BB52
DDR_A_MA5: JDIMM1.126 UC1.BA51
DDR_A_MA6: JDIMM1.127 UC1.BA52
DDR_A_MA7: JDIMM1.122 UC1.AW52
DDR_A_MA8: JDIMM1.125 UC1.AY52
DDR_A_MA9: JDIMM1.121 UC1.BB54
DDR_A_MA10: JDIMM1.146 UC1.AT50
DDR_A_MA11: JDIMM1.120 UC1.BA54
DDR_A_MA12: JDIMM1.119 UC1.AW54
DDR_A_MA13: JDIMM1.158 UC1.AU46
DDR_A_ODT0: JDIMM1.155 UC1.AT45
DDR_A_ODT1: JDIMM1.161 UC1.AT43
DDR_A_PAR: JDIMM1.143 UC1.AT52
DDR_A_RAS#: JDIMM1.152 UC1.AU50
DDR_A_WE#: JDIMM1.151 UC1.AT46
DDR_B_ACT#: JDIMM2.114 UC1.AN53
DDR_B_ALERT#: JDIMM2.116 UC1.AN43
DDR_B_BG0: JDIMM2.115 UC1.AP52
DDR_B_BG1: JDIMM2.113 UC1.AN52
DDR_B_BS0: JDIMM2.150 UC1.BB44
DDR_B_BS1: JDIMM2.145 UC1.BA44
DDR_B_CAS#: JDIMM2.156 UC1.AY43
DDR_B_CKE0: JDIMM2.109 UC1.AN56
DDR_B_CKE1: JDIMM2.110 UC1.AP55
DDR_B_CKE2: TP5.1(TP-1) UC1.AN55
DDR_B_CKE3: TP6.1(TP-1) UC1.AP53
DDR_B_CLK0: JDIMM2.137 UC1.AP45
DDR_B_CLK1: JDIMM2.138 UC1.AP46
DDR_B_CLK#0: JDIMM2.139 UC1.AN45
DDR_B_CLK#1: JDIMM2.140 UC1.AN46
DDR_B_CS#0: JDIMM2.149 UC1.BB42
DDR_B_CS#1: JDIMM2.157 UC1.AY42
DDR_B_D0: JDIMM2.28 UC1.AF65
DDR_B_D1: JDIMM2.25 UC1.AF64
DDR_B_D2: JDIMM2.42 UC1.AK65
DDR_B_D3: JDIMM2.38 UC1.AK64
DDR_B_D4: JDIMM2.24 UC1.AF66
DDR_B_D5: JDIMM2.29 UC1.AF67
DDR_B_D6: JDIMM2.41 UC1.AK67
DDR_B_D7: JDIMM2.37 UC1.AK66
DDR_B_D8: JDIMM2.8 UC1.AF70
DDR_B_D9: JDIMM2.4 UC1.AF68
DDR_B_D10: JDIMM2.21 UC1.AH71
DDR_B_D11: JDIMM2.20 UC1.AH68
DDR_B_D12: JDIMM2.7 UC1.AF71
DDR_B_D13: JDIMM2.3 UC1.AF69
DDR_B_D14: JDIMM2.16 UC1.AH70
DDR_B_D15: JDIMM2.17 UC1.AH69
DDR_B_D16: JDIMM2.45 UC1.AT66
DDR_B_D17: JDIMM2.49 UC1.AU66
DDR_B_D18: JDIMM2.62 UC1.AP65
DDR_B_D19: JDIMM2.59 UC1.AN65
DDR_B_D20: JDIMM2.50 UC1.AN66
DDR_B_D21: JDIMM2.46 UC1.AP66
DDR_B_D22: JDIMM2.63 UC1.AT65
DDR_B_D23: JDIMM2.58 UC1.AU65
DDR_B_D24: JDIMM2.71 UC1.AT61
DDR_B_D25: JDIMM2.66 UC1.AU61
DDR_B_D26: JDIMM2.79 UC1.AP60
DDR_B_D27: JDIMM2.84 UC1.AN60
DDR_B_D28: JDIMM2.70 UC1.AN61
DDR_B_D29: JDIMM2.67 UC1.AP61
DDR_B_D30: JDIMM2.83 UC1.AT60
DDR_B_D31: JDIMM2.80 UC1.AU60
DDR_B_D32: JDIMM2.169 UC1.AU40
DDR_B_D33: JDIMM2.173 UC1.AT40
DDR_B_D34: JDIMM2.183 UC1.AT37
DDR_B_D35: JDIMM2.187 UC1.AU37
DDR_B_D36: JDIMM2.170 UC1.AR40
DDR_B_D37: JDIMM2.174 UC1.AP40
DDR_B_D38: JDIMM2.186 UC1.AP37
DDR_B_D39: JDIMM2.182 UC1.AR37
DDR_B_D40: JDIMM2.190 UC1.AT33
DDR_B_D41: JDIMM2.194 UC1.AU33
DDR_B_D42: JDIMM2.207 UC1.AU30
DDR_B_D43: JDIMM2.203 UC1.AT30
DDR_B_D44: JDIMM2.191 UC1.AR33
DDR_B_D45: JDIMM2.195 UC1.AP33
DDR_B_D46: JDIMM2.204 UC1.AR30
DDR_B_D47: JDIMM2.208 UC1.AP30
DDR_B_D48: JDIMM2.216 UC1.AU27
DDR_B_D49: JDIMM2.212 UC1.AT27
DDR_B_D50: JDIMM2.225 UC1.AT25
DDR_B_D51: JDIMM2.229 UC1.AU25
DDR_B_D52: JDIMM2.211 UC1.AP27
DDR_B_D53: JDIMM2.215 UC1.AN27
DDR_B_D54: JDIMM2.228 UC1.AN25
DDR_B_D55: JDIMM2.224 UC1.AP25
DDR_B_D56: JDIMM2.232 UC1.AT22
DDR_B_D57: JDIMM2.236 UC1.AU22
DDR_B_D58: JDIMM2.249 UC1.AU21
DDR_B_D59: JDIMM2.245 UC1.AT21
DDR_B_D60: JDIMM2.237 UC1.AN22
DDR_B_D61: JDIMM2.233 UC1.AP22
DDR_B_D62: JDIMM2.250 UC1.AP21
DDR_B_D63: JDIMM2.246 UC1.AN21
DDR_B_DQS0: JDIMM2.34 UC1.AH65
DDR_B_DQS1: JDIMM2.13 UC1.AG70
DDR_B_DQS2: JDIMM2.55 UC1.AR65
DDR_B_DQS3: JDIMM2.76 UC1.AR60
DDR_B_DQS4: JDIMM2.179 UC1.AR38
DDR_B_DQS5: JDIMM2.200 UC1.AR32
DDR_B_DQS6: JDIMM2.221 UC1.AR27
DDR_B_DQS7: JDIMM2.242 UC1.AR21
DDR_B_DQS#0: JDIMM2.32 UC1.AH66
DDR_B_DQS#1: JDIMM2.11 UC1.AG69
DDR_B_DQS#2: JDIMM2.53 UC1.AR66
DDR_B_DQS#3: JDIMM2.74 UC1.AR61
DDR_B_DQS#4: JDIMM2.177 UC1.AT38
DDR_B_DQS#5: JDIMM2.198 UC1.AT32
DDR_B_DQS#6: JDIMM2.219 UC1.AR25
DDR_B_DQS#7: JDIMM2.240 UC1.AR22
DDR_B_MA0: JDIMM2.144 UC1.BA46
DDR_B_MA1: JDIMM2.133 UC1.AY46
DDR_B_MA2: JDIMM2.132 UC1.AY47
DDR_B_MA3: JDIMM2.131 UC1.BB46
DDR_B_MA4: JDIMM2.128 UC1.BA47
DDR_B_MA5: JDIMM2.126 UC1.AY48
DDR_B_MA6: JDIMM2.127 UC1.BA48
DDR_B_MA7: JDIMM2.122 UC1.AP48
DDR_B_MA8: JDIMM2.125 UC1.BB48
DDR_B_MA9: JDIMM2.121 UC1.AP50
DDR_B_MA10: JDIMM2.146 UC1.AW46
DDR_B_MA11: JDIMM2.120 UC1.AN48
DDR_B_MA12: JDIMM2.119 UC1.AN50
DDR_B_MA13: JDIMM2.158 UC1.BA43
DDR_B_ODT0: JDIMM2.155 UC1.BA42
DDR_B_ODT1: JDIMM2.161 UC1.AW42
DDR_B_PAR: JDIMM2.143 UC1.AP43
DDR_B_RAS#: JDIMM2.152 UC1.AW44
DDR_B_WE#: JDIMM2.151 UC1.AY44
DDR_VTT_CNTL: UC1.AW67 UC2.2
DGPU_HOLD_RST#: RC48.1 UC1.P3 UV2.2
DGPU_PWR_EN: PRV15.1 RC49.2 RC50.2 RZ6.1 RZ7.1 RZ8.1 UC1.U1
DGPU_PWROK: PRV20.2 PRW01.1 RC116.2 UC1.C8
DIFFOUT_2PH_CPU: PRZ20.1 PRZ21.1 PUZ01.2
DIMM_CHA_SA0: JDIMM1.256 RD1.2 RD4.1
DIMM_CHA_SA1: JDIMM1.260 RD2.2 RD5.1
DIMM_CHA_SA2: JDIMM1.166 RD3.2 RD6.1
DIMM_CHB_SA0: JDIMM2.256 RD13.2 RD16.1
DIMM_CHB_SA1: JDIMM2.260 RD14.2 RD17.1
DIMM_CHB_SA2: JDIMM2.166 RD15.2 RD18.1
DMIC_CLK: L5.2 UA1.3
DMIC_CLK_EDP: CA9.1 JEDP1.31 L5.1
DMIC_DATA: RA42.2 UA1.2
DMIC_DATA_EDP: CA40.1 JEDP1.30 RA42.1
DP_AUXN: CT90.2 RT103.2
DP_AUXP: CT89.2 RT102.2
DP_N0: CT82.2 RT105.2
DP_N1: CT84.2 RT107.2
DP_N2: CT86.2 RT109.2
DP_N3: CT88.2 RT111.2
DP_P0: CT81.2 RT104.2
DP_P1: CT83.2 RT106.2
DP_P2: CT85.2 RT108.2
DP_P3: CT87.2 RT110.2
DP_VSSR: UV1.AF19 UV1.AF20 UV1.AF23 UV1.AG14 UV1.AG23 UV1.AH14 UV1.AM14 UV1.AM16 UV1.AM18 UV1.AM20 UV1.AM22 UV1.AM24
DRAM_RST: RV36.1 UV12.J2 UV13.J2 UV14.J2 UV15.J2
DRAM_RST_G: CV97.1 RV37.1 RV38.1 UV1.L10
DRVON: PUA01.3 PUG01.16 PUI01.16 PUI02.16 PUZ01.35
EC_AGND: CE1.2 CE2.2 CE21.2 CE25.2 CE30.2 RE4.1 RE6.1 RE50.2 UE1.112
EC_MUTE#: RA8.2 RE28.2 UA1.47
EDP_AUX: C11.2 JEDP1.15
EDP_AUX#: C10.2 JEDP1.16
EDP_AUX_DN: C10.1 UC1.E45
EDP_AUX_DP: C11.1 UC1.F45
EDP_BKLT_CTRL: D3.2 R8.2 R9.2
EDP_COMP: RC4.2 UC1.E52
EDP_HPD: JEDP1.12 RP1.6 UC1.L10
EDP_TX0: C7.2 JEDP1.19
EDP_TX0#: C6.2 JEDP1.18
EDP_TX0_DN: C6.1 UC1.C47
EDP_TX0_DP: C7.1 UC1.C46
EDP_TX1: C9.2 JEDP1.22
EDP_TX1#: C8.2 JEDP1.21
EDP_TX1_DN: C8.1 UC1.D46
EDP_TX1_DP: C9.1 UC1.C45
EDP_VDD_EN: D4.2 UC1.U13
EDRAM_OPIO_RCOMP: RC121.1 UC1.H66
EMMC_CLK: RM14.1 UC1.AM3
EMMC_CLK_R: CM8.2 RM13.2 RM14.2 UM1.M6
EMMC_CMD: RM15.1 UC1.AP4
EMMC_CMD_R: RM3.2 RM15.2 UM1.M5
EMMC_D0_R: RM16.2 RPM1.7 UM1.A3
EMMC_D1_R: RM17.2 RPM2.5 UM1.A4
EMMC_D2_R: RM18.2 RPM2.7 UM1.A5
EMMC_D3_R: RM19.2 RPM1.5 UM1.B2
EMMC_D4_R: RM20.2 RPM1.6 UM1.B3
EMMC_D5_R: RM21.2 RPM1.8 UM1.B4
EMMC_D6_R: RM22.2 RPM2.6 UM1.B5
EMMC_D7_R: RM23.2 RPM2.8 UM1.B6
EMMC_DATA0: RM16.1 UC1.AP2
EMMC_DATA1: RM17.1 UC1.AP1
EMMC_DATA2: RM18.1 UC1.AP3
EMMC_DATA3: RM19.1 UC1.AN3
EMMC_DATA4: RM20.1 UC1.AN1
EMMC_DATA5: RM21.1 UC1.AN2
EMMC_DATA6: RM22.1 UC1.AM4
EMMC_DATA7: RM23.1 UC1.AM1
EMMC_RCLK: RM24.1 UC1.AM2
EMMC_RCLK_R: RM12.2 RM24.2 UM1.H5
EMMC_RCOMP: RC8.1 UC1.AT1
EMMC_RST#: CM6.1 RM25.1 RM27.2 UM2.4
EMMC_RST#_R: RM25.2 UM1.K5
EN_0.6VSP: PCM16.1 PRM09.2 PUM01.7
EN_1.2V: PCM15.1 PRM08.2 PUM01.8
EN_1.8VALW: PC1805.1 PR1801.2 PR1802.1 PR1806.2 PR1890.2 PU1801.5
EN_2.5V: PC2503.1 PR2501.2 PU2501.2
EN_3V: PR502.1 PU301.12
EN_5V: PR503.1 PU501.12
EN_+1.35VGPU: PCW09.1 PRW01.2 PRW02.1 PUW01.6
EN_+1VALW: PCH09.1 PRH01.2 PRH02.1 PRH13.2 PRH90.2 PUH01.6
EN_CPU: PRZ22.1 PUZ01.37
ENABLE_VGA: PRV15.2 PUV01.8
