# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA3: length 53.2
  IN1 w0.076: 105.34,80.94 105.53,80.75 105.53,80.06 105.66,79.92 105.81,79.78 106.49,79.78 106.56,79.86 v1(106.56,80.14)
  IN1 w0.183: 103.83,82.44 104.86,81.41 105.34,80.94
  IN1 w0.188: 103.83,82.44 90.51,82.44 86.93,78.86 85.79,78.86 85.6,79.05 85.6,79.95 85.41,80.14 85.04,80.14 84.85,79.95 84.85,79.05 84.66,78.86 84.05,78.86 83.86,79.05 83.86,79.95 83.67,80.14 80.3,80.14 80.04,79.88 80.04,79.49 79.85,79.3 79.26,79.3 79.12,79.16 77.85,79.16 77.71,79.02 75.22,79.02 75.03,78.83 v1(75.03,78.43)
  BOTTOM w0.076: UC1.BA50 114.42,78.23 114.16,77.97 112.31,77.97 111.88,78.41 108.58,78.41 v2(108.38,78.61) 108.01,78.98 106.99,78.98 106.56,79.4 v1(106.56,80.14)
  BOTTOM w0.183: JDIMM1.131 79.15,77.49 78.21,77.49 78.01,77.69 75.7,77.69 75.03,78.36 v1(75.03,78.43)
DDR_A_MA4: length 52
  IN1 w0.076: 104.11,82.7 106.11,80.69 106.11,80.3 v1(105.95,80.14)
  IN1 w0.183: 77.19,79.31 76.47,79.31 75.98,79.8 75.61,79.8 75.11,79.31 75.1,79.31 74.64,78.85 74.36,78.85 73.92,79.29 ; 103.99,82.82 104.11,82.7
  IN1 w0.188: 73.92,79.29 73.83,79.38 73.56,79.38 73.19,79.01 73.19,78.74 v1(73.51,78.42) ; 77.19,79.31 77.52,79.63 78.93,79.63 79.12,79.82 79.12,80.41 79.32,80.61 83.86,80.61 84.1,80.37 84.61,80.37 84.84,80.61 85.88,80.61 86.07,80.42 86.07,79.52 86.26,79.33 86.63,79.33 86.82,79.52 86.82,80.42 87.01,80.61 88.01,80.61 90.31,82.91 103.89,82.91 103.92,82.88 103.92,82.88 103.99,82.82 103.99,82.82
  BOTTOM w0.076: UC1.BB52 113.8,79.67 112.09,79.67 111.54,80.21 110.88,80.21 110.25,80.85 106.66,80.85 106.49,80.68 v1(105.95,80.14)
  BOTTOM w0.183: JDIMM1.128 71.78,78.24 72.08,77.94 73.11,77.94 73.51,78.35 v1(73.51,78.42)
DDR_A_MA5: length 53.2
  IN1 w0.076: v1(108.39,80.14) 108.39,80.72 108.31,80.8 106.71,80.8 104.15,83.36 104.15,83.43
  IN1 w0.183: 103.73,83.85 104.15,83.43
  IN1 w0.188: 103.73,83.85 89.92,83.85 88.13,82.06 87.87,82.06 87.32,82.6 83.27,82.6 83.09,82.42 83.09,81.73 82.9,81.54 82.05,81.54 81.86,81.73 81.86,82.26 81.67,82.45 81.29,82.45 81.11,82.26 81.11,81.73 80.92,81.54 80.54,81.54 80.35,81.73 80.35,82.32 80.17,82.51 79.79,82.51 79.6,82.32 79.6,81.73 79.41,81.54 78.84,81.54 77.98,80.69 76.8,80.69 76.55,80.43 76.07,80.43 75.82,80.69 75.44,80.69 75.25,80.5 75.25,80.04 v1(75.03,79.82)
  BOTTOM w0.076: UC1.BA51 114.67,79.12 114.45,79.12 114.44,79.12 114.43,79.12 114.43,79.12 114.34,79.16 114.14,79.16 114.05,79.12 113.69,79.12 113.48,79.34 111.86,79.34 111.34,79.86 110.73,79.86 110.08,80.5 108.48,80.5 108.39,80.42 v1(108.39,80.14)
  BOTTOM w0.183: v1(75.03,79.82) 74.11,78.9 72.13,78.9 71.97,78.74 JDIMM1.126
DDR_A_MA6: length 51.8
  IN1 w0.076: v1(111.11,80.57) 110.42,80.57 110.18,80.81 109.43,80.81 109.36,80.73 109.36,79.91 109.05,79.6 105.75,79.6 105.31,80.04 105.31,80.54
  IN1 w0.183: 103.87,81.98 105.31,80.54
  IN1 w0.188: 103.87,81.98 90.7,81.98 87.12,78.4 83.39,78.4 83.2,78.58 83.2,79.48 83.01,79.67 82.64,79.67 82.45,79.48 82.45,78.58 82.26,78.4 81.89,78.4 81.7,78.58 81.7,79.48 81.51,79.67 81.13,79.67 80.95,79.48 80.95,79.1 80.68,78.83 79.82,78.83 79.63,78.65 79.63,78.1 79.44,77.91 78.8,77.91 78.61,78.1 78.61,78.51 78.42,78.7 78.05,78.7 77.86,78.51 77.86,78.1 77.67,77.91 76.74,77.91 76.56,78.1 v1(76.56,78.42)
  BOTTOM w0.076: v1(111.11,80.57) 111.11,80.67 111.23,80.79 111.34,80.79 112.3,79.84 114.49,79.84 114.57,79.76 UC1.BA52
  BOTTOM w0.183: v1(76.56,78.42) 76.56,78.8 76.71,78.95 77.56,78.95 78.02,78.49 79.15,78.49 JDIMM1.127
DDR_A_MA7: length 54.8
  IN1 w0.076: 103.37,85.72 103.6,85.72 105.04,84.27 105.04,83.49 106.59,81.94 108.44,81.94 108.52,81.86 v1(108.52,81.58)
  IN1 w0.188: 103.37,85.72 89.15,85.72 87.91,84.47 81.32,84.47 80.91,84.88 79.3,84.88 78.41,83.99 73.53,83.99 72.02,82.48 72.02,80.81 71.85,80.65 71.85,80.64 71.17,79.95 v1(69.54,79.95)
  BOTTOM w0.076: UC1.AW52 115.68,79.46 115.36,79.78 114.81,79.78 114.59,80 112.36,80 111.34,81.03 109.55,81.03 109.43,81.14 v2(109.36,81.14) 108.96,81.14 v1(108.52,81.58)
  BOTTOM w0.183: JDIMM1.122 69.71,79.74 69.54,79.91 v1(69.54,79.95)
DDR_A_MA8: length 53.3
  IN1 w0.076: v1(107.78,80.14) 107.86,80.21 107.86,80.46 107.69,80.63 106.56,80.63 104.1,83.09
  IN1 w0.183: 103.56,83.38 103.81,83.38 104.03,83.16 104.04,83.16 104.1,83.09
  IN1 w0.188: v1(76.56,79.82) 76.56,80.03 76.74,80.22 78.49,80.22 78.66,80.39 78.66,80.7 79.03,81.08 83.37,81.08 83.55,81.26 83.55,81.95 83.74,82.14 84.12,82.14 84.3,81.95 84.3,81.26 84.49,81.08 84.87,81.08 85.06,81.26 85.06,81.95 85.24,82.14 85.62,82.14 85.81,81.95 85.81,81.26 86,81.08 86.37,81.08 86.56,81.26 86.56,81.95 86.75,82.14 87.12,82.14 87.31,81.95 87.31,81.26 87.5,81.08 87.82,81.08 90.12,83.38 103.56,83.38
  BOTTOM w0.076: v1(107.78,80.14) 107.65,80.26 107.65,80.54 107.78,80.67 110.17,80.67 110.8,80.03 111.45,80.03 111.98,79.5 113.56,79.5 113.78,79.29 114.02,79.29 114.11,79.32 114.13,79.32 114.37,79.32 114.46,79.29 114.67,79.29 114.75,79.32 114.75,79.32 114.85,79.35 UC1.AY52
  BOTTOM w0.183: JDIMM1.125 79.15,78.99 78.1,78.99 77.85,79.24 75.93,79.24 75.76,79.41 75.76,79.82 75.96,80.02 76.36,80.02 v1(76.56,79.82)
DDR_A_MA9: length 52.8
  IN1 w0.076: v1(107.3,81.58) 107.1,81.39 106.91,81.39 104.81,83.49 104.81,84.19 103.75,85.25 103.37,85.25
  IN1 w0.188: 103.37,85.25 89.34,85.25 88.1,84.01 81.13,84.01 80.72,84.41 79.49,84.41 78.56,83.48 73.68,83.48 73.49,83.29 73.49,82.46 73.68,82.27 74.84,82.27 75.03,82.09 v1(75.03,81.64)
  BOTTOM w0.076: UC1.BB54 113.67,80.58 113.63,80.54 112.65,80.54 111.12,82.07 107.17,82.07 107.06,81.95 107.06,81.83 v1(107.3,81.58)
  BOTTOM w0.183: JDIMM1.121 79.15,79.99 78.15,79.99 77.8,80.34 76.34,80.34 v1(75.03,81.64)
DDR_A_MA10: length 53.2
  IN1 w0.076: v1(117.4,78.72) 117.4,79.07 116.9,79.56 115.86,79.56 115.67,79.37 115.67,78.2 115.88,77.99 115.88,77.75 115.32,77.19 112.71,77.19 112.54,77.02 111.41,77.02 111.25,77.19 108.86,77.19 108.81,77.13 103.66,77.13 103.56,77.23 103.37,77.23
  IN1 w0.188: v1(73.44,72.44) 73.87,72.86 77.47,72.86 77.86,72.47 78.33,72.47 78.51,72.66 78.51,72.81 78.7,73 79.08,73 79.27,72.81 79.27,72.66 79.45,72.47 89.49,72.47 94.24,77.23 103.37,77.23
  BOTTOM w0.076: v1(117.4,78.72) 117.68,78.43 UC1.AT50
  BOTTOM w0.183: JDIMM1.146 70.95,71.74 72.75,71.74 v1(73.44,72.44)
DDR_A_MA11: length 52.3
  IN1 w0.076: v1(110.35,81.58) 110.46,81.47 110.46,81.16 110.27,80.97 106.77,80.97 104.38,83.36 104.38,83.89 103.96,84.31 103.37,84.31
  IN1 w0.188: 103.37,84.31 89.73,84.31 88.13,82.72 87.87,82.72 87.51,83.07 83.08,83.07 82.64,82.63 82.15,82.63 81.71,83.07 79.69,83.07 79.2,82.58 78.93,82.58 78.51,82.16 78.51,81.89 77.78,81.15 75.12,81.15 74.94,80.97 74.94,80.42 74.75,80.24 74.37,80.24 74.18,80.42 74.18,80.97 74,81.15 73.7,81.15 73.07,80.53 73.07,80.26 v1(73.51,79.82)
  BOTTOM w0.076: UC1.BA54 114.36,80.58 114.1,80.33 112.62,80.33 111.04,81.9 110.42,81.9 110.35,81.83 v1(110.35,81.58)
  BOTTOM w0.183: JDIMM1.120 71.84,80.24 71.87,80.26 73.07,80.26 v1(73.51,79.82)
DDR_A_MA12: length 54.1
  IN1 w0.076: 103.37,84.78 103.58,85 103.77,85 104.57,84.19 104.57,83.49 106.92,81.14 109.92,81.14 110,81.22 110,81.51 109.92,81.58 v1(109.74,81.58)
  IN1 w0.188: 103.37,84.78 89.54,84.78 88.17,83.42 87.83,83.42 87.71,83.54 82.89,83.54 82.64,83.29 82.15,83.29 81.9,83.54 80.39,83.54 80.06,83.87 79.61,83.87 78.76,83.01 78.24,83.01 78.05,82.83 78.05,82.22 77.86,82.03 77.48,82.03 77.3,82.22 77.3,82.83 77.11,83.01 75.69,83.01 75.5,82.83 75.5,82.25 75.69,82.07 76.37,82.07 76.56,81.88 v1(76.56,81.64)
  BOTTOM w0.076: v1(109.74,81.58) 109.64,81.49 109.64,81.28 109.73,81.19 110.45,81.19 110.84,81.58 v2(110.96,81.58) 111.09,81.58 112.5,80.16 114.59,80.16 114.8,80.37 115.79,80.37 115.87,80.45 UC1.AW54
  BOTTOM w0.183: JDIMM1.119 78.32,80.49 78.14,80.67 76.42,80.67 76.07,81.02 76.07,81.31 76.4,81.64 v1(76.56,81.64)
DDR_A_MA13: length 56.8
  IN1 w0.076: 105.34,74.1 105.7,74.46 114.23,74.46 115.72,75.95 v1(116.71,75.95)
  IN1 w0.188: v1(75.03,69.06) 74.87,69.06 74.36,68.56 72.34,68.56 72.15,68.37 72.15,67.79 72.34,67.61 74.61,67.61 74.79,67.78 79.26,67.78 80.1,68.62 90.26,68.62 95.6,73.96 105.2,73.96 105.34,74.1
  BOTTOM w0.076: UC1.AU46 117.03,76.27 v1(116.71,75.95)
  BOTTOM w0.183: JDIMM1.158 70.96,68.74 72.07,68.74 72.19,68.62 74.59,68.62 v1(75.03,69.06)
DDR_A_ODT0: length 54.9
  IN1 w0.076: v1(117.35,75.97) 117.35,76.45 117.27,76.53 116.07,76.53 114.16,74.62 105.42,74.62 105.36,74.57
  IN1 w0.183: 104.78,74.42 105.22,74.42 105.36,74.57
  IN1 w0.188: 104.78,74.42 95.4,74.42 90.24,69.26 89.73,69.26 89.32,69.67 88.85,69.67 88.66,69.48 88.66,69.27 88.47,69.08 88.09,69.08 87.91,69.27 87.91,69.48 87.72,69.67 87.34,69.67 87.15,69.48 87.15,69.27 86.97,69.08 86.59,69.08 86.4,69.27 86.4,69.48 86.21,69.67 85.84,69.67 85.65,69.48 85.65,69.27 85.46,69.08 85.09,69.08 84.9,69.27 84.9,69.48 84.71,69.67 84.34,69.67 84.15,69.48 84.15,69.27 83.96,69.08 83.58,69.08 83.4,69.27 83.4,69.48 83.21,69.67 82.83,69.67 82.64,69.48 82.64,69.27 82.46,69.08 82.08,69.08 81.89,69.27 81.89,69.48 81.7,69.67 81.39,69.67 80.86,69.14 79.96,69.14 79.06,68.24 78.75,68.24 78.56,68.43 78.56,68.95 78.37,69.14 78,69.14 77.81,68.95 77.81,68.43 77.62,68.24 76.36,68.24 76.17,68.43 76.17,68.88 76.36,69.06 v1(76.56,69.06)
  BOTTOM w0.076: UC1.AT45 117.68,75.63 v1(117.35,75.97)
  BOTTOM w0.183: JDIMM1.155 77.89,69.49 77.81,69.56 77.05,69.56 v1(76.56,69.06)
DDR_A_ODT1: length 56.8
  IN1 w0.076: v1(117.34,74.21) 117.34,73.91 117.08,73.65 116.65,73.65 116.03,74.27 115.67,74.27 113.32,71.92 111.57,71.92 110.8,72.69 110.48,72.69
  IN1 w0.188: v1(76.56,66.89) 76.56,66.65 76.74,66.46 79.95,66.46 80.51,67.03 80.99,67.03 81.31,66.71 81.55,66.71 81.76,66.5 82.03,66.5 82.24,66.71 82.38,66.71 82.38,66.72 82.68,66.72 82.94,66.45 83.35,66.45 83.54,66.64 83.54,67.03 83.73,67.21 84.1,67.21 84.29,67.03 84.29,66.64 84.48,66.45 84.86,66.45 85.04,66.64 85.04,67.03 85.23,67.21 85.61,67.21 85.8,67.03 85.8,66.64 85.98,66.45 86.36,66.45 86.55,66.64 86.55,67.03 86.73,67.21 87.11,67.21 87.3,67.03 87.3,66.64 87.49,66.45 90.81,66.45 91,66.64 91,67.37 91.28,67.66 91.55,67.66 92.14,67.07 92.41,67.07 93.14,67.8 93.14,68.16 93.45,68.47 93.81,68.47 95.41,70.08 95.41,70.61 95.9,71.1 96.43,71.1 96.9,71.57 96.9,72.35 97.09,72.54 102.92,72.54 103.35,72.12 103.89,72.12 104.51,72.73 104.98,72.73 105.6,72.12 106.05,72.12 106.61,72.68 107.01,72.68 107.57,72.12 108.02,72.12 108.52,72.62 108.97,72.62 109.48,72.12 109.91,72.12 110.48,72.69
  BOTTOM w0.076: UC1.AT43 117.34,74.25 v1(117.34,74.21)
  BOTTOM w0.183: JDIMM1.161 77.66,67.99 v1(76.56,66.89)
DDR_A_PAR: length 51.5
  IN1 w0.076: v1(117.34,79.63) 117.18,79.79 115.75,79.79 115.35,79.38 115.35,78.87 115.29,78.8 115.29,78.47 115.35,78.41 115.35,78.29 115.15,78.09 114.28,78.09 114.2,78.02 114.2,77.81 114.11,77.73 113.97,77.73 113.9,77.8 113.9,78.02 113.82,78.09 113.62,78.09 113.54,78.02 113.54,77.82 113.46,77.74 113.31,77.74 113.24,77.82 113.24,78.02 113.16,78.09 112.96,78.09 112.88,78.02 112.88,77.82 112.8,77.74 112.65,77.74 112.58,77.82 112.58,78.02 112.5,78.09 111.58,78.09 111.52,78.02 111.52,77.8 111.38,77.67 105.73,77.67
  IN1 w0.188: v1(80.19,73.92) 80.19,73.6 80.38,73.41 81.11,73.41 81.52,73.81 82,73.81 82.4,73.41 82.89,73.41 83.32,73.84 83.81,73.84 84.24,73.41 84.73,73.41 85.16,73.84 85.59,73.84 86.02,73.41 86.45,73.41 86.88,73.84 87.39,73.84 87.83,73.41 88.16,73.41 88.83,74.08 89.1,74.08 89.3,73.87 89.57,73.87 89.95,74.25 89.95,74.52 89.42,75.05 89.42,75.31 89.68,75.58 89.95,75.58 90.48,75.05 90.74,75.05 91.01,75.32 91.01,75.58 90.48,76.11 90.48,76.38 90.75,76.64 91.01,76.64 91.54,76.12 91.81,76.12 93.85,78.16 103.53,78.16 104.02,77.67 104.33,77.67 104.52,77.86 104.52,77.96 104.71,78.15 105.08,78.15 105.27,77.96 105.27,77.86 105.46,77.67 105.73,77.67
  BOTTOM w0.076: v1(117.34,79.63) UC1.AT52
  BOTTOM w0.183: v1(80.19,73.92) 80.46,73.92 80.55,74.01 80.55,74.37 80.43,74.49 JDIMM1.143
DDR_A_RAS#: length 54.6
  IN1 w0.076: v1(116.68,77.84) 116.68,77.84 114.87,76.04 110.87,76.04 110.54,76.36 107.82,76.36
  IN1 w0.183: 103.44,75.83 104.49,75.83 105.03,76.36 107.82,76.36
  IN1 w0.188: v1(73.51,70.52) 73.51,70.01 73.32,69.82 71.97,69.82 71.8,69.99 71.8,70.81 72.06,71.07 90.07,71.07 94.82,75.83 103.44,75.83
  BOTTOM w0.076: v1(116.68,77.84) 116.68,77.9 UC1.AU50
  BOTTOM w0.183: v1(73.51,70.52) 73.07,70.08 72.22,70.08 72.06,70.24 JDIMM1.152
DDR_A_WE#: length 53.9
  IN1 w0.076: v1(117.34,76.88) 116.98,77.24 116.31,77.24 114.54,75.47 113.99,75.47 113.92,75.55 113.92,75.8 113.84,75.87 113.69,75.87 113.61,75.8 113.61,75.23 113.54,75.15 113.38,75.15 113.31,75.23 113.31,75.8 113.23,75.87 113.08,75.87 113,75.8 113,75.23 112.93,75.15 112.77,75.15 112.7,75.23 112.7,75.8 112.62,75.87 112.47,75.87 112.39,75.8 112.39,75.23 112.32,75.15 112.17,75.15 112.09,75.23 112.09,75.8 112.01,75.87 111.86,75.87 111.78,75.8 111.78,75.23 111.71,75.15 111.56,75.15 111.48,75.23 111.48,75.8 111.4,75.87 111.25,75.87 111.17,75.8 111.17,75.55 111.1,75.47 110.43,75.47 109.81,76.09 109.21,76.09
  IN1 w0.183: v1(76.56,70.52) 76.98,70.1 77.5,70.1 ; 109.21,76.09 105.14,76.09 104.4,75.36 103.56,75.36
  IN1 w0.188: 103.56,75.36 95.02,75.36 90.26,70.6 78,70.6 77.5,70.1
  BOTTOM w0.076: v1(117.34,76.88) UC1.AT46
  BOTTOM w0.183: JDIMM1.151 79.15,70.49 78.1,70.49 77.63,70.96 76.73,70.96 76.56,70.79 v1(76.56,70.52)
DDR_B_ACT#: length 67.6
  IN3 w0.076: 115.5,80.94 118.85,80.94 v1(119.24,80.54)
  IN3 w0.175: 105.15,83.21 105.54,82.82 111.03,82.82 112.07,81.77 113.75,81.77 114.59,80.94 115.5,80.94 ; 62.62,85.23 64.94,85.23
  IN3 w0.183: 105.15,83.21 105.15,83.73 104.14,84.73 92.5,84.73 90.98,86.25 89.14,86.25 87.79,87.6 71.07,87.6 70.55,87.08 66.8,87.08 64.94,85.23 ; 62.62,85.23 61.96,85.23 v1(60.83,84.09)
  BOTTOM w0.076: v1(119.24,80.54) UC1.AN53
  BOTTOM w0.183: v1(60.83,84.09) 60.83,83.54 59.04,81.74 JDIMM2.114
DDR_B_ALERT#: length 73.2
  IN3 w0.076: 103.37,77.51 103.55,77.33 119.95,77.33 120.25,77.03 120.25,75.8 119.94,75.5 119.66,75.5 v1(119.29,75.13)
  IN3 w0.183: 103.37,77.51 88.82,77.51 87.78,78.55 81.17,78.55 80.82,78.9 72.03,78.9 70.27,77.14 67.65,77.14 66.72,76.22 59.9,76.22 58.03,78.09 58.03,80.32 v1(56.92,81.44)
  BOTTOM w0.102: UC1.AN43 v1(119.29,75.13)
  BOTTOM w0.183: JDIMM2.116 58.25,81.24 57.12,81.24 v1(56.92,81.44)
DDR_B_BG0: length 69.3
  IN3 w0.076: v1(118.61,79.63) 118.61,79.91 118.53,79.98 115.88,79.98
  IN3 w0.175: 64.73,83.59 63.07,83.59 62.8,83.32 62.49,83.32 ; 104.84,82.26 106.6,82.26 106.61,82.25 110.85,82.25 112.75,80.35 114.42,80.35 114.79,79.98 115.88,79.98
  IN3 w0.183: v1(62.36,84.09) 62.34,84.09 62.02,83.78 62.02,83.52 62.21,83.32 62.49,83.32 ; 104.84,82.26 104.38,82.72 104.38,83.62 104.2,83.81 92.12,83.81 90.6,85.32 86.37,85.32 85.02,86.67 80.01,86.67 79.39,86.05 78.78,86.05 78.6,86.23 78.6,86.49 78.42,86.67 78.05,86.67 77.87,86.49 77.87,86.23 77.68,86.05 75.77,86.05 75.39,86.43 74.93,86.43 74.55,86.05 71.93,86.05 71.82,86.16 67.3,86.16 64.73,83.59
  BOTTOM w0.076: v1(118.61,79.63) 118.98,79.25 UC1.AP52
  BOTTOM w0.183: JDIMM2.115 65.56,81.49 64.73,82.32 63.99,82.73 63.27,83.24 62.78,83.67 v1(62.36,84.09)
DDR_B_BG1: length 68.6
  IN3 w0.076: v1(119.24,79.63) 119.41,79.8 119.41,80.1 119.32,80.19 116.2,80.19 116.13,80.25
  IN3 w0.175: 63.73,84.77 63.91,84.94 65.32,84.94 ; 116.13,80.25 114.9,80.25 114.53,80.62 112.86,80.62 110.92,82.55 104.93,82.55 104.65,82.83 ; 63.64,84.39 63.64,84.33 v1(63.88,84.09)
  IN3 w0.183: 65.32,84.94 66.99,86.62 70.89,86.62 71.08,86.8 71.08,86.95 71.26,87.13 71.62,87.13 71.81,86.95 71.81,86.8 71.99,86.62 72.4,86.62 72.92,87.13 85.21,87.13 86.56,85.79 86.87,85.79 87.05,85.97 87.05,86.95 87.23,87.13 87.6,87.13 87.78,86.95 87.78,85.97 87.97,85.79 90.79,85.79 92.31,84.27 104.22,84.27 104.65,83.84 104.65,82.83 ; 63.73,84.77 63.64,84.68 63.64,84.39
  BOTTOM w0.076: v1(119.24,79.63) 119.63,79.23 UC1.AN52
  BOTTOM w0.183: JDIMM2.113 65.7,81.99 65.3,82.39 65.3,82.67 v1(63.88,84.09)
DDR_B_BS0: length 69.5
  IN3 w0.076: 104.77,74.7 105.52,75.46 v1(106.44,75.46)
  IN3 w0.175: 62.69,72.76 v1(62.27,72.34) ; 104.77,74.7 104.69,74.7 103.61,73.62 103.04,73.62
  IN3 w0.183: 103.04,73.62 85.1,73.62 84.91,73.44 84.91,73.1 84.73,72.92 84.36,72.92 84.18,73.1 84.18,73.87 84,74.05 83.63,74.05 83.45,73.87 83.45,73.1 83.27,72.92 82.9,72.92 82.72,73.1 82.72,73.87 82.54,74.05 82.17,74.05 81.99,73.87 81.99,73.1 81.8,72.92 81.44,72.92 81.26,73.1 81.26,73.29 81.07,73.48 80.71,73.48 80.52,73.29 80.52,73.1 80.34,72.92 79.81,72.92 79.63,73.1 79.63,73.19 79.45,73.37 79.08,73.37 78.9,73.19 78.9,73.1 78.72,72.92 78.35,72.92 78.17,73.1 78.17,73.19 77.99,73.37 76.61,73.37 76.43,73.56 76.43,73.62 76.24,73.8 75.88,73.8 75.69,73.62 75.69,73.56 75.51,73.37 74.4,73.37 74.39,73.37 71.9,73.37 71.46,72.93 67.08,72.93 66.49,72.34 65.15,72.34 64.73,72.76 62.69,72.76
  BOTTOM w0.076: UC1.BB44 113.82,74.84 112.53,74.84 112.43,74.94 110.42,74.94 110.34,74.87 109.58,74.87 109.45,74.73 v2(109.33,74.73) 109.2,74.73 109.07,74.87 104.9,74.87 104.82,74.94 104.82,75.93 104.9,76 106.36,76 106.44,75.93 v1(106.44,75.46)
  BOTTOM w0.183: JDIMM2.150 59.62,70.74 59.96,71.08 61.95,71.08 62.27,71.4 v1(62.27,72.34)
DDR_B_BS1: length 67.8
  IN3 w0.175: v1(108.45,75.46) 108.66,75.25 108.66,74.98 108.49,74.8 107.89,74.8 107.68,75.01 107.17,75.01 106.96,74.8 106.43,74.8 106.26,74.98 106.26,75.07 106.08,75.25 105.68,75.25 104.69,74.26 104.62,74.26 103.52,73.16 103.28,73.16 ; v1(63.79,72.34) 63.79,72.05 63.97,71.88
  IN3 w0.183: 63.97,71.88 66.68,71.88 67.27,72.47 71.95,72.47 72.1,72.62 72.1,72.77 72.23,72.91 74.58,72.91 74.59,72.91 77.64,72.91 77.82,72.73 77.82,72.64 78,72.45 78.91,72.45 79.11,72.65 79.42,72.65 79.62,72.45 80.53,72.45 80.72,72.64 81.06,72.64 81.25,72.45 81.58,72.45 81.76,72.27 81.76,72.03 81.94,71.84 82.31,71.84 82.49,72.03 82.49,72.27 82.67,72.45 83.04,72.45 83.22,72.27 83.22,72.03 83.41,71.84 84.03,71.84 84.22,72.03 84.22,72.27 84.4,72.45 84.76,72.45 84.95,72.27 84.95,72.03 85.13,71.84 85.5,71.84 85.68,72.03 85.68,72.98 85.86,73.16 86.23,73.16 86.41,72.98 86.41,72.03 86.59,71.84 86.96,71.84 87.14,72.03 87.14,72.98 87.32,73.16 87.69,73.16 87.87,72.98 87.87,72.03 88.06,71.84 88.42,71.84 88.6,72.03 88.6,72.98 88.79,73.16 103.28,73.16
  BOTTOM w0.076: UC1.BA44 114.3,75.01 112.59,75.01 112.49,75.11 110.35,75.11 110.27,75.03 108.21,75.03 108.14,75.1 108.14,75.34 108.26,75.46 v1(108.45,75.46)
  BOTTOM w0.183: v1(63.79,72.34) 63.79,73.26 63.96,73.43 65.11,73.43 65.28,73.26 65.28,72.24 65.53,71.99 JDIMM2.145
DDR_B_CAS#: length 69.5
  IN3 w0.175: v1(106.38,73.87) 106.38,73.28 106.2,73.11 105.04,73.11 103.25,71.31 102.86,71.31
  IN3 w0.183: 102.86,71.31 101.04,71.31 100.48,70.75 92.39,70.75 91.1,69.46 83.54,69.46 83.01,70 81.17,70 80.67,70.5 80.29,70.5 80.06,70.27 78.94,70.27 78.65,69.97 77.7,69.97 65.63,69.97 65.16,69.51 63.66,69.51 63.13,70.04 58.51,70.04 58.33,69.86 58.33,68.83 58.51,68.64 60.67,68.64 60.81,68.78 v1(60.81,69.06)
  BOTTOM w0.076: v1(106.38,73.87) 106.38,74.17 106.51,74.3 107.08,74.3 107.51,73.87 107.51,73.62 107.73,73.39 108.31,73.39 v2(108.4,73.48) 108.48,73.55 108.48,73.96 108.72,74.2 109.62,74.2 109.9,74.48 110.42,74.48 110.55,74.61 112.3,74.61 112.45,74.46 113.54,74.46 113.69,74.31 114.06,74.31 114.17,74.36 114.29,74.36 114.51,74.29 114.65,74.29 114.81,74.35 114.99,74.35 115.15,74.27 115.25,74.27 UC1.AY43
  BOTTOM w0.183: v1(60.81,69.06) 60.27,68.53 59.9,68.53 59.19,69.24 JDIMM2.156
DDR_B_CKE0: length 64.5
  IN3 w0.076: 115.18,81.2 116.1,81.2 116.2,81.1 119.16,81.1 119.24,81.18 v1(119.24,81.46)
  IN3 w0.175: 105.42,83.32 105.65,83.08 111.14,83.08 112.18,82.04 113.86,82.04 114.7,81.2 115.18,81.2 ; v1(63.98,85.67) 64.28,85.96
  IN3 w0.183: 105.42,83.32 105.42,83.84 104.07,85.19 92.69,85.19 91.17,86.71 89.33,86.71 87.98,88.06 67.12,88.06 65.21,86.15 64.46,86.15 64.28,85.96
  BOTTOM w0.076: UC1.AN56 119.63,81.85 v1(119.24,81.46)
  BOTTOM w0.183: JDIMM2.109 65.65,82.99 65.35,83.29 65.35,84.3 v1(63.98,85.67)
DDR_B_CKE1: length 67
  IN3 w0.076: v1(118.61,81.46) 118.24,81.82 114.5,81.82 114.36,81.96
  IN3 w0.175: 104.81,84.83 104.81,84.83 105.69,83.95 110.65,83.95 112.29,82.3 114.02,82.3 114.36,81.96
  IN3 w0.183: v1(60.93,85.67) 62.4,87.13 65.54,87.13 66.93,88.52 88.17,88.52 89.52,87.17 91.36,87.17 92.88,85.65 103.99,85.65 104.81,84.83
  BOTTOM w0.076: v1(118.61,81.46) UC1.AP55
  BOTTOM w0.183: JDIMM2.110 59.22,82.74 59.35,82.87 59.35,84.08 v1(60.93,85.67)
DDR_B_CKE2: length 1.1
  TOP w0.089: TP5.1 119.59,80.88 v1(119.89,80.58)
  BOTTOM w0.076: UC1.AN55 119.85,80.62 119.88,80.61 v1(119.89,80.58)
DDR_B_CKE3: length 1.2
  TOP w0.089: TP6.1 118.62,80.29 v1(118.62,80.54)
  BOTTOM w0.076: v1(118.62,80.54) UC1.AP53
DDR_B_CLK0: length 69.8
  IN3 w0.076: v1(118.65,75.97) 118.79,75.97 118.94,75.82 118.94,75.65 118.86,75.58 116.27,75.58 116.12,75.43 116.12,74.89 115.73,74.49 114.98,74.49 114.91,74.57 114.91,74.97 115.4,75.47 115.4,76.04 115.23,76.21 114.01,76.21 113.7,75.9 113.29,75.9 112.92,76.27 112.92,76.48 112.75,76.65 112.26,76.65 111.92,76.32 111.69,76.32 111.35,76.65 105.33,76.65 104.69,76.01 103.41,76.01 103.4,76 103.39,76 103.39,76 103.38,76.01 103.37,76.01
  IN3 w0.117: 103.37,76.01 103.36,76.01 88.19,76.01 87.12,77.09 80.4,77.09 80.24,77.25 79.29,77.25 78.83,76.79 78.34,76.79 77.9,77.23 72.36,77.23 70.53,75.41 68.35,75.41 67.72,74.78 66.4,74.78 65.97,74.35 65.74,74.35 65.34,74.76 64.78,74.76 64.23,74.2 63.18,74.2 63.06,74.32 63.06,74.59 63.25,74.78 v1(63.47,74.78)
  BOTTOM w0.076: v1(118.65,75.97) 118.55,75.87 118.55,75.68 118.61,75.63 118.61,75.54 118.76,75.39 118.86,75.39 UC1.AP45
  BOTTOM w0.102: v1(63.47,74.78) 63.19,74.78 63.08,74.66 63.08,74.46 63.18,74.35 64.37,74.35 64.74,74.72 64.74,75 65.73,75.99 JDIMM2.137
DDR_B_CLK1: length 68.5
  IN3 w0.076: 103.37,76.82 103.38,76.82 103.4,76.8 103.45,76.8 103.47,76.77 103.57,76.77 104.01,76.34 104.52,76.34 104.72,76.54 104.72,76.94 104.89,77.11 113.62,77.11 113.79,76.94 113.79,76.61 113.87,76.54 114.3,76.54 114.38,76.61 114.38,76.98 114.55,77.15 115.22,77.15 115.39,76.98 115.39,76.52 115.78,76.12 116.15,76.12 116.54,76.51 118.84,76.51 118.92,76.59 118.92,76.73 118.77,76.88 v1(118.61,76.88)
  IN3 w0.117: v1(60.43,74.78) 60.71,75.07 60.71,75.29 60.98,75.56 67.28,75.56 67.91,76.19 70.25,76.19 72.05,77.99 77.64,77.99 77.89,78.24 78.47,78.24 78.72,77.99 79.29,77.99 79.5,78.21 80.2,78.21 80.41,77.99 80.54,77.99 80.71,77.82 87.58,77.82 88.58,76.82 103.37,76.82
  BOTTOM w0.076: UC1.AP46 118.98,76.51 v1(118.61,76.88)
  BOTTOM w0.102: v1(60.43,74.78) 60.51,74.78 60.69,74.59 60.69,74.42 60.59,74.32 60.05,74.32 59.72,74.64 59.72,75.35 59.48,75.59 59.25,75.59 59.1,75.74 JDIMM2.138
DDR_B_CLK#0: length 69.7
  IN3 w0.076: 103.37,75.78 103.37,75.78 103.37,75.8 103.41,75.84 104.76,75.84 105.4,76.49 111.29,76.49 111.62,76.15 111.99,76.15 112.33,76.49 112.68,76.49 112.76,76.41 112.76,76.2 113.22,75.73 113.77,75.73 114.08,76.04 115.16,76.04 115.24,75.97 115.24,75.54 114.74,75.04 114.74,74.5 114.91,74.33 115.8,74.33 116.29,74.82 116.29,75.36 116.34,75.41 118.93,75.41 119.1,75.58 119.1,75.83 v1(119.25,75.99)
  IN3 w0.117: v1(62.71,74.78) 62.85,74.64 62.85,74.23 63.09,73.99 64.31,73.99 64.87,74.55 65.25,74.55 65.66,74.14 66.06,74.14 66.49,74.57 67.81,74.57 68.44,75.2 70.62,75.2 72.44,77.02 77.82,77.02 78.26,76.58 78.92,76.58 79.38,77.04 80.15,77.04 80.31,76.88 87.03,76.88 88.11,75.8 103.23,75.8 103.26,75.78 103.37,75.78
  BOTTOM w0.076: v1(119.25,75.99) 119.63,75.6 UC1.AN45
  BOTTOM w0.102: v1(62.71,74.78) 62.85,74.64 62.85,74.36 63.08,74.13 64.46,74.13 64.47,74.13 64.47,74.15 64.95,74.63 64.95,74.91 65.53,75.49 JDIMM2.139
DDR_B_CLK#1: length 68.7
  IN3 w0.076: v1(119.24,76.88) 119.09,76.73 119.09,76.52 118.91,76.35 116.61,76.35 116.22,75.95 115.72,75.95 115.22,76.45 115.22,76.91 115.15,76.99 114.62,76.99 114.54,76.91 114.54,76.55 114.37,76.37 113.8,76.37 113.63,76.55 113.63,76.87 113.55,76.94 104.96,76.94 104.89,76.87 104.89,76.47 104.59,76.17 103.94,76.17 103.5,76.61 103.37,76.61
  IN3 w0.102: 61,74.97 v1(61.19,74.78)
  IN3 w0.117: 61,74.97 60.93,75.04 60.93,75.21 61.07,75.35 67.37,75.35 68,75.98 70.34,75.98 72.14,77.78 77.72,77.78 77.98,78.03 78.38,78.03 78.63,77.78 79.37,77.78 79.59,78 80.11,78 80.32,77.78 80.45,77.78 80.62,77.61 87.49,77.61 88.49,76.61 103.37,76.61
  BOTTOM w0.076: v1(119.24,76.88) 119.63,76.49 UC1.AN46
  BOTTOM w0.102: v1(61.19,74.78) 61.06,74.78 60.92,74.64 60.92,74.32 60.68,74.09 59.95,74.09 59.6,74.44 59.6,74.47 59.51,74.55 59.51,75.23 59.38,75.37 59.21,75.37 59.08,75.24 JDIMM2.140
DDR_B_CS#0: length 67.8
  IN3 w0.076: v1(110.09,73.74) 110.09,74.17 109.84,74.42 109.23,74.42 108.99,74.18 108.34,74.18 108.1,74.42 105.56,74.42 104.86,73.73
  IN3 w0.175: 103.39,72.23 104.86,73.71 104.86,73.73
  IN3 w0.183: v1(62.33,70.51) 62.5,70.51 63.16,71.17 63.62,71.17 63.84,70.95 67.07,70.95 67.66,71.54 68.42,71.54 68.74,71.22 69,71.22 69.33,71.54 70.08,71.54 70.09,71.53 72.11,71.53 77.33,71.53 77.34,71.52 80.95,71.52 81.56,70.92 90.91,70.92 91.09,71.1 91.09,72.05 91.27,72.23 92.05,72.23 92.23,72.05 92.23,71.86 92.42,71.67 92.78,71.67 92.97,71.86 92.97,72.05 93.15,72.23 93.51,72.23 93.7,72.05 93.7,71.86 93.88,71.67 94.25,71.67 94.43,71.86 94.43,72.05 94.61,72.23 94.98,72.23 95.16,72.05 95.16,71.86 95.34,71.67 95.71,71.67 95.89,71.86 95.89,72.05 96.07,72.23 96.44,72.23 96.62,72.05 96.62,71.86 96.81,71.67 97.17,71.67 97.36,71.86 97.36,72.05 97.54,72.23 97.9,72.23 98.09,72.05 98.09,71.86 98.27,71.67 98.64,71.67 98.82,71.86 98.82,72.05 99,72.23 99.37,72.23 99.55,72.05 99.55,71.86 99.73,71.67 100.1,71.67 100.28,71.86 100.28,72.05 100.46,72.23 103.39,72.23
  BOTTOM w0.076: v1(110.09,73.74) 109.97,73.86 109.97,74.03 110.06,74.13 110.53,74.13 110.68,74.28 111,74.28 111.06,74.22 111.06,73.98 111.15,73.89 111.3,73.89 111.38,73.97 v2(111.38,74.09) 111.38,74.21 111.45,74.28 111.66,74.28 111.73,74.21 111.73,73.69 111.95,73.47 112.21,73.47 112.29,73.56 112.29,73.71 112.37,73.78 112.52,73.78 112.6,73.71 112.6,73.56 112.69,73.47 112.87,73.47 112.93,73.42 UC1.BB42
  BOTTOM w0.183: JDIMM2.149 65.45,70.99 65.3,71.14 65.3,71.75 65.2,71.85 62.71,71.85 62.59,71.74 62.59,70.78 62.33,70.52 v1(62.33,70.51)
DDR_B_CS#1: length 68.3
  IN3 w0.175: 65.28,67.48 63.11,67.48 62.96,67.32 ; v1(111.34,73.35) 111.7,73.35 111.87,73.18 111.87,72.71 111.48,72.31 110.64,72.31 110.46,72.49 110.46,73.16 110.29,73.34 109.94,73.34 109.76,73.16 109.76,72.49 109.59,72.31 105.37,72.31 102.98,69.92
  IN3 w0.183: 102.98,69.92 101.62,69.92 101.06,69.36 92.96,69.36 92.09,68.49 91.67,68.07 82.97,68.07 82.43,68.61 80.1,68.61 79.72,68.23 79.72,68.23 79.42,67.93 70.57,67.93 70.39,68.12 70.39,68.43 70.24,68.59 69.65,68.59 69.21,68.14 68.82,68.14 68.38,68.59 66.84,68.59 66.66,68.4 66.66,68.08 66.51,67.93 66.05,67.93 65.78,67.66 65.6,67.48 65.28,67.48 ; 62.96,67.32 62.51,67.32 62.33,67.14 v1(62.33,66.89)
  BOTTOM w0.076: v1(111.34,73.35) 111.03,73.35 110.88,73.2 110.88,72.97 110.96,72.89 v2(111.88,72.89) 112.06,72.89 112.32,73.15 112.74,73.15 112.79,73.09 113.46,73.09 113.56,72.98 114.06,72.98 114.09,73 114.24,73.06 115.23,73.06 115.3,73.13 115.3,73.33 UC1.AY42
  BOTTOM w0.183: JDIMM2.157 65.41,68.99 64.89,68.47 62.38,68.47 62.18,68.27 62.18,67.04 v1(62.33,66.89)
DDR_B_D0: length 75.8
  IN3 w0.076: 115.36,97.5 123.15,89.71 123.15,86.93 v1(122.63,86.4)
  IN3 w0.117: v1(60.05,103.46) 61.14,104.55 65.5,104.55 65.5,104.55 71.77,104.55 71.97,104.75 79.01,104.75 79.18,104.58 82.23,104.58 85.02,101.79 94.1,101.79 94.49,101.41 107.7,101.41 111.01,98.1 114.75,98.1 115.36,97.5
  BOTTOM w0.076: UC1.AF65 v1(122.63,86.4)
  BOTTOM w0.112: v1(60.05,103.46) 59.64,103.46 59.41,103.24 58.25,103.24 JDIMM2.28
DDR_B_D1: length 74.2
  IN3 w0.076: 116.02,95.91 116.05,95.91 122.27,89.68 122.27,86.13 v1(122.63,85.77)
  IN3 w0.109: v1(64.62,103.46) 65.31,103.46
  IN3 w0.117: 65.31,103.46 66.46,103.46 66.56,103.56 68.15,103.56 68.36,103.34 68.61,103.34 68.83,103.56 69.81,103.56 70.02,103.34 70.27,103.34 70.49,103.56 70.74,103.56 70.96,103.34 71.21,103.34 71.43,103.56 72.18,103.56 72.39,103.76 78.12,103.76 78.65,103.23 79.95,103.23 80.3,103.58 80.63,103.58 80.98,103.23 82.16,103.23 84.6,100.79 93.69,100.79 94.07,100.41 106.53,100.41 106.9,100.05 107.06,100.05 107.26,100.25 107.43,100.25 107.59,100.08 107.59,99.92 107.39,99.72 107.39,99.55 107.56,99.38 107.72,99.38 107.92,99.58 108.09,99.58 108.26,99.42 108.26,99.25 108.06,99.05 108.06,98.89 108.22,98.72 108.39,98.72 108.59,98.92 108.75,98.92 108.92,98.76 108.92,98.59 108.72,98.39 108.72,98.23 108.97,97.98 109.13,97.98 109.34,98.19 109.51,98.19 109.68,98.02 109.68,97.86 109.47,97.64 109.47,97.48 109.63,97.31 109.75,97.31 110.13,96.94 110.13,96.82 110.38,96.56 111.9,96.56 112.18,96.29 115.63,96.29 116.02,95.91
  BOTTOM w0.076: UC1.AF64 v1(122.63,85.77)
  BOTTOM w0.112: v1(64.62,103.46) 65.15,103.99 JDIMM2.25
DDR_B_D2: length 74.8
  IN3 w0.076: v1(120.82,86.42) 120.42,86.82 120.42,87.26 120.16,87.51 120.16,88.16 119.03,89.29 118.79,89.29 116.35,91.73 116.35,92.05 115.01,93.38 114.18,93.38
  IN3 w0.109: 112,94.14 113.42,94.14 114.18,93.38
  IN3 w0.117: v1(61.57,100.73) 61.98,100.32 65.1,100.32 65.21,100.43 69.76,100.43 69.96,100.22 82.14,100.22 83.55,98.82 92.87,98.82 94.26,97.43 105.4,97.43 105.59,97.25 105.76,97.25 106.25,97.74 106.42,97.74 106.58,97.57 106.58,97.41 106.09,96.91 106.09,96.75 106.25,96.58 106.42,96.58 106.91,97.08 107.08,97.08 107.24,96.91 107.24,96.75 106.75,96.25 106.75,96.09 106.92,95.91 107.09,95.91 107.46,96.29 107.63,96.29 107.79,96.12 107.79,95.96 107.42,95.58 107.42,95.42 108.7,94.14 112,94.14
  BOTTOM w0.076: v1(120.82,86.42) 121.12,86.72 UC1.AK65
  BOTTOM w0.112: v1(61.57,100.73) 60.58,99.74 JDIMM2.42
DDR_B_D3: length 75.5
  IN3 w0.076: v1(120.82,85.74) 120.23,86.33 120.23,87.19 119.92,87.5 119.92,87.84 119.23,88.53 118.76,88.53 116.54,90.74 116.54,91.25 116.16,91.63 116.16,92 115.61,92.55 114.24,92.55 113.01,93.78 111.65,93.78
  IN3 w0.117: 111.65,93.78 108.58,93.78 105.27,97.1 94.12,97.1 92.74,98.49 83.41,98.49 82.01,99.89 69.83,99.89 69.62,100.1 65.76,100.1 65.53,99.86 61.15,99.86 60.42,99.13 58.56,99.13 58.33,99.36 58.33,100.48 58.58,100.73 v1(60.05,100.73)
  BOTTOM w0.076: v1(120.82,85.74) 121.14,86.07 UC1.AK64
  BOTTOM w0.112: v1(60.05,100.73) 59.32,100.73 59.31,100.74 JDIMM2.38
DDR_B_D4: length 74.8
  IN3 w0.076: 115.12,97.26 115.16,97.26 122.98,89.44 122.98,87.34 122.68,87.04 v1(122.63,87.04)
  IN3 w0.117: v1(61.57,103.46) 62.33,104.22 65.88,104.22 65.88,104.22 71.91,104.22 72.11,104.42 78.87,104.42 79.04,104.25 80.9,104.25 81.25,103.9 82.44,103.9 84.88,101.46 93.97,101.46 94.35,101.08 107.56,101.08 110.87,97.77 114.61,97.77 115.12,97.26
  BOTTOM w0.076: UC1.AF66 v1(122.63,87.04)
  BOTTOM w0.112: v1(61.57,103.46) 60.79,104.24 JDIMM2.24
DDR_B_D5: length 74.7
  IN3 w0.076: v1(122.63,87.67) 122.63,89.56 115.26,96.93 114.98,96.93
  IN3 w0.102: 65.26,103.84 63.48,103.84 v1(63.1,103.46)
  IN3 w0.117: 114.98,96.93 114.47,97.44 113.73,97.44 113.61,97.32 113.61,96.85 113.46,96.7 113.29,96.7 113.14,96.85 113.14,97.15 113.03,97.26 112.79,97.26 112.68,97.15 112.68,96.85 112.56,96.74 112.36,96.74 112.2,96.9 111.85,96.9 111.73,97.01 111.73,97.32 111.62,97.44 111.23,97.44 111.11,97.32 111.11,97.01 110.99,96.9 110.64,96.9 110.08,97.46 110.08,98.09 107.42,100.74 94.21,100.74 93.83,101.13 84.74,101.13 82.3,103.56 81.11,103.56 80.76,103.91 78.65,103.91 78.48,104.09 72.25,104.09 72.05,103.89 66.42,103.89 66.38,103.84 65.26,103.84
  BOTTOM w0.076: UC1.AF67 v1(122.63,87.67)
  BOTTOM w0.112: v1(63.1,103.46) 63.57,102.99 66.45,102.99 JDIMM2.29
DDR_B_D6: length 73.4
  IN3 w0.076: v1(120.82,87.72) 120.82,88.09 119.23,89.67 118.88,89.67 116.85,91.7 116.85,92.99 115.07,94.77
  IN3 w0.117: v1(63.09,100.73) 63.84,101.48 81.99,101.48 83.98,99.49 93.15,99.49 93.53,99.11 99.1,99.11 99.22,98.99 99.22,98.22 99.34,98.1 99.57,98.1 99.69,98.22 99.69,98.99 99.8,99.11 100.04,99.11 100.15,98.99 100.15,98.54 100.27,98.42 100.51,98.42 100.62,98.54 100.62,98.99 100.74,99.11 100.97,99.11 101.09,98.99 101.09,98.58 101.21,98.46 101.44,98.46 101.56,98.58 101.56,98.99 101.67,99.11 101.92,99.11 102.03,98.99 102.03,98.8 102.15,98.69 102.38,98.69 102.5,98.8 102.5,98.99 102.62,99.11 105.99,99.11 110.14,94.95 114.88,94.95 115.07,94.77
  BOTTOM w0.076: UC1.AK67 121.12,88.02 v1(120.82,87.72)
  BOTTOM w0.112: JDIMM2.41 66.45,99.99 63.84,99.99 v1(63.09,100.73)
DDR_B_D7: length 74
  IN3 w0.076: 114.38,93.56 115.07,93.56 116.51,92.12 116.51,91.8 118.83,89.48 119.13,89.48 120.42,88.19 120.42,87.57 120.8,87.19 v1(120.8,87.04)
  IN3 w0.109: 113.43,94.51 114.38,93.56
  IN3 w0.117: 113.43,94.51 110.12,94.51 109.71,94.92 109.54,94.92 109.29,94.67 109.12,94.67 108.96,94.83 108.96,95 109.21,95.25 109.21,95.42 108.96,95.66 108.8,95.66 108.44,95.3 108.27,95.3 108.1,95.47 108.1,95.63 108.47,96 108.47,96.16 106.55,98.07 104.11,98.07 103.8,97.77 98.5,97.77 98.38,97.88 98.38,98.29 98.27,98.41 98.03,98.41 97.91,98.29 97.91,97.88 97.8,97.77 97.55,97.77 97.44,97.88 97.44,98.66 97.32,98.77 97.09,98.77 96.97,98.66 96.97,97.88 96.85,97.77 96.62,97.77 96.5,97.88 96.5,98.66 96.39,98.77 96.15,98.77 96.04,98.66 96.04,97.88 95.92,97.77 95.68,97.77 95.57,97.88 95.57,98.66 95.45,98.77 95.22,98.77 95.1,98.66 95.1,97.88 94.98,97.77 94.4,97.77 93.01,99.15 83.84,99.15 81.85,101.15 65.03,101.15 v1(64.62,100.73)
  BOTTOM w0.076: UC1.AK66 v1(120.8,87.04)
  BOTTOM w0.112: JDIMM2.37 65.29,100.99 65.03,100.73 v1(64.62,100.73)
DDR_B_D8: length 82.9
  IN3 w0.076: 123.88,94.53 v1(123.24,93.89)
  IN3 w0.109: 64.57,108.2 64.45,108.08 61.59,108.08 61.47,108.2
  IN3 w0.117: 64.57,108.2 64.67,108.3 64.7,108.3 65.95,109.55 70.12,109.55 70.23,109.44 70.23,109.36 70.35,109.24 70.58,109.24 70.7,109.36 70.7,109.44 70.82,109.55 79.63,109.55 79.65,109.57 82.58,109.57 86.07,106.09 116.14,106.09 116.19,106.04 116.95,105.28 116.95,105.28 120.14,102.09 121.17,102.09 124.21,99.06 124.21,97.63 123.88,97.31 123.88,94.53 ; 61.47,108.2 61.26,108.41 61.26,108.58 v1(61.57,108.89)
  BOTTOM w0.076: v1(123.24,93.89) 123.43,93.89 124.1,93.23 124.1,90.89 123.39,90.19 UC1.AF70
  BOTTOM w0.112: v1(61.57,108.89) 60.92,108.24 JDIMM2.8
DDR_B_D9: length 84.7
  IN3 w0.076: v1(123.25,95.07) 123.25,95.44 123.54,95.73 123.54,95.75
  IN3 w0.109: 61.47,107.86 64.57,107.86
  IN3 w0.117: 123.54,95.75 123.54,97.44 123.57,97.46 123.88,97.77 123.88,98.92 121.04,101.76 120,101.76 117.36,104.4 116.05,105.71 116,105.75 85.81,105.75 82.67,108.9 79.93,108.9 79.47,108.43 71.91,108.43 71.79,108.55 65.5,108.55 65.07,108.12 64.99,108.12 64.83,107.96 64.82,107.96 64.72,107.86 64.57,107.86 ; v1(60.05,108.89) 59.31,108.89 59.19,108.77 59.19,107.98 59.31,107.86 61.47,107.86
  BOTTOM w0.076: UC1.AF68 123.61,88.99 123.61,89.73 123.71,89.82 123.71,90.27 124.48,91.04 124.48,94.05 v2(124.07,94.46) 123.46,95.07 v1(123.25,95.07)
  BOTTOM w0.112: v1(60.05,108.89) 59.69,109.24 JDIMM2.4
DDR_B_D10: length 82.3
  IN3 w0.076: 122.57,98.07 122.57,96.73 122.46,96.63 122.46,96.57 v1(122.2,96.31)
  IN3 w0.109: v1(64.56,106.21) 65.01,106.21
  IN3 w0.117: 122.57,98.07 122.57,98.38 120.49,100.46 119.46,100.46 115.51,104.4 115.51,104.4 115.46,104.45 111.27,104.45 110.88,104.06 100.63,104.06 100.51,103.94 100.51,103.76 100.36,103.61 100.2,103.61 100.05,103.76 100.05,103.94 99.93,104.06 99.7,104.06 99.58,103.94 99.58,103.58 99.46,103.46 99.23,103.46 99.11,103.58 99.11,103.94 98.99,104.06 98.61,104.06 98.5,103.94 98.5,103.62 98.38,103.5 98.15,103.5 98.03,103.62 98.03,104.33 97.91,104.45 97.68,104.45 97.56,104.33 97.56,103.52 97.45,103.4 97.21,103.4 97.09,103.52 97.09,104.33 96.98,104.45 96.74,104.45 96.63,104.33 96.63,103.52 96.51,103.4 96.28,103.4 96.16,103.52 96.16,104.33 96.04,104.45 95.81,104.45 95.69,104.33 95.69,103.52 95.58,103.4 95.34,103.4 95.23,103.52 95.23,104.33 95.11,104.45 85.27,104.45 82.23,107.49 80.37,107.49 79.67,106.79 71.4,106.79 70.94,107.25 69.18,107.25 68.64,106.71 65.5,106.71 65.01,106.21
  BOTTOM w0.076: v1(122.2,96.31) 121.62,95.73 121.62,94.48 121.37,94.23 121.37,92.75 122.07,92.06 UC1.AH71
  BOTTOM w0.112: JDIMM2.21 66.45,104.99 65.36,104.99 64.56,105.79 v1(64.56,106.21)
DDR_B_D11: length 84.8
  IN3 w0.076: 118.89,99.6 120.14,99.6 120.51,99.23 120.51,97.02 121.87,95.66 v1(122.2,95.66)
  IN3 w0.117: 118.89,99.6 115.05,103.45 111.68,103.45 110.16,101.93 94.7,101.93 94.32,102.31 85.23,102.31 81.63,105.92 80.22,105.92 79.57,105.28 70.09,105.28 69.66,105.71 65.92,105.71 65.37,105.16 58.42,105.16 58.25,105.33 58.25,106.1 58.37,106.21 v1(59.99,106.21)
  BOTTOM w0.076: UC1.AH68 122.75,88.67 122.95,88.86 122.95,89.12 122.96,89.13 122.96,89.39 122.97,89.4 122.97,89.45 123,89.47 123,89.74 122.95,89.86 122.95,90.09 122.96,90.1 122.96,90.11 122.96,90.11 123,90.2 123,90.4 122.96,90.49 122.96,90.84 123.31,91.2 123.31,91.5 122.77,92.05 122.77,95.1 v2(122.75,95.11) v1(122.2,95.66)
  BOTTOM w0.112: v1(59.99,106.21) 59.99,105.8 59.42,105.24 58.25,105.24 JDIMM2.20
DDR_B_D12: length 81.8
  IN3 w0.076: v1(123.24,93.31) 124.22,94.29 124.22,96.66
  IN3 w0.117: 124.22,96.66 124.22,97.15 124.54,97.48 124.54,99.2 121.31,102.43 120.27,102.43 118.11,104.59 117.09,105.61 117.09,105.61 116.33,106.37 116.28,106.42 86.21,106.42 82.72,109.9 79.51,109.9 79.49,109.89 76.9,109.89 76.79,110 76.79,110.51 76.67,110.63 76.44,110.63 76.32,110.51 76.32,110 76.2,109.89 70.59,109.89 70.48,110 70.48,110.24 70.36,110.36 70.13,110.36 70.01,110.24 70.01,110 69.89,109.89 69.65,109.89 69.53,110 69.53,110.37 69.41,110.48 69.18,110.48 69.06,110.37 69.06,110 68.95,109.89 68.71,109.89 68.6,110 68.6,110.37 68.48,110.48 68.25,110.48 68.13,110.37 68.13,110 68.01,109.89 67.78,109.89 67.66,110 67.66,110.37 67.55,110.48 67.31,110.48 67.19,110.37 67.19,110 67.08,109.89 66.84,109.89 66.73,110 66.73,110.37 66.61,110.48 66.38,110.48 66.26,110.37 66.26,110 66.14,109.89 65.82,109.89 65.25,109.32 65.05,109.32 v1(64.62,108.89)
  BOTTOM w0.076: UC1.AF71 123.72,90.95 v2(123.72,92.62) 123.72,92.85 123.26,93.31 v1(123.24,93.31)
  BOTTOM w0.112: v1(64.62,108.89) 65.01,108.49 JDIMM2.7
DDR_B_D13: length 83.3
  IN3 w0.076: v1(123.23,92.1) 123.23,92.16 123.87,92.8 123.87,93.47 124.58,94.18 124.58,96.3
  IN3 w0.117: v1(63.09,108.89) 63.96,109.75 64.93,109.75 66,110.82 73.06,110.82 74.37,112.13 74.94,112.13 74.94,112.13 75.16,112.13 75.16,112.13 75.64,112.13 77.39,110.37 82.73,110.37 86.34,106.75 116.42,106.75 116.46,106.71 117.23,105.94 117.23,105.94 117.55,105.62 120.41,102.76 121.45,102.76 124.87,99.34 124.87,97.34 124.58,97.04 124.58,96.3
  BOTTOM w0.076: UC1.AF69 123.19,89.42 123.19,89.68 123.16,89.79 123.15,89.79 123.12,89.87 123.12,90.08 123.16,90.16 123.16,90.41 123.16,90.43 123.12,90.52 123.12,90.78 123.53,91.18 123.53,91.79 v1(123.23,92.1)
  BOTTOM w0.112: v1(63.09,108.89) 63.98,109.77 65.03,109.77 65.31,109.49 JDIMM2.3
DDR_B_D14: length 83.2
  IN3 w0.076: v1(122.17,97.54) 121.64,98.06 121.64,98.34 120.59,99.39 120.59,99.42 120.4,99.6
  IN3 w0.117: 120.4,99.6 120.22,99.79 119.18,99.79 116.8,102.17 115.19,103.78 111.54,103.78 110.03,102.27 94.84,102.27 94.46,102.65 90.58,102.65 90.47,102.76 90.47,102.91 90.32,103.06 90.15,103.06 90,102.91 90,102.76 89.88,102.65 87.28,102.65 87.17,102.76 87.17,103.35 87.03,103.48 86.82,103.48 86.7,103.36 86.7,102.76 86.58,102.65 86.35,102.65 86.23,102.76 86.23,103.67 86.12,103.78 85.88,103.78 85.76,103.67 85.76,102.76 85.65,102.65 85.37,102.65 81.76,106.25 80.08,106.25 79.44,105.61 70.22,105.61 69.79,106.04 65.78,106.04 65.23,105.49 61.41,105.49 61.29,105.61 61.29,105.99 v1(61.51,106.21)
  BOTTOM w0.076: UC1.AH70 122.07,90.12 121.92,90.26 121.92,90.27 121.92,90.27 121.8,90.52 121.8,92.08 121.18,92.71 121.18,94.43 121.3,94.56 v2(121.3,95.97) 121.3,96.67 v1(122.17,97.54)
  BOTTOM w0.112: JDIMM2.16 58.25,106.24 59.31,106.24 59.79,106.72 61,106.72 v1(61.51,106.21)
DDR_B_D15: length 83.9
  IN3 w0.076: 122.17,98.31 v1(122.17,98.17)
  IN3 w0.109: v1(63.03,106.21) 63.42,105.83 65.09,105.83
  IN3 w0.117: 122.17,98.31 120.36,100.12 119.32,100.12 117.73,101.71 116.94,102.5 115.32,104.12 111.41,104.12 109.89,102.6 94.98,102.6 93.46,104.12 91.47,104.12 91.36,104 91.36,103.73 91.24,103.61 91.01,103.61 90.89,103.73 90.89,104 90.77,104.12 90.53,104.12 90.41,104 90.41,103.73 90.29,103.61 90.06,103.61 89.94,103.73 89.94,104 89.83,104.12 89.41,104.12 89.29,104 89.29,103.11 89.17,102.99 88.94,102.99 88.82,103.11 88.82,104 88.7,104.12 88.47,104.12 88.35,104 88.35,103.11 88.24,102.99 88,102.99 87.89,103.11 87.89,104 87.77,104.12 84.88,104.12 82.41,106.59 79.94,106.59 79.81,106.46 71.26,106.46 70.8,106.91 69.32,106.91 68.78,106.37 65.64,106.37 65.09,105.83
  BOTTOM w0.076: UC1.AH69 122.07,89.52 121.67,89.92 121.67,90.4 121.63,90.48 121.63,92 120.99,92.64 120.99,96.99 v2(121.65,97.65) v1(122.17,98.17)
  BOTTOM w0.112: JDIMM2.17 66.45,105.99 65.39,105.99 64.66,106.72 63.54,106.72 v1(63.03,106.21)
DDR_B_D16: length 65
  IN3 w0.076: v1(117.34,87.86) 117.34,88.36 113.11,92.59
  IN3 w0.109: 110.45,92.59 113.11,92.59
  IN3 w0.117: v1(63.09,98.24) 63.58,98.72 66.42,98.72 66.55,98.59 72.17,98.59 72.47,98.89 81.59,98.89 82.99,97.49 92.32,97.49 94.01,95.8 98.52,95.8 98.64,95.68 98.64,95.16 98.75,95.04 98.99,95.04 99.1,95.16 99.1,95.68 99.22,95.8 105.04,95.8 108.25,92.59 110.45,92.59
  BOTTOM w0.076: v1(117.34,87.86) 117.68,87.51 UC1.AT66
  BOTTOM w0.112: JDIMM2.45 63.85,98.99 v1(63.09,98.24)
DDR_B_D17: length 64.1
  IN3 w0.076: 116.26,89.18 116.36,89.08 116.38,89.08 116.7,88.76 v1(116.7,87.88)
  IN3 w0.109: 109.31,91.04 111.13,91.04 111.35,90.83 113.25,90.83 114.3,89.78 115.66,89.78 116.26,89.18
  IN3 w0.117: 109.31,91.04 109.06,91.04 105.4,94.71 97.89,94.71 97.78,94.83 97.78,95.35 97.66,95.47 97.43,95.47 97.31,95.35 97.31,94.83 97.19,94.71 96.96,94.71 96.84,94.83 96.84,95.35 96.72,95.47 96.49,95.47 96.37,95.35 96.37,94.83 96.26,94.71 96.02,94.71 95.91,94.83 95.91,95.35 95.79,95.47 95.56,95.47 95.44,95.35 95.44,94.83 95.32,94.71 94.63,94.71 92.18,97.16 82.86,97.16 81.45,98.56 72.61,98.56 72.14,98.09 69.36,98.09 68.81,97.54 65.83,97.54 65.06,98.32 64.7,98.32 v1(64.62,98.24)
  BOTTOM w0.076: UC1.AU66 117.03,87.55 v1(116.7,87.88)
  BOTTOM w0.112: JDIMM2.49 66.45,97.99 65.28,97.99 65.03,98.24 v1(64.62,98.24)
DDR_B_D18: length 67.5
  IN3 w0.076: v1(118.73,86.97) 118.73,86.71 118.41,86.39 117.39,86.39 117.26,86.26 115.32,86.26 113.55,88.02 111.04,88.02 110.62,88.45 107.77,88.45 106.16,90.05
  IN3 w0.117: 106.16,90.05 105.15,91.07 95.02,91.07 91.23,94.85 80.41,94.85 80.1,94.54 71.92,94.54 71.56,94.18 61.23,94.18 61.11,94.3 61.11,95.02 v1(61.57,95.48)
  BOTTOM w0.076: v1(118.73,86.97) 118.98,86.71 UC1.AP65
  BOTTOM w0.112: JDIMM2.62 60.83,94.74 v1(61.57,95.48)
DDR_B_D19: length 68.4
  IN3 w0.076: v1(119.29,86.99) 118.86,87.41 118.54,87.41 118.35,87.22 118.35,86.69 118.25,86.58 117.33,86.58 117.17,86.42 115.55,86.42 113.78,88.19 111.11,88.19 110.69,88.61 108.03,88.61 106.16,90.48
  IN3 w0.117: v1(63.09,95.48) 64.06,94.51 71.42,94.51 71.78,94.88 79.96,94.88 80.27,95.19 91.37,95.19 95.15,91.4 95.47,91.4 95.59,91.52 95.59,91.92 95.71,92.04 95.94,92.04 96.06,91.92 96.06,91.52 96.18,91.4 96.41,91.4 96.53,91.52 96.53,91.92 96.64,92.04 96.88,92.04 96.99,91.92 96.99,91.52 97.11,91.4 97.4,91.4 97.52,91.52 97.52,91.71 97.64,91.83 97.87,91.83 97.99,91.71 97.99,91.52 98.1,91.4 105.24,91.4 106.16,90.48
  BOTTOM w0.076: v1(119.29,86.99) 119.29,86.9 119.63,86.55 UC1.AN65
  BOTTOM w0.112: JDIMM2.59 65.26,95.49 64.82,95.93 63.54,95.93 v1(63.09,95.48)
DDR_B_D20: length 67.3
  IN3 w0.076: 114.24,92.22 118,88.46 118.26,88.46 118.45,88.27 118.69,88.27 119.11,87.86 v1(119.23,87.86)
  IN3 w0.109: 111.25,93.39 113.07,93.39 114.24,92.22
  IN3 w0.117: 111.25,93.39 108.5,93.39 105.13,96.77 93.99,96.77 92.6,98.16 83.27,98.16 81.87,99.56 72.2,99.56 71.94,99.3 66.98,99.3 66.85,99.43 61.4,99.43 60.2,98.24 v1(60.05,98.24)
  BOTTOM w0.076: UC1.AN66 119.63,87.46 v1(119.23,87.86)
  BOTTOM w0.112: v1(60.05,98.24) 59.55,97.74 JDIMM2.50
DDR_B_D21: length 66.4
  IN3 w0.076: v1(118.61,87.86) 118.19,88.27 117.87,88.27 114.68,91.46
  IN3 w0.109: 114.68,91.46 114.68,91.5 113.16,93.02 110.88,93.02
  IN3 w0.117: 110.88,93.02 108.36,93.02 104.95,96.43 93.85,96.43 92.46,97.82 83.13,97.82 81.73,99.23 72.34,99.23 72.08,98.97 66.68,98.97 66.55,99.1 62.44,99.1 v1(61.57,98.24)
  BOTTOM w0.076: v1(118.61,87.86) UC1.AP66
  BOTTOM w0.112: v1(61.57,98.24) 61.07,98.74 JDIMM2.46
DDR_B_D22: length 66.1
  IN3 w0.076: v1(117.34,86.94) 116.98,86.59 115.66,86.59 113.9,88.35 111.18,88.35 110.76,88.78 108.24,88.78 106.16,90.86
  IN3 w0.117: 106.16,90.86 104.65,92.37 104.17,92.37 104.05,92.25 104.05,91.85 103.94,91.73 103.7,91.73 103.59,91.85 103.59,92.25 103.47,92.37 103.24,92.37 103.12,92.25 103.12,91.85 103,91.73 102.77,91.73 102.65,91.85 102.65,92.25 102.53,92.37 102.3,92.37 102.18,92.25 102.18,91.85 102.07,91.73 101.83,91.73 101.72,91.85 101.72,92.25 101.6,92.37 101.37,92.37 101.25,92.25 101.25,91.85 101.13,91.73 100.9,91.73 100.78,91.85 100.78,92.25 100.67,92.37 100.43,92.37 100.31,92.25 100.31,91.85 100.2,91.73 99.96,91.73 99.85,91.85 99.85,92.25 99.73,92.37 99.5,92.37 99.38,92.25 99.38,91.85 99.26,91.73 99.03,91.73 98.91,91.85 98.91,92.25 98.8,92.37 94.65,92.37 91.51,95.52 78.51,95.52 78.14,95.89 70.65,95.89 70.63,95.87 66.14,95.87 65.65,95.39 64.71,95.39 v1(64.62,95.48)
  BOTTOM w0.076: UC1.AT65 117.68,86.59 v1(117.34,86.94)
  BOTTOM w0.112: v1(64.62,95.48) 64.62,95.06 65.19,94.49 JDIMM2.63
DDR_B_D23: length 65.2
  IN3 w0.076: v1(116.73,86.94) 115.7,86.94 114.13,88.52 111.25,88.52 110.83,88.94 108.59,88.94 106.5,91.03
  IN3 w0.117: 106.5,91.03 104.83,92.7 97.5,92.7 97.39,92.82 97.39,92.96 97.24,93.11 97.07,93.11 96.92,92.96 96.92,92.82 96.8,92.7 96.56,92.7 96.44,92.82 96.44,93.29 96.32,93.4 96.09,93.4 95.97,93.29 95.97,92.82 95.86,92.7 95.62,92.7 95.51,92.82 95.51,93.29 95.39,93.4 94.09,93.4 91.64,95.85 78.65,95.85 78.27,96.24 66.85,96.24 60.69,96.13 v1(60.05,95.48)
  BOTTOM w0.076: UC1.AU65 117.03,86.64 v1(116.73,86.94)
  BOTTOM w0.112: v1(60.05,95.48) 59.63,95.48 59.37,95.74 JDIMM2.58
DDR_B_D24: length 65.1
  IN3 w0.076: 104.51,89.33 104.77,89.33 106.71,87.39 113.11,87.39 114.92,85.58 116.87,85.58 v1(117.34,85.11)
  IN3 w0.117: v1(64.62,92.57) 71.68,92.57 72.47,93.36 81.61,93.36 82.64,92.32 83.31,92.32 83.42,92.44 83.42,93.24 83.54,93.36 83.77,93.36 83.89,93.24 83.89,92.44 84.01,92.32 84.24,92.32 84.36,92.44 84.36,93.24 84.48,93.36 84.71,93.36 84.83,93.24 84.83,92.44 84.94,92.32 85.19,92.32 85.31,92.44 85.31,93.24 85.43,93.36 85.66,93.36 85.78,93.24 85.78,92.44 85.89,92.32 86.14,92.32 86.25,92.44 86.25,92.72 86.37,92.84 86.6,92.84 86.72,92.72 86.72,92.44 86.84,92.32 90.88,92.32 93.87,89.33 104.51,89.33
  BOTTOM w0.076: UC1.AT61 117.68,84.77 v1(117.34,85.11)
  BOTTOM w0.112: JDIMM2.71 65.39,92.49 65.31,92.57 v1(64.62,92.57)
DDR_B_D25: length 64.8
  IN3 w0.076: v1(116.7,85.09) 116.41,85.38 114.79,85.38 112.95,87.22 105.99,87.22 104.59,88.62 104.51,88.62
  IN3 w0.117: v1(61.57,92.57) 61.57,92.12 62.02,91.67 67.6,91.67 68.09,92.16 70.03,92.16 70.04,92.17 71.75,92.17 72.6,93.02 78.08,93.02 78.19,92.91 78.19,92.6 78.31,92.48 78.55,92.48 78.66,92.6 78.66,92.91 78.78,93.02 81.47,93.02 82.5,91.99 90.74,91.99 94.11,88.62 104.51,88.62
  BOTTOM w0.076: v1(116.7,85.09) 116.7,84.99 UC1.AU61
  BOTTOM w0.112: JDIMM2.66 60.4,93.74 v1(61.57,92.57)
DDR_B_D26: length 67.8
  IN3 w0.076: 103.37,86.64 103.78,86.64 104.69,85.73 104.98,85.73 105.34,85.38 112.58,85.38 113.24,84.72 113.7,84.72 114.77,83.64 117.56,83.64 117.75,83.83 118.23,83.83 v1(118.61,84.2)
  IN3 w0.117: 103.37,86.64 93.29,86.64 91.77,88.16 89.93,88.16 88.59,89.51 81.25,89.51 80.75,90.02 72.44,90.02 72.08,89.66 66.51,89.66 64.97,88.12 61.52,88.12 61.4,88.24 61.4,88.72 61.52,88.83 62.66,88.83 v1(63.09,89.27)
  BOTTOM w0.076: UC1.AP60 118.98,83.82 v1(118.61,84.2)
  BOTTOM w0.112: v1(63.09,89.27) 64.31,90.49 JDIMM2.79
DDR_B_D27: length 67.9
  IN3 w0.076: 103.37,86.31 103.64,86.31 105.71,84.24 113.78,84.24 114.55,83.48 117.65,83.48 117.83,83.65 118.69,83.65 v1(119.24,84.2)
  IN3 w0.117: v1(60.05,89.27) 59.56,89.27 59.36,89.06 59.36,87.99 59.56,87.79 65.27,87.79 66.81,89.33 72.22,89.33 72.57,89.68 80.61,89.68 81.12,89.18 88.45,89.18 89.79,87.83 91.64,87.83 93.16,86.31 103.37,86.31
  BOTTOM w0.076: UC1.AN60 119.63,83.81 v1(119.24,84.2)
  BOTTOM w0.112: v1(60.05,89.27) 60.01,89.24 JDIMM2.84
DDR_B_D28: length 66.7
  IN3 w0.076: v1(119.24,85.11) 118.69,85.66 117.76,85.66 117.43,85.99 115.27,85.99 113.54,87.72 107.2,87.72 107.12,87.8 106.99,87.93 106.99,88.63 105.08,90.54 104.51,90.54
  IN3 w0.117: 104.51,90.54 94.8,90.54 91.32,94.02 72.14,94.02 71.37,93.25 66.18,93.25 65.79,93.64 61.12,93.64 v1(60.05,92.57)
  BOTTOM w0.076: UC1.AN61 119.63,84.72 v1(119.24,85.11)
  BOTTOM w0.102: 59.01,92.74 59.31,92.74 59.48,92.57 v1(60.05,92.57)
  BOTTOM w0.112: JDIMM2.70 59.01,92.74
DDR_B_D29: length 66.8
  IN3 w0.076: 104.51,90.01 104.67,90.01 107.13,87.55 113.39,87.55 115.15,85.8 117.37,85.8 117.69,85.48 118.24,85.48 v1(118.61,85.11)
  IN3 w0.117: v1(63.09,92.57) 63.53,93.01 65.95,93.01 66.04,92.92 71.56,92.92 72.33,93.69 87.65,93.69 87.76,93.57 87.76,92.77 87.88,92.65 88.11,92.65 88.23,92.77 88.23,93.57 88.35,93.69 88.58,93.69 88.7,93.57 88.7,93.03 88.81,92.91 89.2,92.91 89.31,93.03 89.31,93.29 89.43,93.4 89.67,93.4 89.78,93.29 89.78,93.03 89.9,92.91 91.28,92.91 94.18,90.01 104.51,90.01
  BOTTOM w0.076: UC1.AP61 118.98,84.74 v1(118.61,85.11)
  BOTTOM w0.112: JDIMM2.67 64.01,93.49 v1(63.09,92.57)
DDR_B_D30: length 67
  IN3 w0.076: v1(117.35,84.11) 117.04,83.81 115,83.81 113.89,84.91 113.3,84.91 112.64,85.57 105.37,85.57 104.04,86.9 103.99,86.9
  IN3 w0.117: v1(64.62,89.27) 64.48,89.14 64.27,89.14 64.08,88.95 64.08,88.57 64.2,88.45 64.83,88.45 66.37,90 71.94,90 72.3,90.35 80.88,90.35 81.39,89.84 81.64,89.84 81.75,89.96 81.75,90.23 81.87,90.35 82.1,90.35 82.22,90.23 82.22,89.96 82.34,89.84 82.57,89.84 82.69,89.96 82.69,90.23 82.8,90.35 83.04,90.35 83.15,90.23 83.15,89.96 83.27,89.84 83.5,89.84 83.62,89.96 83.62,90.23 83.74,90.35 83.97,90.35 84.09,90.23 84.09,89.96 84.21,89.84 84.44,89.84 84.56,89.96 84.56,90.23 84.67,90.35 84.91,90.35 85.02,90.23 85.02,89.96 85.14,89.84 85.37,89.84 85.49,89.96 85.49,90.23 85.61,90.35 85.84,90.35 85.96,90.23 85.96,89.96 86.08,89.84 86.31,89.84 86.43,89.96 86.43,90.23 86.54,90.35 86.78,90.35 86.89,90.23 86.89,89.96 87.01,89.84 87.3,89.84 87.41,89.96 87.41,90.23 87.53,90.35 87.76,90.35 87.88,90.23 87.88,89.96 88,89.84 88.72,89.84 88.81,89.76 88.97,89.76 89.4,90.18 89.56,90.18 89.73,90.02 89.73,89.85 89.3,89.43 89.3,89.26 90.07,88.5 91.91,88.5 93.43,86.98 103.92,86.98 103.99,86.9
  BOTTOM w0.076: v1(117.35,84.11) 117.68,83.78 UC1.AT60
  BOTTOM w0.112: v1(64.62,89.27) 65.03,89.27 65.25,89.49 JDIMM2.83
