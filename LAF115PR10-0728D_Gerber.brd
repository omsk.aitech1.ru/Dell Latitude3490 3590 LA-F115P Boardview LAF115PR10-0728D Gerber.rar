# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3D3_STB: length 9.4
  TOP w0.203: UA1.20 26.14,16.98 25.27,17.85 25.13,17.85 25.13,17.85 v1(25.15,17.85)
  TOP w0.254: RA12.1 RA11.1 v1(28.6,22.06)
  IN3 w0.254: v1(25.15,17.85) 25.15,19.02 28.19,22.06 v1(28.6,22.06)
VBAT_CHG: length 4.4
  TOP w0.254: v1(207.44,43.8) 207.15,43.51 v2(207.15,43.06) 207.15,42.98 207.31,42.82 PCB45.1
  BOTTOM w0.203: PUB01.31 207.01,44.89 207.44,44.46 v1(207.44,43.8) 207.7,43.54 PRB39.2
VBUS_C_CTRL_P1: length 50.8
  TOP w0.254: PRS35.2 66.56,126.06 v1(66.56,125.03) ; PUS02.1 v1(60.55,125.79)
  IN2 w0.254: v1(66.56,125.03) 66.56,125.2 66.2,125.56 65.52,125.56 64.96,125 61.34,125 v1(60.55,125.79)
  IN3 w0.102: v1(60.55,125.79) 61.01,126.25 61.01,128.75 58.82,130.93 57.03,130.93 54.53,133.43 50.44,133.43 49.26,132.26 49.26,128.16 46.83,125.74 45.13,125.74 41.4,122 39.9,122 38.85,120.95 38.85,120.05 v1(38.02,119.22)
  BOTTOM w0.089: RT113.1 37.94,119.14 v1(38.02,119.22) ; v2(40.5,120.32) 40.43,120.39 39.26,120.39 38.81,120.84 38.38,120.84 38.14,120.6 UT1.12
  BOTTOM w0.102: UT1.12 38.14,119.34 v1(38.02,119.22)
VBUS_DISCHARGE: length 21.8
  TOP w0.089: RT32.1 22.87,127.8 21.57,127.8 v2(21.24,128.13)
  TOP w0.102: 23.59,128.97 23.59,128.51 RT32.1 ; 23.59,128.97 23.59,129.38 QT3.2 ; 23.59,128.97 v1(23.58,128.97)
  IN1 w0.102: v1(33.31,119.61) 33.22,119.7 33.22,124.21 30.09,127.34 27.97,127.34 27.09,128.22 24.32,128.22 v1(23.58,128.97)
  BOTTOM w0.102: UT1.20 34.14,119.92 33.83,119.61 v1(33.31,119.61)
VBUS_MON_P1: length 9.4
  BOTTOM w0.089: RT1.2 40.74,118.64 40.74,117.24 40.14,116.64 v2(37.73,116.64) 37.28,116.64 37.07,116.86 RT2.1 CT1.1
  BOTTOM w0.102: CT1.1 37.64,119.06 UT1.13
VBUS_P_CTRL_P1: length 45.3
  TOP w0.089: v1(34.12,129.83) 33.97,129.83 QT5.1
  TOP w0.254: PUS03.1 51.4,126.54 51.15,126.79 50.39,126.79 PRS38.1 49.51,127.74 49.51,129.8 v2(49.55,129.84) 49.55,130.06 49.83,130.34 v1(50.25,130.34)
  IN3 w0.089: v1(38.7,119.22) 41.23,119.22 41.98,118.46 44.33,118.46 45.27,119.4 45.27,122.13 47.9,124.76 47.9,126.16 49.59,127.85 49.59,129.68 v1(50.25,130.34)
  IN3 w0.102: v1(34.12,129.83) 34.12,128.25 34.41,127.96 34.41,126.55 35.02,125.94 35.02,120.61 34.49,120.07 34.49,119.18 34.83,118.84 38.32,118.84 v1(38.7,119.22)
  BOTTOM w0.089: v1(38.7,119.22) 38.77,119.15 RT112.1
  BOTTOM w0.102: v1(38.7,119.22) 38.64,119.28 UT1.11
VCC_CPU: length 3.7
  BOTTOM w0.203: PUZ01.13 172.15,53.7 171.29,52.84 v2(171.27,52.84) 170.42,52.84 PCZ34.1
  BOTTOM w0.254: PCZ34.1 170.22,51.97 PRZ57.2
VCC_GT_SENSE: length 79.1
  TOP w0.254: RC155.2 131.32,92.17 v1(131.32,91.86) ; PRZ59.1 172.19,65.31 172.68,65.31 v2(172.97,65.6) 173.25,65.89 173.25,66.26 v1(173.2,66.31)
  IN1 w0.254: v1(147.92,96.41) 148.03,96.3 148.03,90.71 149.46,89.28 149.46,87.21 148.15,85.89 148.15,83.35 152.82,78.68 157.57,78.68 159.57,76.69 165.67,76.69 171.34,71.01 171.34,69.93 171.69,69.58 171.69,68.46 173.3,66.86 173.3,66.4 v1(173.2,66.31)
  BOTTOM w0.076: 131.64,91.12 131.41,90.89 131.41,90.23 131.66,89.98
  BOTTOM w0.089: UC1.J70 131.66,89.98
  BOTTOM w0.254: v1(147.92,96.41) 145.97,98.37 142.05,98.37 139.57,95.88 135.3,95.88 134.7,96.48 132.67,96.48 131.44,95.25 131.44,93.11 131.09,92.76 131.09,92.1 v1(131.32,91.86) 131.64,91.54 131.64,91.12
VCC_VCORE1: length 4.6
  TOP w0.089: v2(160.16,70.02) PRI02.2
  TOP w0.508: v1(163.33,70.9) 163.04,70.9 162.53,70.39 PCI10.1 162.36,70.02 PRI02.2
  BOTTOM w0.254: PUI01.3 163.02,70.59 v1(163.33,70.9)
VCC_VCORE2: length 4.2
  TOP w0.089: v2(167.89,87.1) 167.89,86.62 v1(167.6,86.33)
  BOTTOM w0.254: PUI02.3 167.23,86.52 167.42,86.33 v1(167.6,86.33) 167.76,86.5 167.76,86.83 168.21,87.27 PCI30.1 168.23,87.31 PRI22.2
VCC_VGT1: length 3.5
  TOP w0.089: v2(159.9,95.93) 159.84,95.99 158.88,95.99 v1(158.85,96.02)
  TOP w0.254: v1(158.85,96.02) 158.7,95.87 PRG02.2
  BOTTOM w0.254: PCG10.1 158.99,96.15 v1(158.85,96.02) 158.84,96 PUG01.3
VCCDSW_ON: length 185.5
  TOP w0.089: v1(71.9,26.37) 72.29,26.76 72.29,32.92 72.93,33.56 72.93,34.13 73.79,34.99 73.79,36.76 74.18,37.14 v3(74.18,39.34) 74.18,39.61 v1(73.49,40.29) ; DC2.2 78.82,112.2 v1(78.08,112.95) 78.08,113.08 RC442.1 ; Q4.2 58.96,33.2 58.96,31.76 R66.2 58.16,30.96 58.16,28.37 v1(57.69,27.9)
  TOP w0.102: RE91.1 38.57,86.33 v1(38.52,86.38)
  IN2 w0.089: v1(52.66,80.15) 52.3,79.78 52.3,72.95 53.84,71.4 53.84,70.65 54.84,69.66 54.84,61.08 53.45,59.69 53.45,57.8 53.89,57.37 53.89,52.34 55.24,50.99 55.24,49.21 55.13,49.1 55.13,46.09 56.22,45 57.66,45 62.5,40.16 73.36,40.16 v1(73.49,40.29)
  IN3 w0.089: v1(57.69,27.9) 57.78,27.99 64.54,27.99 65.77,26.75 71.52,26.75 v1(71.9,26.37) ; v1(78.08,112.95) 77.54,113.48 72.14,113.48 71.36,112.7 66.71,112.7 66.31,112.31 61.9,112.31 59.95,114.25 58.1,114.25 56.17,112.31 56.17,111.37 51.43,106.64 51.43,102.38 51.95,101.86 51.95,101.11 v1(51.56,100.72)
  IN3 w0.102: v1(45.22,99.53) 44.57,98.88 44.57,97.84 44.04,97.3 42.02,97.3 41.65,96.93 41.65,95.69 42.43,94.91 42.43,93.14 41.88,92.58 41.88,89.53 40.4,88.05 40.4,87.52 39.25,86.38 v1(38.52,86.38)
  BOTTOM w0.089: 45.6,99.14 v1(45.22,99.53) 45.04,99.7 45.04,100.66 45.35,100.96 51.32,100.96 v1(51.56,100.72)
  BOTTOM w0.102: v1(52.66,80.15) 51.65,80.15 50.89,80.9 50.89,81.66 49.52,83.04 49.52,96.87 47.24,99.14 45.6,99.14
VCCGT_B+:
  vias: v1(162.83,94.91) v1(162.83,94.28) v1(163.41,94.91) v1(163.41,94.28) v1(164.02,94.91) v1(164.02,94.28) v2(165.21,94.75)
VCCIO_SENSE: length 2.9
  TOP w0.254: v1(122.15,62.6) 122.6,62.6 TP38.1
  BOTTOM w0.076: v1(122.15,62.6) 121.75,63 121.38,63 120.75,63.63 UC1.AM23
VCCSA_B+:
  vias: v1(160.66,62.11) v1(161.25,62.11) v1(161.83,62.11) v1(162.42,62.11) v3(159.62,61.12)
VCCSENSE: length 76.4
  TOP w0.152: v1(181.92,50.4) 182.92,50.4 v2(183.19,50.12)
  IN1 w0.203: v1(181.92,50.4) 182.26,50.73 182.26,53.28 180.57,54.97 180.57,57.74 179.55,58.76 177.72,58.76 176.61,59.86 173.11,59.86 171.19,61.79 171.19,65.98 169.23,67.94 169.23,70.14 165.1,74.27 159,74.27 156.7,76.57 148.49,76.57 147.26,75.34 147.26,73.62 146.71,73.08 146.31,73.08 145.87,72.64 v1(145.87,72.64)
  BOTTOM w0.076: UC1.E32 134.02,68 134.16,68 134.24,67.92 134.24,67.52 134.41,67.35 134.93,67.35 134.93,67.35 136.08,67.35 136.08,67.35 137.08,67.35 137.08,67.35 137.16,67.35
  BOTTOM w0.152: 143.92,71.59 143.77,71.43 143.77,70.5 143.49,70.23 143.49,69.73 142.55,68.79 142.55,68.69 141.88,68.02 RC150.2 141.63,68.02 140.63,69.01 138.82,69.01 137.16,67.35
  BOTTOM w0.254: v1(145.87,72.64) 144.97,72.64 143.92,71.59 ; PRZ14.1 182.15,50.62 v1(181.92,50.4)
VCCSENSE_VGA: length 81.1
  TOP w0.254: PRV34.1 76.71,123.57 76.96,123.82 76.96,123.95 77,123.98 v1(77,123.98) ; RV159.2 116.45,139.81 115.98,139.81 115.29,140.49 115.29,140.88 115.4,140.99 115.4,142.06 115.03,142.43 115.03,145.25 114.35,145.92 111.32,145.92 109.39,147.85 107.05,147.85 105.25,146.05 105.25,145.28 103.51,143.54 103.51,134.66 105.7,132.47 105.7,128.52 103.35,126.17 103.35,120.54 100.96,118.15 95.47,118.15 94.74,118.89 92.73,118.89 92.27,118.43 v1(92.27,118.19)
  IN2 w0.254: v1(77,123.98) 77,122.58 77.88,121.7 82.01,121.7 83.42,120.3 90.27,120.3 90.66,120.68 91.1,120.68 92.27,119.51 v1(92.27,118.19)
  BOTTOM w0.089: v1(92.27,118.19) v2(91.85,118.62)
VCCST_PWRGD: length 7.9
  BOTTOM w0.076: 139.18,87.13 139.17,87.12 v2(138.64,87.12) 138.57,87.05 138.57,86.82 138.46,86.71 138.26,86.71 138.18,86.79 138.18,87.35 138.26,87.42 138.42,87.42 138.5,87.5 138.5,87.73 138.39,87.84 137.95,87.84 137.88,87.76 137.88,86.79 137.8,86.71 137.3,86.71 137.23,86.79 137.23,86.87 137.15,86.95 137,86.95 136.92,86.87 136.92,86.79 136.84,86.71 136.8,86.71 136.65,86.56 135.7,86.56 135.62,86.64 135.62,86.78 135.7,86.86 UC1.B65
  BOTTOM w0.112: 139.18,87.13 139.71,87.13 RC96.2
VCCSTG_EN: length 91.1
  TOP w0.089: RZ2.2 147.59,91.16 148.29,90.46 v2(148.29,90.23) 148.29,89.53 v1(148.05,89.29) 147.55,88.79 146.61,88.79 UC9.4
  TOP w0.254: RZ3.1 159.33,29.69 DZ2.1 158.54,29.67 158.54,28.48 v1(158.47,28.41)
  IN1 w0.102: v1(142.96,68.62) 142.96,67.94 143.42,67.48 143.42,62.08 143.69,61.8 143.69,55.75 144.23,55.22 144.23,52.56 144.71,52.07 144.87,51.91 144.87,50.68 145.26,50.29 145.26,49.57 146.97,47.86 148.23,47.86 149.12,46.97 v1(149.12,43.28)
  BOTTOM w0.089: v1(148.05,89.29) 148.05,89.24 148.38,88.91 148.38,83.01 148.74,82.65 148.74,80.45 148.78,80.41 148.78,78.29 147.72,77.24 147.72,71.88 146.73,70.88 144.47,70.88 143.72,70.14 143.72,69.38 v1(142.96,68.62)
  BOTTOM w0.102: v1(149.12,43.28) 149.12,42.94 146.29,40.11 146.29,39.15 145.8,38.67 145.8,37.83 146.54,37.09 146.54,36.48 145.72,35.66 144.47,35.66 143.97,35.16 143.97,33.33 148.62,28.69 155.78,28.69 156.74,27.73 157.79,27.73 v1(158.47,28.41)
VCCSTG_EN_R: length 6.3
  TOP w0.089: CZ7.1 157.42,29.97 157.87,29.52 v2(157.87,28.15)
  TOP w0.254: CZ7.1 157.61,30.28 157.61,30.74 157.25,31.11 UZ2.4 157.46,31.54 157.99,31.54 158.43,31.09 DZ2.2 159.33,31.09 RZ3.2
VDD10: length 16.5
  TOP w0.203: UL1.8 25.6,78.9 v1(25.54,78.84) ; UL1.22 23.6,86.04 23.73,86.18 23.73,86.22 CL19.1 ; UL1.30 21.49,81.66 21.28,81.45 v1(20.9,81.45) ; UL1.3 v1(23.6,78.85)
  TOP w0.305: CL19.1 CL22.1 22.22,86.28 22.11,86.39
  IN3 w1.016: 21.73,81.81 21.73,86.37 21.52,86.58
  BOTTOM w0.127: v1(20.89,80.86) 20.89,80.23 v2(20.34,79.69)
  BOTTOM w0.508: CL23.1 v1(25.54,78.84) CL18.1 24.37,78.84 24.35,78.85 v1(23.6,78.85)
  vias: v1(21.28,87.71) v1(21.88,87.71)
VDD_1.2V: length 8.5
  TOP w0.508: v1(36.94,23.02) 37.19,22.77 v2(37.63,22.77) 37.75,22.89 PRM03.2 ; v1(32.21,24.51) 32.21,24.92 32.59,25.3 PCM14.1
  IN1 w0.508: v1(32.21,24.51) 33.36,24.51 34.84,23.02 v1(36.94,23.02)
VDD_CHG: length 22.4
  TOP w0.254: v1(201.25,43.3) 201.25,43.53 v2(201.48,43.76) 201.48,44.15 201.71,44.38 PRB09.2
  IN1 w0.254: v1(206.41,52.42) 206.41,52.21 204.71,50.5 203.31,50.5 200.08,47.28 200.08,44.47 v1(201.25,43.3)
  BOTTOM w0.203: PUB01.18 203.57,49.26 203.28,49.54 203.28,50.28 PRB13.2
  BOTTOM w0.254: PRB13.2 203.82,50.83 PCB28.1 203.85,51.62 204.87,52.65 206.19,52.65 v1(206.41,52.42) 207.01,52.42 PRB11.1
VDDIO_VGA: length 4
  TOP w0.203: PRV12.2 PRV14.2 68.83,130.16 69.55,130.16 PCV10.1 69.58,130.16 70.44,130.16 v2(70.52,130.08) 71.1,129.5 PUV01.6
VDDP_CHG: length 3.1
  TOP w0.089: v1(202.66,43.77) 203.32,43.77 v2(203.64,44.09)
  TOP w0.254: v1(202.66,43.77) 202.66,44.66 PRB09.1 202.32,45 PCB29.1
VDDR4: length 2.1
  BOTTOM w0.381: UV1.U12 UV1.V12 122.21,129.87 121.47,129.87 UV1.Y12
VDDREG: length 1.2
  BOTTOM w0.127: 23.63,84.7 24.57,84.7 v2(24.74,84.54)
  vias: v1(22.98,85.67) v1(22.97,85.09)
VSS_GT_SENSE: length 80.3
  TOP w0.254: v1(173.79,66.36) 173.7,66.27 173.7,65.74 172.92,64.96 172.39,64.96 v2(171.81,64.37) 171.04,63.6 171.04,63.29 PRZ53.2
  IN1 w0.254: v1(173.79,66.36) 173.66,66.49 173.66,66.61 173.65,66.62 173.65,66.99 172.05,68.6 172.05,69.72 171.69,70.08 171.69,71.17 165.72,77.13 159.75,77.13 157.85,79.03 152.96,79.03 148.5,83.49 148.5,85.76 149.82,87.07 149.82,89.41 148.38,90.85 148.38,96.83 148.13,97.09 v1(148.03,97.09)
  BOTTOM w0.076: 131.12,91.31 131.23,91.2 131.23,89.97 131.66,89.53 UC1.J69
  BOTTOM w0.254: 131.12,91.31 130.56,91.87 RC156.1 130.58,92.81 131.07,93.3 131.07,95.46 132.51,96.9 134.86,96.9 135.52,96.23 139.36,96.23 141.85,98.72 146.11,98.72 147.74,97.09 v1(148.03,97.09)
VSS_MECH: length 62.9
  TOP w0.254: v1(111.97,144.38) 111.51,144.38 v3(111.09,143.97) 109.13,142.01 104.64,142.01 104.2,141.57 104.2,134.95 106.4,132.76 106.4,126.3 107.44,125.26 107.44,124.17 107.48,124.13 109.96,121.65 111.16,121.65 111.16,121.65 v1(111.16,121.65)
  IN1 w0.254: v1(111.97,144.38) 111.97,144.86 114.01,146.9 117.14,146.9 118.06,145.98 118.91,145.98 119.31,146.39 120.96,146.39 121.75,145.6 126.42,145.6 126.75,145.27 126.75,145.07 v1(127.14,144.69)
  IN2 w0.254: v1(127.14,144.69) 128,145.55 128.48,145.55 128.89,145.96 131.05,145.96 131.57,145.43 132.88,145.43 132.9,145.45 134.17,145.45 v1(134.71,144.91)
  BOTTOM w0.254: UV1.AM32 112.35,144.2 112.16,144.38 v1(111.97,144.38) ; v1(134.71,144.91) 134.71,144.37 UV1.A32 ; v1(111.16,121.65) 111.16,121.65 111.16,121.65 112.11,122.6 UV1.AM1
VSSIO_SENSE: length 1.2
  TOP w0.254: TP39.1 120.9,62.24 v1(120.61,62.24)
  BOTTOM w0.254: UC1.AM22 120.29,62.57 v1(120.61,62.24)
VSSSENSE: length 75
  TOP w0.152: v1(181.92,49.81) 181.99,49.75 181.99,49.28 v2(181.97,49.27)
  IN1 w0.203: v1(146.49,72.64) 146.62,72.77 146.84,72.77 147.58,73.51 147.58,75.23 148.61,76.26 156.57,76.26 158.87,73.96 164.97,73.96 168.92,70.01 168.92,67.81 170.88,65.85 170.88,61.68 173,59.56 176.45,59.56 177.55,58.45 179.42,58.45 180.27,57.61 180.27,54.84 181.77,53.33 181.77,50.95 181.48,50.66 181.48,50.05 181.71,49.81 v1(181.92,49.81)
  BOTTOM w0.076: UC1.E33 134.15,68.78 134.15,68.27 134.36,68.07 137.21,68.07
  BOTTOM w0.152: 137.21,68.07 138.39,69.26 140.75,69.26 141.25,68.75 RC151.1 142.16,68.75 143.24,69.84 143.24,70.34 143.51,70.61 143.51,71.67 144.79,72.95 144.82,72.95 144.96,73.09 145.5,73.09
  BOTTOM w0.254: v1(146.49,72.64) 146.49,72.84 146.24,73.09 145.5,73.09 ; v1(181.92,49.81) 181.91,49.83 181.46,49.83 PRZ18.1
VSSSENSE_VGA: length 79
  TOP w0.254: v1(92.86,118.19) 93.21,118.54 94.59,118.54 95.33,117.81 101.11,117.81 103.7,120.4 103.7,120.69 103.7,126.03 106.05,128.38 106.05,132.61 103.86,134.81 103.86,143.38 105.6,145.12 105.6,145.91 107.19,147.5 109.25,147.5 111.19,145.56 114.21,145.56 114.67,145.1 114.67,142.58 114.49,142.39 114.49,140.84 114.69,140.64 114.69,140.59 115.83,139.45 115.91,139.45 RV158.2 ; v1(77.57,123.82) PRV36.1
  IN2 w0.254: v1(92.86,118.19) 92.86,119.42 91.25,121.03 90.51,121.03 90.12,120.64 83.56,120.64 82.15,122.05 78.02,122.05 77.35,122.73 77.35,123.6 v1(77.57,123.82)
  BOTTOM w0.089: v1(92.86,118.19) v2(93.48,118.19)
+BIF_VDDC: length 1.5
  BOTTOM w0.381: v1(124.54,137.27) 124.69,137.27 125.14,136.82 UV1.R21 ; v1(123.76,137.3) 123.34,136.89 UV1.U21
  vias: v1(122.13,142.19) v1(122.97,142.25) v1(123.68,142.22) v2(122.59,141.87)
+CCG_VBUS: length 67.5
  TOP w0.279: JUSBC1.B4 6.18,120.07 6.36,119.89 6.64,119.89 ; JUSBC1.B9 6.17,122.57 6.21,122.61 6.7,122.61 6.99,122.32 JUSBC1.A4 7.97,122.32 8.11,122.46 v1(8.37,122.46) 8.82,122.46 v1(8.95,122.59) ; JUSBC1.A9 7.35,119.83 7.88,119.83 7.94,119.76 v1(9.09,119.76)
  TOP w0.508: CT44.1 10.57,119.76 v1(9.09,119.76) ; v1(65.75,120.18) 65.72,120.22 PRS26.1 ; CT45.1 11.22,120.92 v1(11.22,121.52)
  IN1 w0.508: v1(65.75,120.18) 65.75,119.73 64.2,118.18 60.64,118.18 60.52,118.07 59.1,118.07 58.5,118.67 55.76,118.67 55.12,119.31 50.24,119.31 49.31,120.24 43.09,120.24 v1(41.97,119.12) ; 76.26,141.71 76.01,141.46 72.45,141.46 70.6,139.61 46.26,139.61
  BOTTOM w0.508: RT1.1 39.54,119.68 v1(39.29,119.93)
  vias: v1(11.83,121.51) v1(12.33,127.69) v1(12.96,127.69) v1(13.6,127.69) v1(14.23,127.69) v1(38.91,129.71) v1(38.91,129.13) v1(38.87,128.49) v1(38.92,127.88) v1(39.47,128.74) v1(39.47,128.13) v1(43.28,139.76) v1(43.28,139.15) v1(43.28,138.54) v1(43.28,137.93) v1(43.89,139.76) v1(43.89,139.15) v1(43.89,138.54) v1(43.89,137.93) v1(76.42,142.96) v1(76.42,142.38) v3(12.62,126.64)
+CCG_VBUS_1: length 48
  TOP w0.508: v1(49.63,134.49) 49.68,134.44 PQS13.3 52.62,134.44 53.26,135.07 PRS36.1 ; v1(29.83,117.41) 29.83,117.99 RT59.1 31.33,118.39 UT4.1 31.45,117.4 CT14.1
  IN2 w0.508: v1(29.83,117.41) 30.11,117.69 32.87,117.69 33.04,117.86 34.42,117.86 34.93,118.37 36.07,118.37 37.53,116.91 40.24,116.91 41.2,117.87 43.37,117.87 43.99,118.49 43.99,123.67 46.64,126.32 47.08,126.32 49.1,128.34 49.1,131.23 47.41,132.93 47.41,133.71 47.67,133.98 49.12,133.98 v1(49.63,134.49) v1(49.63,136.65)
  BOTTOM w0.508: v1(29.83,117.41) 30.23,117.81 CT15.1
  vias: v2(49.16,139.53)
+CHARGER_SRC: length 0.9
  TOP w0.089: v1(199.8,56.24) v2(198.92,56.24)
  vias: v1(199.8,55.6) v1(199.8,54.97) v1(199.8,54.33)
+DC_IN: length 286.1
  TOP w0.508: v1(93.29,151.74) PR13.1 ; v1(47.42,125.1) 47.42,125.78 PR61.1 ; PRS03.1 51.53,114.82 52.13,115.42 v1(52.13,116.02) ; v1(168.72,48.12) 168.72,47.58 v3(169.36,46.93) 170.13,46.17 170.13,44.26 169.79,43.92 169.79,40.53 170.3,40.03 171.66,40.03 172.67,39.02 PR34.1 172.67,37.38 172.16,36.87 PR32.1 171.32,36.04 170.14,34.86 170.14,33.53 170.62,33.05 PR36.1
  IN1 w0.508: v1(53.36,125.81) 52.84,126.34 50.17,126.34 48.94,125.1 v1(47.42,125.1)
  IN2 w0.305: 109.85,115.79 113.99,115.79 114.73,116.53 119.4,116.53 120.39,115.54 123.49,115.54 125.33,113.71 126.65,113.71 126.98,114.04 129.6,114.04 129.95,113.69 131.8,113.69 132.37,113.12 132.37,112.1 135.38,109.09 141.96,109.09 144.69,106.36
  IN2 w0.508: 92.17,151.72 92.19,151.74 v1(93.29,151.74) ; 92.17,151.72 90.71,151.72 87.74,148.75 87.22,148.75 85.86,147.39 85.86,146.01 85.4,145.55 81.47,145.55 74.51,138.59 72.95,138.59 71.87,139.68 64.59,139.68 64.21,139.3 56.72,139.3 53.62,136.2 53.62,130.1 53.86,129.86 53.86,127.65 53.36,127.15 v1(53.36,125.81) 53.36,122.18 54.33,121.22 54.33,119.59 52.13,117.4 v1(52.13,116.02) ; 92.17,151.72 92.17,148.22 92.55,147.84 v1(92.55,146.22) 90.86,144.53 90.12,144.53 89.59,144.01 89.59,138.5 90.65,137.45 94.75,137.45 96.33,135.87 96.33,134.52 96.64,134.21 96.64,129.46 100.53,125.57 100.53,121.43 99.06,119.97 99.06,118.66 100.69,117.03 108.62,117.03 109.85,115.79 ; 144.69,106.36 155.29,106.36 156.45,105.2 156.45,95.43 156.92,94.97 159.19,94.97 160.55,96.32 164.72,96.32 167.88,93.15 167.88,89.84 168.11,89.61 168.11,87.43 167.7,87.02 167.2,87.02 166.92,86.73 166.92,83.9 169.05,81.77 169.05,72.02 171.49,69.57 171.49,63.49 169.31,61.31 169.31,59.22 165.83,55.74 165.83,47.42 166.16,47.09 167.68,47.09 v1(168.72,48.12)
+DC_IN_SS: length 161.2
  TOP w0.089: v3(93.18,137.42) 93.18,138.15 v1(93.07,138.26)
  IN2 w0.305: 144.9,107.57 142.58,109.89 136.22,109.89 133.78,112.32 133.78,113.27 132.56,114.5 130.46,114.5 129.9,115.05 127.57,115.05 126.87,115.76 124.94,115.76 124.01,116.69 121.1,116.69 119.72,118.07 115.52,118.07 114.78,118.8 109.48,118.8 108.94,118.26
  IN2 w0.508: 108.94,118.26 101.74,118.26 101.13,118.87 101.13,125.82 97.24,129.71 97.24,134.46 96.93,134.77 96.93,137.67 96.94,137.68 ; 144.9,107.57 157.83,107.57 170.55,94.85 170.91,89.15 171.3,87.68 171.3,72.96 173.7,70.56 175.05,70.56 175.66,69.95 176.44,69.95 178.09,68.3 178.09,67.37 180.41,65.04 180.41,63.66 180.75,63.32 181.47,63.32 181.64,63.5 185.14,63.5 185.77,62.86 190.43,62.86 192.05,61.25 200.92,61.25 201.46,60.71
  BOTTOM w0.508: PR11.1 v1(97.28,145.26)
  vias: v1(91.86,138.87) v1(91.86,138.26) v1(92.46,138.87) v1(92.46,138.26) v1(93.07,138.87) v1(97.98,143.6) v1(97.98,142.99) v1(98.59,143.6) v1(98.59,142.99) v1(99.2,143.6) v1(99.2,142.99) v1(203.09,60.6) v1(203.09,60)
+DCBAT_LCD: length 6.5
  TOP w0.127: v3(211.96,60.68) 211.44,60.16 v1(211.44,59.39) ; v1(211.44,59.39) 211.77,59.39 212.11,59.74 213.04,59.74 v3(213.9,60.6) ; v1(211.44,59.39) 210.09,59.39 v3(209.58,58.89)
+DP_VDDC: length 6.8
  TOP w0.508: v1(117.5,131.02) 117.5,130.3 CV33.1 CV34.1 116.21,130.23 CV30.1 115.44,129.46 v2(114.08,129.46) 113.64,129.02 RV30.2
  BOTTOM w0.305: v1(117.5,131.02) 117.74,131.27 UV1.AD14
+DP_VDDR: length 7.5
  TOP w0.089: v2(112.2,131.88) 112.2,131.26 CV27.1
  TOP w0.508: v1(116.26,131) 115.65,131 CV26.1 115.59,130.77 115.23,130.41 114.33,130.41 CV35.1 113.19,130.86 CV27.1 112.9,130.09 112.91,130.08 RV27.2
  BOTTOM w0.305: UV1.AF14 116.14,131.12 v1(116.26,131)
+EMMC_VDDI: length 4.9
  TOP w0.089: 86.36,34.94 86.36,34.54 UM1.C2
  TOP w0.102: 86.36,34.94 86.1,35.2 86.1,36.01 86.46,36.37 CM5.1
+FB0_VREFCL: length 6.7
  TOP w0.254: UV12.J14 155.11,146.73 154.66,147.18 v1(154.58,147.18)
  BOTTOM w0.127: RV54.2 v2(152.34,149.98)
  BOTTOM w0.254: UV12.J14 155.11,146.73 154.66,147.18 v1(154.58,147.18)
  BOTTOM w0.381: v1(154.58,147.18) 154.37,147.39 154.37,148.24 154.64,148.51 CV395.1 RV55.1 154.59,149.98 RV54.2
+FB0_VREFDL: length 22
  TOP w0.254: UV12.U10 161.51,143.52 161.11,143.13 v1(161.11,143.13) ; v1(149.14,143.13) 148.74,143.53 UV12.A10
  TOP w0.508: RV52.2 164.06,144.47 CV394.1 RV53.1 v1(162.78,143.5)
  IN2 w0.508: v1(149.14,143.13) 149.14,141.95 149.61,141.47 153.25,141.47 153.55,141.17 159.16,141.17 v1(161.11,143.13)
  BOTTOM w0.127: v1(162.78,143.5) 162.93,143.5 v2(163.53,144.1)
  BOTTOM w0.254: UV12.A10 148.74,143.53 v1(149.14,143.13) ; v1(162.78,143.5) 162.7,143.42 161.61,143.42 UV12.U10 161.51,143.52 161.11,143.13 v1(161.11,143.13)
+FB1_VREFCL: length 7.9
  TOP w0.254: v1(156.07,118.16) 155.68,118.16 155.36,118.48 155.36,119.05 UV14.J14
  BOTTOM w0.254: v1(156.07,118.16) 155.7,118.16 155.11,118.75 UV14.J14
  BOTTOM w0.508: RV51.1 CV391.1 RV50.2 156.28,116.65 v2(156.5,116.87) 156.5,117.74 v1(156.07,118.16)
+FB1_VREFDL: length 20.2
  TOP w0.254: v1(149.11,122.81) 148.97,122.81 148.71,122.55 UV14.U10
  TOP w0.508: v1(161.25,123.3) 161.25,122.76 UV14.A10 v2(163.33,122.51) 163.56,122.74 RV49.1 164.24,121.87 RV48.2 CV390.1
  IN1 w0.508: v1(161.25,123.3) 160.84,123.71 150.01,123.71 v1(149.11,122.81)
  BOTTOM w0.254: UV14.U10 149.01,122.81 v1(149.11,122.81) ; v1(161.25,123.3) 161.25,122.76 161.51,122.51 UV14.A10
+LAN_VDD33: length 1.5
  TOP w0.127: 15.15,84.6 15.15,84.02 v3(14.52,83.4)
  vias: v1(16.07,85.61) v1(16.07,85.02) v1(20.27,84.39) v1(20.76,84.04) v1(21.31,79.56) v1(21.31,78.98) v1(27.36,81.33) v1(27.82,80.91)
+LCDVDD: length 2.6
  TOP w0.127: 211.36,49.49 211.44,49.56 211.44,51.11 v3(210.75,51.8)
  vias: v1(210.65,48.9) v1(211.22,49.13) v1(211.22,48.49) v3(208.8,48.36) v3(210.68,48.24)
+LCDVDD_LCD: length 1.1
  TOP w0.127: C2.1 212.51,57.56 v2(212.51,58.48)
  vias: v1(213.28,56.98) v1(213.33,56.38) v1(213.88,56.98) v1(213.94,56.38)
+LINE1_VREFO_L: length 3.5
  TOP w0.203: RA29.1 20.96,13.44 21.32,13.09 23.12,13.09 23.16,13.05 UA1.31
+LINE1_VREFO_R: length 5.2
  TOP w0.203: RA33.1 19.39,13.97 21.04,13.97 v3(21.5,13.5) 21.59,13.42 22.9,13.42 22.93,13.45 UA1.30
+MIC2-VREFO: length 13.2
  TOP w0.089: v1(27.69,20.35) 27.69,20.68 v3(28.08,21.06)
  TOP w0.203: v1(22.37,13.85) 22.45,13.85 UA1.29
  TOP w0.254: RA26.1 24.62,18.85 v1(24.6,18.88) ; RA25.1 27.75,20.3 v1(27.69,20.35)
  BOTTOM w0.254: v1(22.37,13.85) 22.37,14.31 24.6,16.53 v1(24.6,18.88) 24.6,18.91 26.04,20.35 v1(27.69,20.35)
+MPLL_PVDD: length 5.2
  TOP w0.381: CV124.1 127.27,125.21 126.58,124.53 126.48,124.53 LV6.2
  TOP w0.508: v1(128.43,126.22) 128.28,126.37 CV82.1 127.63,126.29 127.63,125.75 CV124.1 127.3,125.38 127.84,124.84 CV81.1
  BOTTOM w0.381: UV1.L8 128.05,126.6 v1(128.43,126.22)
+MVREFDA: length 9.2
  TOP w0.102: v1(129.24,141.4) v2(129.24,140.67)
  IN1 w0.508: v1(128.88,145.21) 127.87,144.2 127.87,143.13 128.09,142.9 128.1,142.9 128.83,142.17 128.83,141.82 v1(129.24,141.4)
  BOTTOM w0.254: v1(129.24,141.4) 128.94,141.1 UV1.K26
  BOTTOM w0.508: v1(128.88,145.21) 128.88,145.35 129.71,146.19 CV94.1 130.45,146.43 RV33.2 RV34.1
+MVREFSA: length 12.5
  TOP w0.254: 130.72,143.49 130.72,141.96 v1(130.21,141.45)
  TOP w0.508: 130.72,143.49 130.72,146.55 131.43,147.25 v2(132.04,147.25) 132.55,147.25 v1(133.36,146.45)
  BOTTOM w0.254: UV1.J26 130.19,141.45 v1(130.21,141.45)
  BOTTOM w0.508: CV95.1 RV35.1 134.4,147.38 134.23,147.55 134.2,147.55 134.17,147.58 133.69,147.58 133.49,147.38 RV32.2 133.33,146.47 v1(133.36,146.45)
+PCIE_VDDC: length 11.5
  BOTTOM w0.381: UV1.N24 127.11,139.76 v1(127.42,139.76) 127.57,139.76 UV1.L24 ; UV1.L23 127.47,139.07 v1(127.42,139.07) 127.21,139.07 UV1.N23 126.64,138.7 v1(126.14,138.7) UV1.N22 UV1.M22 ; UV1.L25 127.69,140.45 v1(127.42,140.45) ; UV1.L26 127.66,141.28 v1(127.42,141.28) ; v1(122.54,138.4) UV1.V22 UV1.U22 v1(123.74,138.33) 124.14,137.93 UV1.T22 124.34,137.8 v1(124.92,138.38) UV1.R22
  vias: v1(115.74,121.01) v1(115.74,120.43) v1(116.32,121.01) v1(116.32,120.43) v2(125.54,143.72)
+PWR_SRC_AC: length 1
  BOTTOM w0.089: PRB01.4 184.17,56.49 v2(184.49,56.17)
+RTC_CELL: length 192
  TOP w0.254: v1(37.67,54.9) 38.25,54.33 C1.1 38.25,52.81 39.07,51.99 D1.1 41.19,51.99 42.66,53.45 44.97,53.45 45.47,52.94 45.47,51.58 47.24,49.82 51.49,49.82 51.95,49.37 51.95,47.89 51.06,47 51.06,40.27 54.25,37.08 63.17,37.08 63.39,36.85 v1(63.39,36.6) ; RA12.2 30.98,22.84 31.42,22.41 v1(31.42,22.02) ; v1(30.13,67.01) 30.06,66.94 RE7.1 30.64,66.29 31.11,66.76 31.38,66.76 RE70.2 RE41.1 ; RC91.2 99.13,42.49 v1(99.13,41.52) RC199.2 ; 65.19,28.16 v1(65.19,26.44) ; v1(74.52,36.09) 74.52,36.08 74.32,35.89 v3(74.32,35.26) 74.32,34.89 73.41,33.98 73.41,32.81 72.74,32.14 72.74,27.41 73.27,26.87 v1(73.27,26.36)
  IN1 w0.254: v1(30.13,67.01) 30.13,64.09 30.6,63.62 33.23,63.62 34.34,62.51 34.34,61.53 34.92,60.96 37.37,60.96 37.7,60.63 37.7,58.48 37.67,58.45 v1(37.67,54.9) ; v1(23.71,61.96) 22.75,61.01 22.75,56.87 22.07,56.18 21.38,55.49 21.38,53.64 20.44,52.7 20.44,50.88 19.93,50.38 19.93,44.78 20.54,44.17 20.54,42.45 19.43,41.33 19.43,32.36 18.2,31.12 18.2,27.62 v1(19.69,26.12)
  IN2 w0.254: v1(63.39,36.6) 63.59,36.79 70.1,36.79 70.53,36.36 72.24,36.36 72.85,35.75 74.18,35.75 v1(74.52,36.09) 74.64,36.21 80.59,36.21 83.4,39.02 91.96,39.02 92.33,38.65 96.11,38.65 98.98,41.52 v1(99.13,41.52)
  IN3 w0.254: v1(30.13,67.01) 29.66,66.54 29.66,64.03 28.13,62.49 24.24,62.49 v1(23.71,61.96)
  BOTTOM w0.254: v1(19.69,26.12) 19.69,24.29 20.25,23.73 29.13,23.73 30.01,22.86 31,22.86 31.42,22.44 v1(31.42,22.02) ; v1(73.27,26.36) 73.27,26.49 72.49,27.28 66.02,27.28 v1(65.19,26.44)
+RTC_CELL_PCH: length 88.1
  TOP w0.254: v1(64.35,36.34) 64.26,36.25 C59.1 64.25,35.29 R73.1 63.51,34.35 63.25,34.09 v2(63.25,33.82) 63.25,32.33 64.22,31.36 Q23.1 ; RC199.1 100.05,41.18 v1(99.72,41.51) 99.72,42.32 RC77.2 RC78.2 101.28,42.52 101.36,42.45 CC71.1
  IN1 w0.254: v1(99.72,41.51) 99.72,41.81 102.99,45.08 103.92,45.08 104.31,44.69 105.14,44.69 110.49,50.04 v1(110.49,57.13) 111,57.64 113.01,57.64 v1(113.4,58.02)
  IN2 w0.254: v1(99.72,41.51) 99.72,40.59 98.13,39 96.95,39 96.25,38.3 92.19,38.3 91.82,38.67 86.92,38.67 86.68,38.44 83.67,38.44 81.09,35.86 75.14,35.86 74.68,35.4 72.7,35.4 72.09,36.01 70.39,36.01 69.95,36.45 68.42,36.45 67.76,35.78 64.69,35.78 64.42,36.05 64.42,36.26 v1(64.35,36.34)
  IN3 w0.254: v1(121.51,61.02) 121.39,60.91 116.96,60.91 116.93,60.93 116.36,60.93 113.46,58.02 v1(113.4,58.02)
  BOTTOM w0.254: UC1.BB14 114.18,58.03 113.61,58.03 113.61,58.03 113.6,58.02 v1(113.4,58.02) ; v1(121.51,61.02) 121.48,61 121.39,61 121.11,60.72 UC1.AK19 ; v1(110.49,57.13) 110.43,57.19 CC70.1
+RTC_CELL_VBAT: length 16.3
  TOP w0.089: v2(28.33,65.72) 29.16,64.89 RE7.2 30.39,64.89
  TOP w0.203: UE1.122 34.57,71.81 34.24,72.14 v1(33.13,72.14) 32.3,72.14 CE14.1
  TOP w0.508: 30.39,64.89 30.77,64.51 v1(30.77,64.19)
  IN2 w0.508: v1(30.77,64.19) 32.19,65.62 32.19,71.64 32.7,72.14 v1(33.13,72.14)
+RTC_VCC: length 189.5
  TOP w0.254: R1.2 42.41,47.16 v3(43.32,46.24) 44.76,44.8 44.76,43.94 44.33,43.51 44.33,40.85 v1(42.27,38.79)
  IN2 w0.254: v1(203.77,35.92) 201.95,35.92 201.66,36.2 198.55,36.2 197.98,36.77 194.59,36.77 194.1,36.28 192.31,36.28 191.98,36.61 186.48,36.61 185.88,36.01 181.72,36.01 180.96,35.25 179.23,35.25 177.02,33.04 173.87,33.04 173.48,33.43 167.67,33.43 167.53,33.29 165.48,33.29 164.86,32.67 164.53,32.67 163.74,31.88 157.8,31.88 157.65,32.03 155.42,32.03 155.19,31.8 151.71,31.8 150.72,32.79 150.72,34.01 150.43,34.3 146.41,34.3 145.82,34.9 145.13,34.9 144.64,35.39 143.8,35.39 143.59,35.6 134.42,35.6 133.21,34.39 130.05,34.39 129.45,33.79 116.96,33.79 115.68,32.51 114.69,32.51 113.87,31.69 108.07,31.69 107.73,31.35 97.66,31.35 96.72,30.41 91.92,30.41 90.75,29.24 79.06,29.24 78.37,29.93 77.38,29.93 77.21,30.1 76.41,30.1 76.28,30.23 70.85,30.23 70.48,30.6 65.95,30.6 65.79,30.76 v1(65.07,30.76) ; v1(42.27,38.79) 43.28,38.79 47.34,34.73 47.34,31.96 48.23,31.07 55.91,31.07 56.75,30.23 56.75,29.59 v1(57.71,28.63)
  BOTTOM w0.254: v1(203.77,35.92) 203.24,36.45 JIOB1.11 ; v1(57.71,28.63) 57.95,28.63 60.27,30.95 64.89,30.95 v1(65.07,30.76)
+SDC_IN: length 221.6
  TOP w2.54: 107.55,151.94 116.94,151.94 120.84,148.04 125.35,148.04 125.8,148.02 125.81,148.02 125.92,148.02 126.34,148 126.42,148.02 126.51,148.02 126.92,148.1 126.93,148.1 127.31,148.17 127.39,148.19 127.84,148.28 127.97,148.41 128.24,148.51 128.31,148.55 128.47,148.62 128.53,148.68 128.78,148.85 129.08,149.04 129.13,149.09 129.22,149.14 129.56,149.49 129.59,149.51 129.68,149.51 130.97,150.81 133.51,150.81 135.1,152.4 164.78,152.4 166.85,150.33 166.85,131.32 167.43,130.74 167.43,118.61
  IN1 w0.508: v1(198.8,50.14) 198.19,50.75 198.19,53.97 193.37,58.79 186.25,58.79 184.82,60.21 v1(184.82,61.09)
  BOTTOM w0.508: v1(198.8,50.14) PRB05.1 199.67,49.37 PRB04.1 ; 102.42,149.22 101.42,148.22 100.58,148.22 100.09,147.73 PQ19.3 98.64,148.28 97.1,148.28 96.64,147.82 96.64,147.46 96.25,147.06 94.01,147.06 93.37,147.71 PR47.1
  BOTTOM w2.54: 167.43,118.61 167.43,130.74 166.85,131.31 166.85,150.26 164.85,152.26 138.93,152.26 137.6,150.93 134.45,150.93 ; 131.25,150.88 130.96,150.88 130.16,150.09 130.04,150.03 129.75,149.65 129.02,148.99 128.17,148.48 127.96,148.4 127.84,148.28 127.36,148.19 127.36,148.19 127.24,148.14 126.86,148.09 126.86,148.09 126.51,148.02 126.38,148.02 126.26,148 125.88,148.02 125.51,148.02 125.39,148.04 125.27,148.05 124.91,148.14 119.62,149.19 116.99,151.82 108.09,151.82 108.08,151.82
  vias: v1(64.74,132.06) v1(64.74,131.43) v1(65.38,132) v1(65.38,131.4) v1(66,132.02) v1(66,131.42) v1(66.68,132.02) v1(66.68,131.42) v1(67.92,134.67) v1(68.6,134.64) v1(104.28,149.31) v1(104.7,149.77) v1(104.81,148.87) v1(105.1,150.19) v1(105.24,149.32) v1(105.52,150.61) v1(105.64,149.74) v1(105.94,151.01) v1(106.05,150.16) v1(106.48,150.56) v1(163.74,116.52) v1(163.74,115.91) v1(163.74,115.3) v1(164.35,116.52) v1(164.35,115.91) v1(164.35,115.3) v1(164.96,116.52) v1(164.96,115.91) v1(164.96,115.3) v1(165.57,116.52) v1(165.57,115.91) v1(165.57,115.3) v1(169.96,101.72) v1(169.96,101.11) v1(169.96,100.5) v1(169.96,99.89) v1(169.96,99.28) v1(169.96,98.67) v1(170.57,101.72) v1(170.57,101.11) v1(170.57,100.5) v1(170.57,99.89) v1(170.57,99.28) v1(170.57,98.67) v1(177.55,77.07) v1(178.02,76.71) v1(178.47,76.32) v1(178.92,75.91) v1(179.37,75.5) v1(183.55,61.71) v1(183.55,61.13) v1(184.18,61.71) v1(184.18,61.13) v1(184.82,61.71) v3(184.53,69.87)
+SPLL_PVDD: length 8.5
  TOP w0.127: v2(131.71,118.12) 132.13,118.55 LV7.2
  TOP w0.508: v1(130.91,125.37) 130.91,123.84 130.93,123.82 CV85.1 130.93,122.51 131.5,121.94 CV86.1 131.5,121.24 132.01,120.74 132.01,120.24 CV84.1 132.13,120.11 LV7.2
  BOTTOM w0.381: v1(130.91,125.37) 130.54,125.74 UV1.H7
+SPLL_VDDC: length 4.5
  TOP w0.127: v2(133.26,118.19) 132.9,118.55 LV8.2
  TOP w0.508: CV93.1 131.67,125.51 v1(130.93,126.24)
  BOTTOM w0.305: UV1.H8 130.89,126.24 v1(130.93,126.24)
+TP_VDD: length 32.5
  TOP w0.254: v1(120.93,29.1) 121.81,29.1 R46.1
  TOP w0.508: v1(117.71,29.45) 117.34,29.45 v3(116.99,29.1) 115.88,27.99 R31.1 115.91,27.54 116.18,27.54 116.76,26.96 R47.1 117.04,26.91 117.6,26.91 118.09,26.41 R32.1 121.03,26.12 122.04,25.1 122.17,25.1 R39.1 122.25,25.1 122.8,25.1 123.28,25.58 123.28,26.24 124.34,27.3 124.71,27.3 Q9.2 127.03,26.65 C19.1 127.9,26.65 R40.1 129.43,26.67 130.15,27.39 Q12.1 131.29,26.64 130.95,26.3 130.95,25.62 R36.2 131.76,25.98 133.29,25.98 R37.2
  BOTTOM w0.381: v1(120.93,29.1) 120.93,28.82 120.65,28.55 119.22,28.55 118.32,29.45 v1(117.71,29.45)
+TPAN_VDD:
  vias: v1(212.7,40.44) v1(212.7,39.86) v2(208.48,37.93)
+TPAN_VDD_F: length 10.4
  TOP w0.508: C31.1 v2(206.43,36.81) 207.51,36.81 R30.2 207.7,37.47 207.43,37.74 v1(207.06,37.74)
  IN1 w0.508: v1(213.56,38.65) 213.52,38.69 210.64,38.69 209.68,37.74 v1(207.06,37.74)
  vias: v1(214.12,39.67) v1(214.07,39.05)
+TSVDD: length 9.8
  TOP w0.508: LV2.2 110.13,133.55 CV19.1 111.51,133.24 112.69,133.24 113.03,132.89 v2(113.45,132.89) 113.79,132.89 114.06,133.16 114.78,133.16 115.46,132.48 116.77,132.48 CV21.1 117.57,132.57 CV20.1 117.62,132.87 v1(117.62,133.45)
  BOTTOM w0.381: UV1.AD17 117.62,133.88 v1(117.62,133.45)
+V_DDR_REFA: length 2.7
  TOP w0.089: v1(72.75,66.89) v2(72.75,67.65)
  BOTTOM w0.305: v1(72.75,66.89) 72.17,66.89 71.82,67.24 JDIMM1.164
+V_DDR_REFA_R: length 138
  TOP w0.508: v1(68.36,62.85) 68.36,63.3 68.72,63.67 v2(69.48,63.67) CD30.1 RD9.1
  IN1 w0.381: v1(68.36,62.85) 68.5,62.99 68.5,66.76 68.96,67.22 68.96,68.63 66.65,70.94 66.65,108.89 65.12,110.42 v1(65.12,110.74) ; v1(115.22,89.28) 116.28,90.35 122.66,90.35 123.77,91.46 123.77,100.16 116.52,107.41 88.87,107.41 v1(88.03,108.25)
  IN2 w0.508: v1(88.03,108.25) 86.86,108.25 83.8,111.32 77.89,111.32 77.02,112.19 76.45,112.19 76.01,112.63 70.01,112.63 69.71,112.94 67.13,112.94 65.12,110.93 v1(65.12,110.74)
  BOTTOM w0.152: UC1.AY67 115.29,88.28 115.29,89.21 v1(115.22,89.28)
+V_DDR_REFB: length 2.5
  TOP w0.089: v1(60.05,66.89) 60.31,66.63 v2(60.31,66.4)
  BOTTOM w0.305: v1(60.05,66.89) 59.69,67.24 JDIMM2.164
+V_DDR_REFB_R: length 139.9
  TOP w0.508: v1(56.98,68.99) 57.04,68.94 CD59.1 RD19.1
  IN1 w0.381: v1(88.92,108.25) 89.28,107.89 116.71,107.89 124.25,100.35 124.25,98.24 124.25,98.24 124.25,91.27 122.69,89.71 116.42,89.71 115.4,88.7 v1(114.46,88.7)
  IN1 w0.508: v1(56.98,68.99) 57.9,68.99 58.68,69.76 65.15,69.76 66.11,70.72 66.11,108.55 64.72,109.93 64.45,110.21 v1(64.45,110.49)
  IN2 w0.508: v1(64.45,110.49) 64.45,111.15 66.84,113.54 70.04,113.54 70.32,113.26 76.23,113.26 76.7,112.79 77.27,112.79 78.14,111.92 84.12,111.92 86.83,109.22 88.29,109.22 88.92,108.58 v1(88.92,108.25)
  BOTTOM w0.254: v1(114.46,88.7) 114.57,88.59 UC1.BA67
+VCHGR: length 0.8
  TOP w0.089: v2(171.52,39.04) 171.84,38.72 v1(171.84,38.39)
  vias: v1(170.62,38.39) v1(170.62,37.75) v1(171.26,38.39) v1(171.26,37.75) v1(171.84,37.75) v1(177.38,44.22) v1(177.38,43.63) v1(177.73,45.79) v1(177.96,44.2) v1(177.96,43.62) v1(178.32,45.78)
+VGA_CORE: length 16.9
  TOP w0.381: v1(127.64,134.2) 127.84,134.01 CV115.1 ; CV112.1 122.49,134.02 v1(122.77,134.3) 123.33,133.73 CV113.1 CV111.1 ; CV116.1 126.67,134.24 v1(126.72,134.24) 126.21,133.73 CV114.1 ; v1(124.61,134.19) 125.19,134.77 CV117.1 ; CV105.1 CV101.1 123.4,126.77 CV102.1 122.95,127.74 v1(122.69,127.74) ; v1(127.71,132.47) 127.89,132.65 CV77.1
  TOP w0.457: CV107.1 121.84,127.57 v1(121.3,127.57) ; CV73.1 120.71,132.51 v1(120.82,132.4) 121.28,132.4 CV71.1 ; CV103.1 120.68,126.85 v1(121.3,126.85)
  TOP w0.508: CV127.1 120.86,136.32 v1(120.86,136.32) ; v1(127.41,128.4) 126.98,128.4 CV119.1 ; CV74.1 121.39,135.67 v1(121.77,135.3) 122.28,135.3 CV75.1 ; CV118.1 125.16,135.91 v1(124.67,136.41)
  vias: v1(104.76,139.99) v1(104.76,139.4) v1(104.76,138.46) v1(104.76,137.88) v1(104.76,136.94) v1(104.76,136.36) v1(105.06,122.46) v1(105.06,121.85) v1(105.06,121.27) v1(105.06,120.68) v1(105.19,124.9) v1(105.19,124.29) v1(105.19,123.68) v1(105.19,123.07) v1(105.34,140.75) v1(105.34,139.99) v1(105.34,139.4) v1(105.34,138.46) v1(105.34,137.88) v1(105.34,136.94) v1(105.34,136.36) v1(105.34,135.42) v1(105.65,122.46) v1(105.65,121.85) v1(105.65,121.27) v1(105.65,120.68) v1(105.77,125.51) v1(105.77,124.9) v1(105.77,124.29) v1(105.77,123.68) v1(105.77,123.07) v1(105.93,140.75) v1(105.93,139.99) v1(105.93,139.4) v1(105.93,138.46) v1(105.93,137.88) v1(105.93,136.94) v1(105.93,136.36) v1(105.93,135.42) v1(105.93,134.83) v1(106.23,122.46) v1(106.23,121.85) v1(106.23,121.27) v1(106.23,120.68) v1(106.36,125.51) v1(106.36,124.9) v1(106.36,124.29) v1(106.36,123.68) v1(106.36,123.07) v1(106.51,140.75) v1(106.51,139.99) v1(106.51,139.4) v1(106.51,138.46) v1(106.51,137.88) v1(106.51,136.94) v1(106.51,136.36) v1(106.51,135.42) v1(106.51,134.83) v1(106.82,122.46) v1(106.82,121.85) v1(106.82,121.27) v1(106.82,120.68) v1(106.94,124.9) v1(106.94,124.29) v1(106.94,123.68) v1(106.94,123.07) v1(107.1,140.75) v1(107.1,139.99) v1(107.1,139.4) v1(107.1,138.46) v1(107.1,137.88) v1(107.1,136.94) v1(107.1,136.36) v1(107.1,135.42) v1(107.1,134.83) v1(115.79,125.4) v1(115.79,124.57) v1(116.54,125.44) v1(118.11,128.61) v1(118.29,131.02) v1(118.56,121.07) v1(118.7,132.22) v1(118.94,121.58) v1(119.25,121.07) v1(119.57,122.56) v1(119.79,130.41) v1(119.81,129.5) v1(119.8,121.39) v1(120.66,123.4) v1(121.34,124.63) v1(121.83,121.39) v1(122.06,123.8) v1(122.15,124.58) v1(122.92,130.55) v1(123.74,131.53) v1(125.65,131.38) v1(125.76,129.48) v1(126.71,135.24) v3(113.53,123.13)
AC_B2B_ACOK: length 21
  TOP w0.254: PQ16.1 90.75,149.05 v2(91.15,149.46) 91.41,149.72 92.39,149.72 v1(92.88,150.2) 93.63,150.96 PD10.1
  IN2 w0.254: v1(104.17,147.47) 101.71,147.47 100.78,148.39 96.27,148.39 94.47,150.2 v1(92.88,150.2)
  BOTTOM w0.254: PQ20.1 v1(104.17,147.47) ; PR2.1 90.43,150.49 92.07,150.49 92.36,150.2 v1(92.88,150.2)
AC_B2B_S1: length 68.4
  TOP w0.089: v1(86.97,147.63) 86.97,147.59 v2(87.31,147.25)
  TOP w0.254: PQ16.2 88.6,149.13 PR22.2 87.73,148.26 PC22.1 v1(86.97,147.63) ; v1(64.5,119.72) 64.66,119.57 PQS11.1
  IN2 w0.254: v1(64.68,126.86) 65.23,126.3 67.46,126.3 68.46,125.31 68.46,121.09 67.09,119.72 v1(64.5,119.72)
  IN3 w0.254: v1(64.68,126.86) 64.68,127.44 63.5,128.62 63.5,136.18 65.71,138.39 70,138.39 73.14,141.53 75.09,141.53 75.58,142.03 75.58,144.47 79.65,148.53 83.22,148.53 83.83,149.14 86.17,149.14 86.65,148.66 86.65,147.95 v1(86.97,147.63) 87.55,148.22 88.49,148.22 89.58,149.3 93.17,149.3 93.48,148.99 94,148.99 94.24,149.23 v1(94.24,149.6)
  BOTTOM w0.254: PQ15.1 94.24,148.87 v1(94.24,149.6)
AC_B2B_S1_A: length 5.8
  BOTTOM w0.254: PR100.1 v2(91.7,152.64) 91.08,152.01 PQ5.2 90.48,151.01 PR2.2 89.45,150.43 89.45,149.77 PC7.1
AC_B2B_S2: length 5.9
  BOTTOM w0.089: v2(94.42,141.96) PR51.1
  BOTTOM w0.254: PR51.1 94.51,143.12 PQ6.2 94.51,144.65 95.12,145.26 PR11.2 95.64,144.42 PC10.1 PR17.1
AC_B2B_S2_A: length 5.9
  BOTTOM w0.127: PR50.2 v2(91.86,144.72)
  BOTTOM w0.254: PR60.2 91.12,143.49 PQ18.1 91.12,143.93 90.68,144.37 PQ17.2 91.21,145.97 PR50.2
AC_B2B_S2_B: length 15.4
  TOP w0.089: v2(98.56,147.84) 98.23,147.51 v1(97.82,147.51)
  IN3 w0.254: v1(90.81,149.91) 91.07,149.65 93,149.65 94.03,150.68 96.05,150.68 97.82,148.9 v1(97.82,147.51)
  BOTTOM w0.254: v1(90.81,149.91) 90.78,149.87 PR48.1 91.44,148.62 PR47.2 ; PQ19.2 98.39,145.8 97.82,146.36 v1(97.82,147.51)
AC_B2B_S2_G: length 11.9
  TOP w0.089: PR9.2 99.83,148.6 v2(99.63,148.8)
  TOP w0.254: PR9.2 100.62,148.15 PC6.2 100.07,146.8 v1(100.05,146.77) 100.66,146.15 PQ4.4
  BOTTOM w0.254: v1(100.05,146.77) 100.05,146.77 PQ19.1 101.28,146.21 100.05,144.98 98.33,144.98 97.25,146.06 PR12.1
AC_B2B_S2_SW: length 74
  TOP w0.089: v1(80.08,147.94) v2(80.08,148.84)
  TOP w0.254: PR52.2 51.49,121.2 v1(51.41,121.12)
  IN1 w0.254: v1(52.48,135.33) 55.87,138.72 75.57,138.72 77.35,140.5 79.41,140.5 80.08,141.17 v1(80.08,147.94)
  IN2 w0.254: v1(51.41,121.12) 50.39,121.12 49.68,121.83 49.68,126.27 50.63,127.23 50.63,129.03 52.08,130.48 52.08,134.93 v1(52.48,135.33)
  BOTTOM w0.254: v1(80.08,147.94) 80.55,148.41 84.58,148.41 86.51,146.48 86.51,143.39 PR49.2 PC23.1 88.27,142.84 PQ18.2 90.05,142.84 90.59,142.3 91.41,142.3 91.74,141.97 92.92,141.97 93.51,142.55 PR51.2
AC_DIS: length 231.9
  TOP w0.089: PRB43.2 194.74,32.38 v2(194.76,32.36) 195.09,32.36 195.3,32.15 v1(195.3,31.73)
  TOP w0.102: v1(47.66,81.62) 48.15,82.12 UE1.69
  IN1 w0.102: v1(34.49,77.86) 34.49,79.3 36.77,81.58 42.81,81.58 43.32,81.07 46.53,81.07 47.08,81.62 v1(47.66,81.62)
  IN2 w0.089: v1(195.3,31.73) 194.7,31.14 185.7,31.14 184.79,32.05 180.93,32.05 178.99,30.1 178.12,30.1 177.41,29.39 175.17,29.39 174.61,28.84 173.77,28.84 173.01,28.84 172.61,29.24 168.93,29.24 168.65,29.52 166.12,29.52 165.95,29.35 156.14,29.35 156.14,29.35 155.84,29.35 155.22,28.74 148.43,28.74 145.58,31.58 144.67,31.58 143.05,33.21 136.17,33.21 133.37,30.42 117.2,30.42 116.29,29.5 113.42,29.5 112.27,28.35 107.82,28.35 107.05,29.13 105.77,29.13 104.25,27.61 99.61,27.61 98.87,26.86 97.99,26.86 97.42,27.43 94.41,27.43 93.89,26.91 76.4,26.91 75.67,27.65 60.42,27.65 59.75,28.32 59.75,30.57 57.62,32.71 57.34,32.71 55.25,34.79 51.93,34.79 45.54,41.17 45.54,42.45 43.84,44.16 43.84,44.81 44.29,45.26 44.29,53.58 45.02,54.31 45.39,54.68 45.39,59.65 43.17,61.87 43.17,64.16 42.94,64.38 42.24,64.38 40.94,65.68 40.94,66.28 40.54,66.69 40.11,67.12 36.23,67.12 36.08,66.96 34.99,66.96 34.68,67.28 34.68,73.56 33.91,74.33 33.91,76.24 34.49,76.83 v1(34.49,77.86)
AC_DIS1: length 193.1
  TOP w0.254: v1(192.2,42.24) 192.2,33.52 PQB04.2 192.14,33.02 191.93,32.81 PRB23.1 192.75,32.44 PRB43.1
  IN1 w0.254: v1(181,63.9) 180.73,63.64 180.73,61.13 181.24,60.63 181.36,60.63 184.88,57.11 184.88,49.49 184.21,48.82 184.21,43.92 185.9,42.24 v1(192.2,42.24)
  IN2 w0.254: v1(102.5,146.36) 102.22,146.36 100.99,145.13 100.99,135.31 104.53,131.77 104.53,128.94 101.61,126.02 101.61,119.28 102.15,118.74 108.89,118.74 109.33,119.18 114.93,119.18 115.67,118.44 121.52,118.44 122.9,117.06 124.16,117.06 124.6,116.62 125.87,116.62 126.36,116.13 127.02,116.13 127.73,115.43 129.12,115.43 129.46,115.77 129.46,116.58 129.92,117.04 133.51,117.04 135.38,115.17 135.38,113.4 135.7,113.08 135.7,112.04 136.38,111.36 137.58,111.36 138.29,110.65 142.34,110.65 144.83,108.16 148,108.16 148.55,108.71 157.36,108.71 171.01,95.06 171.38,89.23 171.77,87.75 171.77,73.16 173.21,71.73 175.18,71.73 176.34,70.57 176.54,70.57 178.56,68.55 178.56,67.56 181,65.13 v1(181,63.9)
  BOTTOM w0.254: PQ20.2 102.95,146.82 v1(102.5,146.36)
AC_OK: length 290.9
  TOP w0.102: v1(168.51,48.7) 168.8,48.99 v2(168.8,49.18)
  TOP w0.254: PR15.1 91.61,152.84 PR13.2 92.38,151.93 PD10.2 92.05,151.47 v1(91.55,150.97) ; v1(51.3,122.32) 51.55,122.32 PRS33.1 PRS41.1 ; v1(168.51,48.7) 168.13,48.32 168.13,47.46 169.65,45.93 169.65,44.58 168.69,43.62 168.69,42.81 169.11,42.39 169.11,40.27 170.07,39.3 170.07,35.74 169.53,35.19 168.96,35.19 168.7,34.93 168.7,33.47 168.82,33.36 PRB44.1
  IN2 w0.254: v1(168.51,48.7) 168.82,48.7 169.21,48.31 169.21,47.79 168.04,46.61 165.88,46.61 165.31,47.18 165.31,55.96 166.41,57.06 166.41,59.12 170.92,63.63 170.92,69.47 168.58,71.82 168.58,81.57 166.44,83.7 166.44,88.48 167.41,89.45 167.41,92.96 164.52,95.84 160.75,95.84 159.39,94.49 156.6,94.49 155.41,95.67 155.41,96.05 155.98,96.62 155.98,105 155.09,105.89 144.49,105.89 142.52,107.86 135.58,107.86 131.92,111.51 130.07,111.51 129.59,112 127.42,112 126.13,113.28 124.61,113.28 123.07,114.82 120.04,114.82 119.03,115.82 115.18,115.82 114.31,114.94 109.84,114.94 108.28,116.51 100.34,116.51 98.95,117.89 94.88,117.89 91.39,121.38 90.37,121.38 89.98,120.99 86.93,120.99 83.71,120.99 82.3,122.4 78.17,122.4 77.7,122.87 77.7,123.3 78.02,123.63 78.02,124.2 77.45,124.77 77.45,126.31 76.65,127.11 76.65,138.23 78.8,140.37 79.45,140.37 80.3,141.22 80.3,142.88 82.1,144.69 88.13,144.69 89.54,146.1 89.54,147.43 89.89,147.77 89.89,150.05 90.81,150.97 v1(91.55,150.97)
  IN3 w0.254: v1(51.3,122.32) 51.3,124.29 51.89,124.87 53.31,124.87 53.98,124.2 55.28,124.2 56.41,125.34 60.97,125.34 63,127.36 63,136.17 65.56,138.74 69.85,138.74 73,141.88 74.94,141.88 75.23,142.17 75.23,144.61 79.5,148.88 83.08,148.88 83.69,149.49 89.16,149.49 90.65,150.97 v1(91.55,150.97)
AC_PRESENT: length 30.6
  TOP w0.089: v1(101.09,45.22) 100.09,46.22 98.6,46.22 98.38,46.01 96.71,46.01 DZ1.2 ; RC211.1 103.49,54.01
  TOP w0.102: v1(103.19,53) 103.19,53.71 RC90.1
  BOTTOM w0.076: 107.43,57.02 108.32,57.91 111.84,57.91 112.25,58.32 112.73,58.32 113.27,58.86 114.76,58.86 UC1.AY15
  BOTTOM w0.089: v1(101.09,45.22) 101.09,45.78 101.91,46.6 101.91,50.13 102.62,50.84 102.62,52.43 v1(103.19,53) 103.55,53.36 104.21,53.36 107.43,56.58 107.43,57.02
AC_SW_PROCHOT: length 4.7
  TOP w0.089: v2(172.27,27.57) 170.77,27.57 PR33.2
  TOP w0.254: PR33.2 169.71,28.63 169.56,28.63 PC13.1 169.56,29.25 PQ12.6
ACAV_IN1: length 67.4
  TOP w0.254: PQB04.1 192.79,36.47 PRB20.1 v2(192.73,37.68) 192.73,37.68 193.09,38.03 v1(193.09,38.16) ; PRB41.1 162.75,35.66 v1(162.75,35.91)
  IN2 w0.254: v1(207.98,49.33) 207.75,49.1 207.75,48.5 208.52,47.73 208.52,42.9 208.15,42.53 208.15,39.14 207.41,38.4 205.81,38.4 205.04,37.63 199.14,37.63 198.11,38.66 193.59,38.66 v1(193.09,38.16) 192.62,38.63 186.79,38.63 186.12,39.3 185.16,39.3 183.46,37.6 180.86,37.6 180.4,37.15 178.59,37.15 177.52,36.08 175.78,36.08 175.45,36.4 169.35,36.4 169.33,36.42 163.25,36.42 v1(162.75,35.91)
  BOTTOM w0.203: PRB11.2 207.06,50.81 PRB22.2 207.09,50.79 207.29,50.79 207.55,50.53 207.55,49.77 v1(207.98,49.33)
ACIN_CHG: length 7.7
  TOP w0.089: v2(200.45,52.84) PRB07.1
  TOP w0.254: v1(201.15,51.79) 201.11,51.75 PRB07.1
  IN3 w0.254: v1(201.15,51.79) 202.66,51.79 204,50.45 v1(204,48.8)
  BOTTOM w0.203: v1(204,48.8) 203.97,48.76 PUB01.19
ACOK_CHG: length 3
  BOTTOM w0.203: PRB22.1 207.06,49.57 207.32,49.31 v2(207.32,48.97) 207.01,48.66 206.36,48.66 205.97,48.27 PUB01.24
ADDR_VBOOT_CPU: length 3.5
  TOP w0.089: v2(172.46,58.39) 171.79,57.72 PRZ69.1
  TOP w0.254: PRZ69.1 171.12,57.36 v1(171.11,57.36)
  BOTTOM w0.203: v1(171.11,57.36) 171.58,56.9 PUZ01.21
ADJ_2.5V: length 6.1
  TOP w0.254: PU2501.7 64.93,111.69 PC2505.2 PR2502.2 63.85,110.17 v2(64.2,109.82) 64.95,109.82 PR2503.1
ADP_CHG: length 3.5
  TOP w0.089: v1(202.2,48.25) 202.2,48.55 v2(201.93,48.83)
  BOTTOM w0.203: PRB04.2 201.32,49.13 v1(202.2,48.25) 202.47,47.98 PUB01.16
ALERT#: length 3.6
  BOTTOM w0.089: R28.2 175.6,64.59 175.51,64.68 v2(175.51,65.5) 175.59,65.58 176.51,65.58 U2.6
ALERT#_CPU: length 2.3
  BOTTOM w0.203: PRZ47.1 176.67,61.08 176.67,59.94 176.43,59.7 PUZ01.33
ALL_SYS_PWRGD: length 171.1
  TOP w0.089: RE42.1 52.88,74.84 v1(52.82,74.91) ; v1(145.16,86.91) v2(145.16,87.51) 145.16,87.93 145.62,88.38 147.94,88.38 148.8,89.24 148.8,90.69 146.66,92.83 v1(146.66,93.72)
  IN1 w0.089: v1(145.16,86.91) 144.47,87.6 144.47,91.12 143.34,92.26 141,92.26 137.9,95.36 136.22,95.36 132.8,98.78 132.8,101.86 123.5,111.16 122.93,111.16 121.64,112.45 120.23,112.45 119.01,113.67 109.66,113.67 109.19,114.15 95.66,114.15 95.19,113.68 85.72,113.68 84.97,114.42 83.66,114.42 82.8,115.29 79.9,115.29 77.72,117.48 66.33,117.48 v1(65.38,116.53)
  IN2 w0.089: v1(65.38,116.53) 65.14,116.28 58.43,116.28 55.88,113.72 52.41,113.72 51.61,112.92 51.61,111.23 52.24,110.6 52.24,106.04 52.49,105.8 52.49,103.42 51.98,102.91 51.98,89.25 54.29,86.94 54.29,79.44 53.81,78.95 53.81,75.9 v1(52.82,74.91)
  BOTTOM w0.089: UC6.4 144.77,89.05 144.97,88.86 144.97,88.5 C35.1 144.39,87.68 v1(145.16,86.91) ; v1(146.66,93.72) 146.93,93.45 RC107.1 RC106.2 RC105.2 147.17,91.86 146.72,92.31 UC7.2
ALWON: length 40.9
  TOP w0.102: UE1.121 36.56,72.21 36.85,71.92 37.45,71.92 v1(37.88,72.35)
  IN3 w0.102: v1(18.58,84.36) 18.58,84.69 18.8,84.92 19.24,84.92 19.67,84.49 19.67,79.6 21.03,78.24 25.85,78.24 26.18,78.57 26.18,78.75 27.41,79.98 29.68,79.98 31.55,78.11 32.53,78.11 34.27,76.37 36.44,76.37 38.27,74.53 38.27,72.74 v1(37.88,72.35)
  BOTTOM w0.089: v2(23.83,87.99) 23.07,87.23 21.87,87.23 PR506.1
  BOTTOM w0.254: PR506.1 20.15,86.77 18.58,85.2 v1(18.58,84.36)
AMBER_LED_BAT: length 77.1
  TOP w0.102: Q18.1 48.36,94.99 47.5,95.85 v2(47.5,96.29) 47.93,96.72 48.62,96.72 v1(48.8,96.53)
  IN1 w0.102: v1(48.8,96.53) 48.8,98.92 46.9,100.82 41.03,100.82 39.72,102.13 32.3,102.13 29.77,104.65 23.57,104.65 21.13,107.09 15.06,107.09 12.49,109.66 12.49,118.45 14.04,120 15.2,120 16.61,121.41 16.61,123.01 19.59,125.99 20.04,125.99 20.89,126.84 20.89,127.39 20.5,127.78 19.15,127.78 17.39,129.54 17.39,130.34 18.27,131.21 18.27,131.51 18.01,131.77 17.87,131.77 v1(17.71,131.61)
  BOTTOM w0.102: R68.2 v1(17.71,131.61)
AUD_AGND: length 65.5
  TOP w0.089: v3(16.11,16.67) 15.71,17.08 RA40.1 ; v1(18.27,15.86) 17.92,15.5 v3(17.61,15.5)
  TOP w0.203: UA1.25 23.33,15.45 v1(22.79,15.98) ; v1(24.77,9.41) 24.77,9.44 24.94,9.61 UA1.38
  TOP w0.508: CA11.2 20.06,18.33 RA41.1 19.34,17.61 v1(18.83,17.61) ; CA23.2 19.69,14.84 19.2,15.34 CA20.1 v1(18.27,15.86) ; v1(22.79,15.98) 22.79,16.14 22.21,16.72 CA10.2 ; RA22.1 25.67,23.59 26.04,23.96 EC2302.1 26.87,23.96 CA42.2 CA36.2 28.04,23.74 28.9,23.74 EC3003.1 ; RA22.1 24.83,22.89 CA37.2 ; RA22.1 24.63,23.59 23.6,22.56 CA26.2 23.55,21.44 23.51,21.4 23.51,21.37 24.08,20.79 v1(24.37,20.79) ; v1(20.45,7.98) CA12.1 CA21.1 v1(20.46,9.19) ; JHP1.7 10,7.31 11.21,6.1 RA18.1 RA17.1 12.89,6.1 14.74,7.96 v3(14.74,8.34) 15.44,9.04 15.44,10.31 v1(15.25,10.5) ; CA7.2 28.84,19.69 v1(28.81,19.67) ; v1(14.24,18.19) 15.02,18.19 15.05,18.17 RA40.1 ; CA41.2 v1(24.43,19.95)
  GND1 w0.203: 8.92,7.23 JHP1.7 ; JHP1.7 11.08,7.9 ; JHP1.7 10,7.23 ; JHP1.7 11.08,7.23 ; JHP1.7 8.92,7.9
  IN1 w0.508: v1(22.79,15.98) 22.79,14.52 23.69,13.62 23.69,11.44 24.77,10.37 v1(24.77,9.41)
  VCC w0.203: JHP1.7 11.08,7.9 ; JHP1.7 10,7.23 ; JHP1.7 8.92,7.9 ; JHP1.7 11.08,7.23 ; JHP1.7 8.92,7.23
  IN3 w0.508: v1(20.45,7.98) 24.08,7.98 24.77,8.66 v1(24.77,9.41)
  GND2 w0.203: 10,7.23 JHP1.7 ; JHP1.7 8.92,7.23 ; JHP1.7 11.08,7.9 ; JHP1.7 11.08,7.23 ; JHP1.7 8.92,7.9
  BOTTOM w0.508: EC2301.1 17.75,8.71 18.94,8.71 v1(19.06,8.59)
  vias: v1(17.31,12.94)
AUD_HP1_JACK_L: length 3.4
  TOP w0.203: RA27.1 20.47,12.78 22.98,12.78 23.12,12.65 UA1.32
AUD_HP1_JACK_L1: length 14.9
  TOP w0.127: v1(18.64,12.94) 18.47,12.94 v2(18.17,13.24)
  TOP w0.305: v1(18.64,12.94) 18.64,12.23 RA36.1 18.92,12.15 RA27.2 RA29.2 ; v1(21.93,21.5) 21.93,20.97 RA28.2
  IN1 w0.305: v1(21.93,21.5) 21.95,21.5 21.59,21.13 21.59,16.84 21.34,16.59 20.42,16.59 17.95,14.12 17.95,13.49 18.5,12.94 v1(18.64,12.94)
AUD_HP1_JACK_R: length 9.5
  TOP w0.127: RA31.1 15.52,12.3 v2(15.12,12.7)
  TOP w0.203: 19.07,11.62 19.57,12.11 20.7,12.11 21.07,12.48 22.86,12.48 23.09,12.25 UA1.33
  TOP w0.254: RA31.1 17.03,11.62 19.07,11.62
AUD_HP1_JACK_R1: length 15.8
  TOP w0.127: v2(15.16,13.99) 15.93,13.22 RA31.2
  TOP w0.305: RA31.2 16.84,13.22 17.26,13.64 RA37.1 17.71,14.46 RA33.2 17.98,14.33 18.61,13.71 v1(18.61,13.57) ; v1(22.52,21.5) 22.52,20.96 RA32.2
  IN1 w0.305: v1(18.61,13.57) 18.61,14.03 20.65,16.08 21.55,16.08 22.52,17.05 v1(22.52,21.5)
AUD_PC_BEEP: length 2.2
  TOP w0.203: CA31.2 28.32,17.87 28.32,17.31 27.74,16.73 UA1.16
AUD_PC_BEEP_C: length 15.9
  TOP w0.089: v2(36.15,10.04) 35.57,10.63 DA3.1 v1(34.45,12.7)
  TOP w0.102: RA23.1 30.75,21.28 v1(30.79,21.32)
  IN3 w0.089: v1(34.45,12.7) 34.88,13.13 34.88,17.23 34.04,18.07 32.92,18.07 30.79,20.19 v1(30.79,21.32)
AUD_SENSE: length 17.6
  TOP w0.102: RA39.1 16.72,19.82 v1(16.87,19.97) ; RA10.1 30.37,17.83 29.65,17.11 v1(29.16,17.11)
  IN2 w0.102: v1(29.16,17.11) 28.89,16.85 20.24,16.85 19.92,17.17 18.21,17.17 16.87,18.51 v1(16.87,19.97)
  BOTTOM w0.089: v2(16.79,19.19) 16.87,19.27 v1(16.87,19.97)
AUD_SENSE_A: length 5.3
  TOP w0.203: RA10.2 29.2,17.61 28.94,17.61 28.71,17.38 28.71,16.9 28.94,16.67 UA1.13
  TOP w0.254: RA10.2 29.29,18.02 29.29,18.58 CA7.1 29.91,18.37 30.84,18.37 31.1,18.11 RA3.1
