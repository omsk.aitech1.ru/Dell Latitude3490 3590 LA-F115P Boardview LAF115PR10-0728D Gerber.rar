# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SNB_VCCSA: length 0.8
  TOP w0.089: 156.96,58.22 156.96,57.67 v2(156.75,57.46)
SNUB1_CHG: length 1.5
  TOP w0.089: PCB36.1 v2(185.73,51.51)
SNUB2_CHG: length 1.7
  TOP w0.089: PCB37.1 190.38,47.15 v2(189.86,47.67)
SNUB_+1.35VGPU: length 0.7
  TOP w0.089: v2(151.29,111.62) 150.96,111.29 150.76,111.29
SNUB_+1VALW: length 1.5
  TOP w0.089: PCH13.1 v3(158.14,47.56)
SOC_XDP_TDI: length 25.2
  TOP w0.102: 138.15,91.5 138.15,84.69 137.96,84.5 v1(137.96,84.24)
  TOP w0.112: RC141.1 126.87,95.23 127.83,94.28 132.31,94.28 132.71,93.88 135.75,93.88 TPC5.1 138.15,91.5
  BOTTOM w0.076: UC1.D59 134.59,83.49 UC1.D60 134.92,84.52 135.09,84.69 135.61,84.69 135.71,84.8 136.76,84.8 136.87,84.69 137.37,84.69 137.83,84.24 v1(137.96,84.24)
SOC_XDP_TDO: length 26.3
  TOP w0.089: v1(137.41,83.81) 137.41,83.53 137.68,83.27 137.68,82.44 v1(138.14,81.97)
  TOP w0.102: 136.55,92.13 137.91,90.77 137.91,85.42 137.95,85.38 137.95,84.76 137.59,84.4 137.59,84.19 137.41,84 v1(137.41,83.81)
  TOP w0.112: RC142.1 125.99,95.1 127.32,93.77 132.12,93.77 132.51,93.38 TPC1.1 135.41,93.38 136.55,92.24 136.55,92.13
  BOTTOM w0.076: UC1.A56 136.63,81.81 137.98,81.81 v1(138.14,81.97) ; v1(137.41,83.81) 137.39,83.83 137.09,83.83 UC1.A61
SOC_XDP_TMS: length 24.4
  TOP w0.102: 138.38,91.51 138.35,91.48 138.35,84.03 v1(137.94,83.62)
  TOP w0.112: RC140.1 127.76,95.1 128.1,94.77 132.52,94.77 132.9,94.39 135.97,94.39 137.89,92.47 TPC4.1 138.38,92.16 138.38,91.51
  BOTTOM w0.076: 136.95,83.42 136.39,83.98 135.73,83.98 UC1.C60
  BOTTOM w0.089: UC1.C59 135.25,83.49 UC1.C60
  BOTTOM w0.102: v1(137.94,83.62) 137.74,83.42 136.95,83.42
SOC_XDP_TRST#: length 3.6
  TOP w0.089: TPC6.1 136.22,83.05 v1(136.22,83.62)
  BOTTOM w0.076: UC1.C61 135.25,83.73 134.93,83.42 134.93,83.09 135.05,82.97 135.61,82.97 UC1.B59 135.9,83.3 v1(136.22,83.62)
SPKR: length 149.5
  TOP w0.089: v1(42.19,46.43) 43.29,45.33 43.29,41.51 41.78,40 37.41,40 36.91,39.51 36.44,39.51 36.23,39.72 36.23,39.94 35.86,40.31 35.56,40.31 35.08,39.83 34.37,39.83 34.2,39.66 33.31,39.66 32.93,39.28 29.7,39.28 28.33,37.9 28.33,36 29.13,35.2 29.13,34.26 29.92,33.47 29.92,30.67 30.78,29.81 30.78,24.19 32.38,22.59 36.37,22.59 38.5,20.46 38.5,17.39 v2(39.33,16.57) 39.97,15.93 39.97,14.4 39.23,13.66 DA3.3 ; v1(104.15,45.79) 104.47,46.11 RC128.2 ; 112.21,52.28 v1(115.86,52.28)
  TOP w0.102: 107.47,47.54 112.21,52.28
  TOP w0.112: 107.47,47.54 106.94,47.54 106.8,47.4 105.17,47.4 104.47,46.71 RC128.2
  IN1 w0.089: v1(55.76,52.15) 55.76,51.85 55.08,51.17 54.56,51.17 52.03,48.64 45.77,48.64 43.56,46.43 v1(42.19,46.43)
  IN1 w0.102: v1(104.15,45.79) 103.61,46.33 100.65,46.33 99.37,45.06 96.55,45.06 96.38,44.89 95.42,43.93 84.9,43.93 83.66,42.69 81.82,42.69 81.47,42.34 77.09,42.34 75.89,41.14 74.43,41.14 74.02,41.55 72.83,41.55 69.43,44.95 67.61,44.95 65.62,46.93 65.25,46.93 65.24,46.93 59.75,46.93 57.36,49.32 57.36,52.6 56.37,53.59 56.37,53.9 v1(55.34,54.94)
  IN3 w0.102: v1(55.34,54.94) 55.1,54.7 55.1,53.49 55.76,52.83 v1(55.76,52.15)
  BOTTOM w0.076: UC1.AW5 116.08,52.28 v1(115.86,52.28)
SRTCRST#: length 50
  TOP w0.112: RC77.1 100.15,43.67 v1(100.15,44.07) 99.94,44.28 98.68,44.28 98.47,44.5 97.94,44.5 97.49,44.05 97.49,42.91 98.57,41.84 98.57,40.6 98.8,40.37 100.08,40.37 100.36,40.09 100.36,39.38 100.14,39.15 99.72,39.15 99.53,38.96 99.53,38.37 101.46,36.44 v2(101.46,36.17) 101.46,35.48 102,34.94 103.04,34.94 103.81,35.71 v1(104.4,35.71)
  IN3 w0.135: v1(100.15,44.07) 100.15,45.76 100.55,46.16 103.88,46.16 103.95,46.23 105.72,46.23 106.31,46.82 106.86,46.82 107.37,47.33 107.37,47.77 109.48,49.89 109.48,51.51 110.53,52.56 110.53,52.76 113.63,55.85 114.13,55.85 114.65,56.37 117.52,56.37 117.75,56.6 117.75,57.59 118.38,58.22 118.95,58.22 118.99,58.27 119.23,58.27 119.43,58.47 119.43,59.02 v1(119.92,59.51)
  BOTTOM w0.102: v1(119.92,59.51) UC1.AN18
  BOTTOM w0.112: v1(104.4,35.71) 104.34,35.71 103.82,35.19 CC4.1
SSD_DEVSLP: length 171.1
  TOP w0.089: v1(136.66,44.68) 137.1,44.24 138.41,44.24 139.83,43.66 140.69,42.8 141.76,41.2 141.76,39.17 143.49,37.44 147.41,37.44 150.45,34.4 150.45,32.9 152.36,30.99 152.36,27.86 v2(152.62,27.59) 153.04,27.18 v1(153.04,26.94)
  IN1 w0.089: v1(125.51,24.9) 125.74,24.67 143.08,24.67 144.04,25.62 151.81,25.62 153.04,26.85 v1(153.04,26.94)
  IN3 w0.102: v1(30.21,28.51) 30.4,28.7 31.45,28.7 31.71,28.44 34.77,28.44 36.36,30.03 37.91,30.03 39.55,31.67 45.7,31.67 48.05,34.02 50.8,34.02 51.31,33.51 53.55,33.51 54.98,32.08 55.64,32.08 56.55,31.17 56.99,31.17 59.06,29.1 64.01,29.1 65.79,27.31 71.79,27.31 72.28,26.82 72.28,24.42 121.2,24.42 121.69,24.9 v1(125.51,24.9)
  BOTTOM w0.102: JSSD1.38 30.13,28.42 v1(30.21,28.51) ; UC1.J3 131.98,51.29 132.08,51.19 132.08,50.84
  BOTTOM w0.112: v1(136.66,44.68) 135.07,46.28 135.07,47.29 134.69,47.68 134.69,48.14 133.38,49.44 133.38,49.46 133.33,49.51 133.21,49.51 133.2,49.51 132.85,49.51 132.37,50 132.26,50 132.08,50.18 132.08,50.84
SUSCLK: length 34.3
  TOP w0.112: v1(101.99,41.84) 102.14,41.84 RC110.1 102.98,42.21 102.98,41.97 v2(103.44,41.51)
  BOTTOM w0.076: 104.64,54.79 105.69,55.85 105.69,56.02 107.94,58.27 110.33,58.27 110.88,58.81 112.53,58.81 113.19,59.47 114.3,59.47 UC1.BA17
  BOTTOM w0.112: 104.64,54.79 103.92,54.07 102.81,54.07 101.42,52.68 101.42,46.8 99.57,44.95 99.57,43.62 100.49,42.71 101.56,42.71 101.99,42.27 v1(101.99,41.84) 101.96,41.84 101.54,41.42 RC75.2 RC74.2
SUSCLK_EC: length 106.7
  TOP w0.112: RE45.2 33.09,67.6 33.45,67.24 v1(33.77,67.24)
  BOTTOM w0.112: v1(33.77,67.24) 33.77,64.78 34.27,64.27 34.27,63.58 34.91,62.95 34.91,61.25 35.37,60.79 35.37,58.95 36.09,58.22 36.09,57.69 36.71,57.07 38.14,57.07 39.63,55.58 39.63,44.96 40.78,43.81 42.76,43.81 43.83,42.75 43.83,40.02 47.96,35.88 v2(52.84,35.88) 54.24,35.88 55.42,34.71 57.42,34.71 59.18,32.94 68.18,32.94 68.91,32.21 71.46,32.21 76.41,27.26 93.98,27.26 95.02,28.31 95.02,29.33 95.34,29.65 95.34,32.93 96.1,33.69 96.1,34.92 96.67,35.49 96.67,36.63 97.14,37.1 99.58,37.1 100.34,37.85 100.58,37.85 100.96,38.24 100.96,38.57 101.54,39.14 RC75.1
SUSCLK_WLAN: length 168.7
  IN1 w0.119: v1(52.75,73.87) 53.63,72.99 53.63,70.93 53.14,70.43 53.14,67.78 54.8,66.12 54.8,63.36 53.4,61.96 v1(51.94,61.96)
  IN3 w0.135: v1(58.89,113.65) 58.09,113.65 57.05,112.61 57.05,110.15 54.92,108.02 54.92,86.68 51.96,83.71 51.96,81.07 52.42,80.6 52.97,80.6 53.6,79.97 53.6,78.09 54.15,77.54 54.15,75.53 52.75,74.14 v1(52.75,73.87)
  BOTTOM w0.112: v1(58.89,113.65) 58.92,113.68 71.98,113.68 74.08,115.78 74.08,117.08 72.79,118.36 72.79,121.66 72.44,122.01 72.44,127.25 73.06,127.88 73.06,132.39 72.55,132.9 JWLAN1.50 ; RC74.1 100.54,38.97 100.54,38.65 99.41,37.51 95.68,37.51 95.42,37.77 93.91,37.77 93,36.85 93,36.3 92.67,35.98 91.58,35.98 91.02,36.54 91.02,37.19 89.68,38.53 82.48,38.53 80.04,36.09 76.69,36.09 74.99,37.79 72.41,37.79 70.73,39.47 68.75,39.47 68.31,39.91 61.97,39.91 61.79,40.09 58.34,40.09 55.13,43.3 55.13,45.81 51.94,48.99 v1(51.94,61.96)
SVI2_SVC: length 54.6
  TOP w0.102: PUV01.3 71.07,130.7 70.46,131.31 v1(70.34,131.31)
  IN1 w0.089: v1(106.93,127.05) 104.55,127.05 103.18,125.68 103.18,121.78 102.16,120.76 92.47,120.76 91.91,121.32 90.44,121.32 89.68,120.56 87.99,120.56 87.73,120.83 84.06,120.83 81.5,123.39 80.51,123.39 79.55,124.36 79.19,124.36 76.77,126.77 72.12,126.77 69.95,128.94 69.95,130.98 70.28,131.31 v1(70.34,131.31)
  BOTTOM w0.102: v1(106.93,127.05) 107.48,126.5 108.35,126.5 RV84.1 RV89.2 RV157.2
SVI2_SVD: length 55.7
  TOP w0.102: v1(70.32,130.73) 70.33,130.73 70.33,130.73 71.16,129.9 PUV01.5
  IN1 w0.089: v1(70.32,130.73) 70.72,130.33 70.72,128.69 72.27,127.14 76.92,127.14 79.34,124.72 79.7,124.72 80.67,123.76 81.65,123.76 84.22,121.19 87.88,121.19 88.14,120.93 89.53,120.93 90.29,121.69 92.06,121.69 92.62,121.13 102.01,121.13 102.81,121.93 102.81,125.83 104.39,127.41 104.55,127.41 105.04,127.41 107.71,130.08 v1(108.64,130.08)
  BOTTOM w0.089: v2(108.84,130.73) 108.64,130.53 v1(108.64,130.08)
  BOTTOM w0.102: v2(108.84,130.73) 109.19,130.73 RV155.2 ; RV87.1 108.94,128.91 RV88.2 108.94,129.21 108.64,129.51 v1(108.64,130.08)
SVI2_SVT: length 51.3
  TOP w0.102: PUV01.7 70.59,129.1 v1(70.34,129.34)
  IN1 w0.089: v1(70.34,129.34) 70.34,128.81 72.2,126.96 76.85,126.96 79.26,124.54 79.62,124.54 80.59,123.57 81.57,123.57 84.14,121.01 87.8,121.01 88.07,120.75 89.6,120.75 90.36,121.51 91.98,121.51 92.54,120.95 102.08,120.95 102.99,121.86 102.99,125.75 104.47,127.23 105.12,127.23 106.96,129.07 108.61,129.07 v1(109.2,129.65)
  BOTTOM w0.102: v1(109.2,129.65) 109.4,129.65 RV156.2
SW_USB_PN1: length 11.7
  TOP w0.102: 33.14,50.42 33.03,50.31 UU2.11
  TOP w0.112: RU2.1 32.95,51.8 LU1.3 32.95,51.55 33.09,51.41 33.09,51.04 v1(32.96,50.91) 33.14,50.72 33.14,50.42 ; v1(33.19,43.51) 33.38,43.69 33.38,43.93 RU22.2
  IN1 w0.119: v1(33.19,43.51) 33.19,44.77 33.94,45.52 33.94,46.66 34.41,47.13 34.41,49.17 33.21,50.37 33.21,50.65 v1(32.96,50.91)
SW_USB_PP1: length 11.9
  TOP w0.112: RU1.1 33.45,51.84 LU1.2 33.45,51.59 33.31,51.45 33.31,51.14 v1(33.54,50.91) 33.36,50.72 33.36,50.5 33.53,50.34 UU2.10 ; v1(33.78,43.51) 33.6,43.69 33.6,43.91 RU21.2
  IN1 w0.119: v1(33.78,43.51) 33.78,43.85 33.68,43.95 33.51,43.95 33.41,44.05 33.41,44.68 34.16,45.43 34.16,46.57 34.63,47.04 34.63,49.26 33.43,50.46 33.43,50.79 v1(33.54,50.91)
SYS_LED_MASK#: length 114.9
  TOP w0.089: v1(41.45,93.99) 41.45,94.01 41.46,94.03 41.46,95 U4.1 ; RE81.2 52.7,63.86 v1(52.73,63.89) ; v1(43.15,95.89) 43.49,95.55 R71.1 ; v1(94.47,41.33) 94.47,41.91 v2(94.12,42.26)
  IN1 w0.089: v1(45.91,77.31) 46.37,77.78 v1(49.62,77.78)
  IN2 w0.089: v1(94.47,41.33) 93.47,41.33 93.18,41.63 92.31,41.63 91.88,42.06 82.6,42.06 81.61,41.07 81.61,40.63 79.28,38.29 73.44,38.29 72.95,37.8 71.13,37.8 70.69,38.24 61.68,38.24 58.43,41.49 56.52,41.49 53.37,44.64 53.37,48.1 52.75,48.71 52.75,50.64 52.09,51.31 52.09,56.31 51.66,56.74 51.66,60.4 52.86,61.6 52.86,63.76 v1(52.73,63.89) 51.92,64.69 51.92,65.37 51.86,65.43 51.86,68.49 50.76,69.59 50.76,71.64 50.48,71.92 50.48,76.92 v1(49.62,77.78) ; v1(45.91,77.31) 45.76,77.46 45.76,86.36 44.81,87.32 44.4,87.32 41.83,89.88 41.83,92.8 41.45,93.19 v1(41.45,93.99) 41.45,95.11 41.78,95.44 42.7,95.44 v1(43.15,95.89)
  BOTTOM w0.089: v1(94.47,41.33) 94.47,40.89 93.28,39.7 RE540.2
SYS_PWROK: length 142.7
  TOP w0.089: v3(130.14,37.98) 130.15,37.99 v1(130.81,37.99)
  TOP w0.102: RE68.1 50.26,65.15 50.03,65.38 48.36,65.38 47.84,65.9 47.84,66.65 48.15,66.96 UE1.28 48.15,69 v1(47.98,69.17)
  IN2 w0.089: v1(130.81,37.99) 130.66,37.99 129.85,37.18 128.9,37.18 128.48,36.76 125.19,36.76 124.58,37.37 121.9,37.37 120.95,36.42 115.12,36.42 114.66,35.95 110.54,35.95 109.91,35.32 107.09,35.32 106.35,34.58 101.07,34.58 100.6,35.05 96.81,35.05 96.75,35.1 88.48,35.1 86.76,36.82 85.25,36.82 84.61,36.18 84.4,36.18 83.12,34.9 82.42,34.9 81.89,34.37 76.28,34.37 75.82,33.91 72.09,33.91 71.6,34.4 68.64,34.4 68.52,34.28 61.98,34.28 57.37,38.89 54.2,38.89 50.79,42.31 50.79,45.61 49.57,46.84 49.57,52.35 49.74,52.53 49.74,57.07 49.29,57.52 49.29,58.5 49.67,58.88 49.67,63.84 49.67,67.08 47.98,68.77 v1(47.98,69.17)
  IN3 w0.135: v1(130.81,37.99) 130.81,38.47 132.91,40.57 132.91,41.79 133.67,42.55 133.67,45.38 134.17,45.87 135.99,45.87 136.9,46.77 v1(136.9,50.39)
  BOTTOM w0.102: UC1.B6 135.84,52.57 135.99,52.57 136.22,52.35 136.22,50.77 136.6,50.39 v1(136.9,50.39)
SYS_RESET#: length 7.3
  TOP w0.089: v1(138.65,50.02) 138.67,50.01 138.67,50 TPS1.1
  BOTTOM w0.089: UC1.B5 135.9,51.61 135.59,51.31 135.59,50.95 135.75,50.8 135.75,50.35 135.93,50.16 136.46,50.16 136.6,50.02
  BOTTOM w0.102: 136.6,50.02 137.05,50.02
  BOTTOM w0.112: v1(138.65,50.02) 137.05,50.02 137.05,50.02
  BOTTOM w0.127: RC86.2 139.76,48.92 v1(138.65,50.02)
SYSPWR_PRES: length 7.3
  TOP w0.102: UE1.120 v2(33.46,72.61) 33.31,72.75 RE32.1 32.09,73.65 32.08,73.66 ; 32.08,73.66 RE29.1 ; 32.08,73.66 31.61,73.19 29.97,73.19 RE88.1
T_CRIT#: length 3.1
  BOTTOM w0.089: R29.2 179.54,60.03 180.17,60.03 v2(180.39,60.24) 180.39,60.78 U2.4
TESTEN: length 7
  TOP w0.102: v1(129.36,125.37) 129.61,125.37 129.92,125.06 v3(129.92,124.77) 129.92,124.38 129.26,123.72 129.26,121.72 128.99,121.45 128.35,121.45 RV17.2 128.17,121.62 RV154.2
  BOTTOM w0.102: UV1.K7 v1(129.36,125.37)
THM_SML1_CLK: length 15.7
  TOP w0.112: Q11.4 183.56,67.47 183.69,67.6 R49.2 184.32,68.05 184.95,67.42 v2(184.95,66.94) 184.95,66.43 185.14,66.24 185.49,66.24 v1(185.69,66.44)
  BOTTOM w0.112: v1(185.69,66.44) 185.69,66.37 185.59,66.27 185.07,66.27 184.71,65.91 184.71,65.35 184.48,65.12 184.48,63.8 184.18,63.51 182.91,63.51 181.4,65.02 178.63,65.02 178.51,65.15 178.51,65.42 U2.8
THM_SML1_DATA: length 17.5
  TOP w0.112: v1(185.69,65.86) 185.55,66 185.25,66 184.87,65.62 v2(184.87,65.24) 184.83,65.2 184.83,64.79 184.64,64.6 182.67,64.6 182.19,64.11 R48.2 181.96,64.29 181.96,64.46 182.26,64.76 Q11.1
  BOTTOM w0.112: v1(185.69,65.86) 185.69,65.91 185.57,66.03 185.17,66.03 184.95,65.81 184.95,65.25 184.72,65.02 184.72,63.7 184.28,63.27 182.81,63.27 181.3,64.78 178.54,64.78 178.39,64.93 178.08,64.93 U2.7
TON_1.2V: length 2
  TOP w0.203: PUM01.9 34.72,28.41 33.78,27.47 PRM07.2
TOP_MUX_N: length 4.5
  BOTTOM w0.112: RT55.1 25.93,131.74 LT3.2 26.25,131.74 26.53,132.02 26.92,132.02 27.18,132.28 27.19,132.28 27.56,132.64 28.45,132.64 28.69,132.4 28.69,131.88 28.62,131.81 UT3.17
TOP_MUX_N_R: length 26.5
  TOP w0.112: JUSBC1.A7 7.35,120.83 8.18,120.83 9.37,122.02 9.58,122.02 9.7,121.9 v1(9.7,121.9)
  IN1 w0.119: v1(9.7,121.9) 9.89,122.08 10.05,122.08 10.33,121.8 10.88,121.8 11.65,122.57 11.65,128.33 14.15,130.83 15,130.83 v1(15.19,130.64)
  BOTTOM w0.112: v1(15.19,130.64) 15.42,130.87 18.43,130.87 18.82,131.27 19.24,131.27 19.65,130.86 EU4001.2 EU4001.8 22.01,130.86 22.4,131.26 23.07,131.26 23.76,131.94 24.13,131.94 24.33,131.74 LT3.1 24.84,131.61 RT55.2
TOP_MUX_P: length 4.8
  BOTTOM w0.112: UT3.18 29.02,131.82 28.91,131.92 28.91,132.49 28.54,132.86 27.47,132.86 27.25,132.64 v4(27.24,132.65) 26.83,132.24 LT3.3 25.8,132.41 RT56.1
TOP_MUX_P_R: length 26.4
  TOP w0.112: v1(9.7,122.48) 9.46,122.24 9.28,122.24 8.28,121.24 8.12,121.24 8.03,121.32 8,121.32 JUSBC1.A6
  IN1 w0.119: v1(9.7,122.48) 9.89,122.3 10.14,122.3 10.42,122.02 10.79,122.02 11.44,122.66 11.44,128.42 14.06,131.05 15,131.05 v1(15.19,131.23)
  BOTTOM w0.112: v1(15.19,131.23) 15.32,131.09 18.34,131.09 18.73,131.49 19.26,131.49 19.63,131.86 EU4001.4 EU4001.7 22.06,131.86 22.44,131.48 22.96,131.48 v4(23.27,131.79) 23.65,132.16 24.19,132.16 24.27,132.24 LT3.4 24.88,132.41 RT56.2
TOUCH_PAD_INTR#: length 8.9
  TOP w0.102: v1(110.46,47.49) v2(110.46,48.85) 110.46,49.01 v1(111.15,49.7)
  BOTTOM w0.076: 113.64,52.21 113.7,52.27 114.07,52.27 114.39,52.59 UC1.BA5
  BOTTOM w0.102: v1(110.46,47.49) 110.16,47.49 DZ3.2
  BOTTOM w0.112: 113.64,52.21 113.14,52.21 111.15,50.22 v1(111.15,49.7) RC114.2
TOUCH_PANEL_PD#: length 7.8
  TOP w0.089: v1(113.14,51.54) 112.96,51.54 v2(112.62,51.2)
  BOTTOM w0.076: RC118.2 111.01,48.87 111.57,49.43 111.57,50.22 112.88,51.54 v1(113.14,51.54) 113.63,52.02 113.71,52.02 113.73,52.05 114.08,52.05 114.34,52.31 114.88,52.31 115.21,52.64 UC1.AY5
TOUCH_SCREEN_PD#: length 135.7
  TOP w0.089: v1(147.23,36.21) 147.28,36.17 147.28,35.9 147.21,35.83 v2(144.84,35.83) 144.77,35.91 136.5,35.91 136.26,36.14 135.64,36.14 134.5,37.28 134.35,37.46 133.76,38.32 133.35,39.66 133.35,44.46 132.54,45.26 129.78,45.26 128.62,44.1 127.55,44.1 127.26,43.81 127.26,43.13 126.41,42.27 126.41,41.68 126.13,41.41 124.3,41.41 123.38,40.48 122.14,40.48 121.88,40.75 121.03,40.75 120.83,40.95 120.83,43.2 120.06,43.97 120.06,44.3 119.67,44.69 119.65,44.69 119.63,44.7 119.62,44.7 119.6,44.72 117.61,44.72 116.16,46.17 116.16,47.7 115.87,47.99 113.56,47.99 113.47,47.9 113.47,47.45 112.93,46.9 v1(112.9,46.9)
  TOP w0.102: v1(214.11,40.7) 214.49,40.7 215.43,41.64 D5.2 214.4,42.66 R19.2
  IN1 w0.102: v1(214.11,40.7) 214.11,40.67 213.44,40.01 213.44,39.44 213.09,39.09 210.41,39.09 209.52,38.2 204.96,38.2 204.72,37.96 197.82,37.96 197.24,38.54 192.34,38.54 191.73,37.93 191.62,37.82 186.95,37.82 186.57,38.2 177.81,38.2 177.52,37.91 173.99,37.91 173.01,36.93 164.8,36.93 164.33,37.39 160.04,37.39 158.72,36.07 156.43,36.07 154.38,34.02 153.84,34.02 152.5,32.67 151.82,32.67 151.6,32.9 151.6,35.07 150.71,35.96 147.48,35.96 v1(147.23,36.21)
  BOTTOM w0.102: v1(112.9,46.9) 112.6,46.6 110.82,46.6 110.66,46.76 110.66,47.13 110.85,47.32 110.85,47.76 110.16,48.45 109.95,48.45 RC118.1 109.48,48.82 108.75,48.82 RC115.2
TP_EN: length 4.2
  TOP w0.089: v2(211.59,41.74) 211.9,41.43 C16.1 213.07,40.99 v1(213.37,40.99) 213.65,40.99 R19.1
  BOTTOM w0.102: v1(213.37,40.99) 213.19,40.99 212.73,41.45 JEDP1.39
TP_EN#: length 178.4
  TOP w0.089: v1(40.34,74.71) 44,74.71 45.56,76.27 49.65,76.27 50.12,75.81 UE1.49
  TOP w0.102: R38.1 133.77,30.86 v2(133.77,30.21) 133.77,29.2 v1(134.57,28.4)
  IN1 w0.089: v1(23.74,57.4) 24.58,58.24 24.58,61.87 v1(23.73,62.72)
  IN3 w0.089: v1(40.34,74.71) 40.34,73.63 39.75,73.04 39.75,68.81 37.78,66.84 37.11,66.84 36.23,65.96 33.02,65.96 31.59,67.39 29.8,67.39 29.4,66.99 29.4,64.26 27.95,62.81 23.82,62.81 v1(23.73,62.72)
  IN3 w0.102: v1(134.57,28.4) 134.57,27.52 134.15,27.1 132.14,27.1 131.25,26.21 117.25,26.21 116.6,26.85 113.93,26.85 113.59,26.51 113,26.51 112.28,25.79 98.05,25.79 97.77,26.07 97.28,26.56 93.96,26.56 93.11,25.71 74.58,25.71 72.52,27.78 66.11,27.78 63.72,30.16 59.04,30.16 57.3,31.91 57,31.91 54.62,34.29 51.59,34.29 49.39,36.49 48.9,36.49 44,41.39 44,42.53 42.94,43.59 42.94,45.42 43.2,45.68 43.2,46.81 40.23,49.78 36.92,49.78 34.59,52.1 34.08,52.1 30.13,56.05 25.09,56.05 v1(23.74,57.4)
TP_LOCK#: length 19.6
  BOTTOM w0.089: JTP1.3 123.05,31.4 122.31,32.14 119.7,32.14 119.21,32.63 119.19,32.63 118.93,32.89 118.93,33.32 R41.2 118.89,33.65 118.64,33.9 117.55,33.9 117.17,33.52 117.17,32.8 116.51,32.14 116.51,31.75 115.76,31 115.76,29.88 114.77,28.89 113.65,28.89 113.19,28.43 113.19,27.49 112.86,27.16 112.86,26.51 v2(112.5,26.15) 111.95,26.15 D6.2
TP_WAKE_KBC#: length 148.2
  TOP w0.089: v1(113.41,33.96) 113.67,33.7 113.67,32.25 112.34,30.92 111.97,30.56 111.51,30.56 110.94,29.98 110.94,29.52 110.52,29.1 108.07,29.1 106.76,27.8 105.7,27.8 105.19,27.29 v1(105.19,26.89) ; RE14.1 53.36,67.46 51.47,67.46 v1(49.96,68.97)
  TOP w0.102: v1(113.43,26.89) 113.85,26.48 v2(113.85,25.89) 113.85,25.13 114.3,24.68 118.4,24.68 119.36,25.64 120.88,25.64 121.4,25.13 121.4,24.96 121.7,24.66 123.01,24.66 123.2,24.85 124.25,24.85 124.58,25.18 Q9.1 ; UE1.33 50.4,69.41 v1(49.96,68.97)
  IN2 w0.089: v1(105.19,26.89) 105.56,27.26 113.07,27.26 v1(113.43,26.89)
  IN3 w0.102: v1(49.96,68.97) 50.28,68.97 51.11,68.13 51.11,63.17 50.59,62.65 50.59,61.58 51.07,61.09 51.07,59.06 52.01,58.12 52.01,57.15 52.87,56.29 52.87,52.59 53.99,51.47 53.99,48.99 54.69,48.29 54.69,46.94 56.35,45.29 56.35,43.62 56.86,43.1 57.77,43.1 59.96,40.92 60.38,40.92 61.4,39.9 68.15,39.9 68.86,39.19 70.69,39.19 71.75,38.14 74.64,38.14 74.73,38.22 81.41,38.22 82.72,39.53 88.26,39.53 89.04,40.31 92.89,40.31 93.45,39.75 95.45,39.75 95.67,39.97 97.52,39.97 97.61,40.05 99.08,40.05 99.69,39.45 103.54,39.45 105.27,41.17 105.27,44.21 106.63,45.57 v1(107.05,45.57)
  BOTTOM w0.089: 107.82,46.85 108.01,47.05 108.01,47.57 108.23,47.79 DZ3.1 ; v1(113.41,33.96) 113.41,34.4 112.74,35.07 111.36,35.07 108.59,37.84 108.59,41.42 108.3,41.71 108.3,44.75 107.98,45.06 107.98,45.35 107.76,45.57 v1(107.05,45.57)
  BOTTOM w0.102: v1(107.05,45.57) 107.05,46.08 107.82,46.85
TPM_ID: length 16.8
  BOTTOM w0.076: 137.16,54.78 136.88,55.06 136.33,55.06 136.24,54.97 135.18,54.97 134.92,54.71 UC1.D8
  BOTTOM w0.102: 137.57,54.12 137.16,54.52 137.16,54.78 ; RC63.2 RC64.1
  BOTTOM w0.112: RC64.1 145.67,49.52 v2(145.67,50.12) 145.67,50.65 144.42,51.91 142.45,51.91 141.93,52.43 139.39,52.43 139.19,52.63 138.53,52.63 137.57,53.6 137.57,54.12
TPM_SPI_IRQ#: length 38.6
  IN2 w0.089: v1(130.88,37.01) 130.39,36.52 129.17,36.52 128.75,36.1 123.89,36.1 123.3,36.7 122.16,36.7 121.2,35.74 115.75,35.74 v1(115.45,35.44)
  IN3 w0.102: v1(134.19,45.3) 134.19,45.03 133.99,44.84 133.99,42.41 133.24,41.66 133.24,40.44 132.22,39.42 132.22,38.75 130.92,37.45 130.92,37.05 v1(130.88,37.01)
  BOTTOM w0.076: 132.35,48.72 132.35,48.75 131.99,49.1 131.88,49.1 131.78,49.21 130.63,49.21 129.97,49.87 129.97,50.23 UC1.M2
  BOTTOM w0.102: v1(134.19,45.3) 134.19,45.45 133.48,46.16 133.48,47.49 132.35,48.63 132.35,48.72 ; v1(115.45,35.44) 114.54,34.53 114.54,33.98 RX4.2 114.17,33.59 113.05,32.47 UX1.18
TSENSE_1PH_CPU: length 3.8
  BOTTOM w0.203: PRZ63.1 170.17,57.15 PCZ36.1 170.17,58.11 170.68,58.62 v2(171.19,58.62) 171.45,58.36 171.45,58.25 172,57.7 PUZ01.23
TSENSE_1PH_CPU_R: length 58.2
  TOP w0.089: v1(157.39,97.34) v2(156.73,97.34)
  IN2 w0.254: v1(157.39,97.34) 157.6,97.13 157.6,95.74 157.86,95.47 159.03,95.47 160.35,96.79 164.91,96.79 168.35,93.36 168.63,88.93 168.63,88.82 168.63,88.81 168.63,87.12 168.37,86.86 168.37,83.12 169.53,81.96 169.53,72.22 169.74,72.01 171.1,70.65 171.1,70.64 171.97,69.77 171.97,63.3 169.8,61.13 169.8,55.7 v1(169.9,55.6)
  BOTTOM w0.254: v1(157.39,97.34) 157.2,97.15 PHZ05.1 ; v1(169.9,55.6) 169.55,55.6 169.29,55.86 PRZ65.1 PRZ63.2
TSENSE_2PH_CPU: length 4.4
  TOP w0.089: PRZ34.2 172.71,51.96 v2(171.83,51.07)
  TOP w0.254: PRZ34.2 173,52.32 PCZ22.1 173.69,51.87 v1(173.48,51.67)
  BOTTOM w0.203: PUZ01.11 173.63,51.81 v1(173.48,51.67)
TSENSE_2PH_CPU_R: length 5.7
  TOP w0.089: v1(169.99,50.36) 169.44,50.36 v2(169.33,50.48)
  TOP w0.254: v1(169.99,50.36) 170.81,50.36 171.31,50.86 171.31,51.53 PRZ34.1 PRZ36.1
  BOTTOM w0.254: PHZ04.1 170.32,49.64 169.99,49.97 v1(169.99,50.36)
TX_P80DATA: length 15.6
  BOTTOM w0.089: RW6.2 67.89,117.61 v2(67.34,117.61)
  BOTTOM w0.254: JWLAN1.38 69.61,129.9 68.52,128.8 68.52,124.35 68.07,123.91 68.07,118.27 RW6.2
TYPEC_DP_AUXN: length 25.3
  TOP w0.112: RT117.2 32.24,106.18 32.41,106.18 32.6,105.99 32.89,105.99 33.11,105.76 v1(33.13,105.76) 33.13,105.94 33.42,106.23 33.85,106.23 33.91,106.17 UT5.29
  BOTTOM w0.112: CT33.1 18.41,115.36 18.8,114.98 21.72,114.98 22.66,114.04 25.15,114.04 25.17,114.02 25.8,114.02 25.81,114.04 28.34,114.04 30.15,112.22 30.15,110.66 31.96,108.86 31.96,106.01 32.2,105.76 v1(33.13,105.76)
TYPEC_DP_AUXN_C: length 38.5
  TOP w0.112: CT90.1 18.75,117.59 18.75,118.05 v1(18.58,118.22) ; v1(32.19,105.27) 31.97,105.04 31.97,104.77 RT97.2
  IN1 w0.119: v1(18.58,118.22) 18.76,118.04 18.76,117.86 18.55,117.65 15.35,117.65 13.86,116.16 13.86,110.13 14.56,109.43 15.67,109.43 17.39,107.7 21.38,107.7 23.82,105.26 30.09,105.26 30.94,104.41 31.6,104.41 32.01,104.82 32.01,105.08 v1(32.19,105.27)
  BOTTOM w0.112: CT90.1 18.74,117.58 18.74,118.06 v1(18.58,118.22) 18.77,118.41 18.77,118.56 19.08,118.87 19.32,118.87 19.43,118.98 19.43,119.15 19.36,119.23 UT2.25
TYPEC_DP_AUXP: length 25.2
  TOP w0.112: RT116.2 32.32,106.4 32.5,106.4 32.69,106.21 32.81,106.21 v1(33.11,106.51) 33.17,106.46 33.75,106.46 33.87,106.57 UT5.28
  BOTTOM w0.112: CT32.1 18.63,115.67 18.63,115.45 18.89,115.2 21.81,115.2 22.75,114.26 v4(25.5,114.26) 28.43,114.26 30.37,112.31 30.37,110.75 32.18,108.95 32.18,106.1 32.29,105.98 32.63,105.98 32.75,106.1 32.75,106.14 v1(33.11,106.51)
TYPEC_DP_AUXP_C: length 37.8
  TOP w0.112: v1(19.16,118.22) 18.97,118.03 18.97,117.58 CT89.1 ; RT94.2 31.75,104.78 31.75,105.13 v1(31.61,105.27)
  IN1 w0.119: v1(19.16,118.22) 18.98,118.04 18.98,117.77 18.64,117.43 15.44,117.43 14.08,116.07 14.08,110.22 14.65,109.65 15.76,109.65 17.48,107.92 21.47,107.92 23.91,105.48 30.18,105.48 31.03,104.63 31.51,104.63 31.79,104.91 31.79,105.08 v1(31.61,105.27)
  BOTTOM w0.112: UT2.24 19.76,119.23 19.66,119.12 19.66,118.89 19.41,118.65 19.17,118.65 18.99,118.47 18.99,118.38 19.14,118.22 v1(19.16,118.22) 18.96,118.02 18.96,117.6 CT89.1
TYPEC_DP_N0: length 42.7
  TOP w0.112: UT5.39 38.34,104.6 38.52,104.42 38.81,104.14 39.15,104.14 39.55,103.74 39.55,103.52 39.36,103.32 v1(39.33,103.32)
  IN1 w0.119: v1(26.16,126.58) 26.36,126.79 26.72,126.79 28.39,125.11 28.39,117.69 28.1,117.4 27.12,117.4 26.19,116.47 26.19,114.29 25.21,113.31 25.21,110.86 25.61,110.46 29.49,110.46 30.7,109.25 35.88,109.25 36.32,108.82 36.32,108.48 37.45,107.35 37.45,105.53 38.66,104.31 39.25,104.31 39.59,103.97 39.59,103.58 v1(39.33,103.32)
  BOTTOM w0.112: v1(26.16,126.58) 25.92,126.82 24.94,126.82 CT25.2
TYPEC_DP_N0_C: length 5.3
  TOP w0.112: v1(23.05,126.5) 23.22,126.67 23.61,126.67 CT82.1
  BOTTOM w0.112: UT2.10 21.93,124.46 22.04,124.57 22.21,124.57 22.53,124.89 v4(22.53,125.67) 22.53,126.45 22.73,126.64 22.9,126.64 v1(23.05,126.5) 23.29,126.75 23.45,126.75 CT25.1
TYPEC_DP_N1: length 37.6
  TOP w0.112: v1(37.55,103.37) 37.75,103.57 37.75,103.66 37.23,104.18 37.23,104.46 37.14,104.55 UT5.36
  IN1 w0.119: v1(37.55,103.37) 37.81,103.64 37.81,104.2 36.23,105.78 36.23,107.44 35.62,108.05 34.28,108.05 33.72,108.61 30.43,108.61 29.23,109.81 25.35,109.81 24.57,110.59 24.57,113.58 25.55,114.56 25.55,116.74 27.27,118.46 27.27,122.69 27.55,122.97 27.55,124.12 27.18,124.49 26.66,124.49 26.56,124.39 26.56,124.39 v1(26.39,124.23)
  BOTTOM w0.112: v1(26.39,124.23) 26.2,124.41 26,124.41 25.77,124.18 25.42,124.18 CT27.2
TYPEC_DP_N1_C: length 4.1
  TOP w0.112: v1(23.4,123.82) 23.63,124.05 23.99,124.05 CT84.1
  BOTTOM w0.112: UT2.13 22.01,123.26 22.08,123.33 22.41,123.33 23.07,123.99 23.23,123.99 v1(23.4,123.82) 23.69,124.11 23.92,124.11 CT84.1
TYPEC_DP_N2: length 32.6
  TOP w0.112: UT5.34 36.34,104.6 36.43,104.51 36.43,103.83 36.32,103.72 36.32,103.51 v1(36.11,103.31)
  IN1 w0.119: v1(36.11,103.31) 36.3,103.49 36.3,103.8 34.72,105.38 34.72,106.57 33.32,107.97 30.17,107.97 28.97,109.17 28.81,109.17 25.09,109.17 23.93,110.32 23.93,113.85 24.91,114.83 24.91,117.01 26.63,118.73 26.63,120.97 26.49,121.1 26.36,121.1 v1(26.15,120.9)
  BOTTOM w0.112: CT29.2 24.75,121.4 25.06,121.71 25.21,121.71 25.66,121.26 25.79,121.26 v1(26.15,120.9)
TYPEC_DP_N2_C: length 3.5
  TOP w0.112: v1(22.83,121.92) 23.03,122.11 23.18,122.11 CT86.1
  BOTTOM w0.112: CT29.1 23.28,121.85 22.89,121.85 v1(22.83,121.92) 22.69,122.06 UT2.16
TYPEC_DP_N3: length 33.9
  TOP w0.112: v1(34.03,103.94) 34.03,103.94 34.34,103.63 34.59,103.63 v4(34.81,103.86) 35.21,104.26 35.21,104.52 35.14,104.59 UT5.31
  IN1 w0.119: v1(26.16,119.73) 26.05,119.62 25.84,119.62 25.74,119.72 25.74,120.04 25.66,120.12 24.96,120.12 24.48,119.64 24.48,115 23.5,114.02 23.5,108.42 24.89,107.03 29.1,107.03 29.54,107.48 33.14,107.48 34.03,106.59 34.03,105.06 33.31,104.34 33.31,103.75 33.48,103.58 33.66,103.58 34.03,103.94 v1(34.03,103.94)
  BOTTOM w0.112: v1(26.16,119.73) 25.86,120.02 25.28,120.02 25.17,119.91 25.17,119.67 25,119.5 CT31.2
TYPEC_DP_N3_C: length 4.1
  TOP w0.112: v1(22.87,119.77) 23.01,119.92 23.22,119.92 CT88.1
  BOTTOM w0.112: UT2.19 22.17,120.86 22.25,120.78 22.25,120.22 22.49,119.99 22.66,119.99 v1(22.87,119.77) 22.99,119.9 23.42,119.9 CT31.1
TYPEC_DP_P0: length 42.8
  TOP w0.112: UT5.40 38.74,104.52 38.86,104.39 39.21,104.39 39.77,103.83 39.77,103.46 v1(39.91,103.32)
  IN1 w0.119: v1(39.91,103.32) 39.81,103.43 39.81,104.07 39.34,104.53 38.75,104.53 37.66,105.62 37.66,107.44 36.53,108.57 36.53,108.91 35.97,109.47 30.79,109.47 29.58,110.68 25.7,110.68 25.43,110.95 25.43,113.22 26.41,114.2 26.41,116.38 27.21,117.18 28.19,117.18 28.61,117.6 28.61,125.21 26.81,127.01 26.32,127.01 26.16,127.17 v1(26.16,127.17)
  BOTTOM w0.112: CT24.2 24.98,127.04 26.03,127.04 v1(26.16,127.17)
TYPEC_DP_P0_C: length 5.3
  TOP w0.112: v1(23.05,127.08) 23.21,126.92 23.72,126.92 CT81.1
  BOTTOM w0.112: UT2.9 21.93,124.86 22.01,124.79 22.12,124.79 22.31,124.98 22.31,125.36 22.3,125.37 22.3,125.94 22.31,125.95 22.31,126.54 22.65,126.88 22.84,126.88 v1(23.05,127.08) 23.14,126.99 23.3,126.99 CT24.1
TYPEC_DP_P1: length 37.8
  TOP w0.112: UT5.37 37.54,104.63 37.45,104.54 37.45,104.28 37.97,103.75 37.97,103.54 v1(38.13,103.37)
  IN1 w0.119: v1(38.13,103.37) 38.03,103.48 38.03,104.29 36.45,105.87 36.45,107.53 35.71,108.27 34.37,108.27 33.81,108.83 30.52,108.83 29.32,110.03 25.44,110.03 24.79,110.68 24.79,113.49 25.77,114.47 25.77,116.65 27.49,118.37 27.49,122.6 27.77,122.88 27.77,124.21 27.27,124.71 26.49,124.71 v1(26.39,124.81)
  BOTTOM w0.112: CT26.2 25.43,124.4 25.68,124.4 25.9,124.63 26.21,124.63 v1(26.39,124.81)
TYPEC_DP_P1_C: length 4.2
  TOP w0.112: CT83.1 23.7,124.27 23.54,124.27 v1(23.4,124.4)
  BOTTOM w0.112: UT2.12 21.99,123.66 22.1,123.55 22.3,123.55 v4(22.76,124.01) 22.96,124.21 23.21,124.21 v1(23.4,124.4) 23.47,124.34 23.77,124.34 CT83.1
TYPEC_DP_P2: length 32.6
  TOP w0.112: UT5.35 36.74,104.58 36.65,104.49 36.65,103.73 36.54,103.63 36.54,103.47 v1(36.7,103.31)
  IN1 w0.119: v1(36.7,103.31) 36.52,103.49 36.52,103.89 34.94,105.47 34.94,106.66 33.41,108.19 30.26,108.19 29.06,109.38 28.72,109.38 25.18,109.38 24.14,110.42 24.14,113.76 25.12,114.74 25.12,116.91 26.85,118.64 26.85,121.06 26.58,121.32 26.31,121.32 v1(26.15,121.48)
  BOTTOM w0.112: CT28.2 25,121.94 25.3,121.94 25.75,121.48 v1(26.15,121.48)
TYPEC_DP_P2_C: length 3.5
  TOP w0.112: v1(22.83,122.5) 23,122.33 23.3,122.33 23.55,122.59 CT85.1
  BOTTOM w0.112: CT28.1 23.8,122.14 23.19,122.14 v1(22.83,122.5) 22.61,122.28 22.22,122.28 22.04,122.46 UT2.15
TYPEC_DP_P3: length 34
  TOP w0.112: UT5.32 35.54,104.61 35.53,104.61 35.43,104.52 35.43,104.17 35.19,103.92 35.19,103.9 34.7,103.41 34.08,103.41 v1(34.03,103.36)
  IN1 w0.119: v1(34.03,103.36) 33.39,103.36 33.09,103.66 33.09,104.43 33.81,105.15 33.81,106.5 33.05,107.26 29.64,107.26 29.19,106.82 24.79,106.82 23.28,108.33 23.28,114.11 24.26,115.09 24.26,119.73 24.87,120.34 26.13,120.34 v1(26.16,120.31)
  BOTTOM w0.112: v1(26.16,120.31) 26.09,120.24 24.89,120.24 CT30.2
TYPEC_DP_P3_C: length 4.2
  TOP w0.112: v1(22.87,120.36) 23.08,120.15 23.3,120.15 23.55,120.4 CT87.1
  BOTTOM w0.112: UT2.18 21.98,121.26 22.15,121.08 22.26,121.08 22.47,120.87 22.47,120.31 22.58,120.21 22.72,120.21 v1(22.87,120.36) 23.08,120.15 23.6,120.15 CT30.1
TYPEC_RX1N: length 15.6
  TOP w0.102: JUSBC1.B10 6.46,123.07 v1(6.47,123.08)
  IN1 w0.119: v1(13.45,122.42) 13.45,122.42 13.8,122.78 14.16,122.78 15.31,121.62 15.31,121.16 15.19,121.04 14.98,121.04 v1(14.8,121.22)
  BOTTOM w0.112: UT2.31 17.11,121.26 17.02,121.17 16.41,121.17 16.29,121.04 14.98,121.04 v1(14.8,121.22) ; v1(6.47,123.08) 6.47,123.12 6.85,123.5 7.12,123.5 7.58,123.04 8.69,123.04 9.3,123.65 9.84,123.65 DT8.1 10.57,123.57 10.73,123.57 11.46,122.84 13.03,122.84 v1(13.45,122.42)
TYPEC_RX1P: length 15.6
  TOP w0.112: v1(6.49,123.72) 6.34,123.57 JUSBC1.B11
  IN1 w0.119: v1(14.8,120.64) 14.98,120.82 15.28,120.82 15.53,121.07 15.53,121.71 14.24,123.01 v1(13.45,123.01)
  BOTTOM w0.112: v1(14.8,120.64) 14.98,120.82 16.38,120.82 16.5,120.95 17.02,120.95 17.11,120.86 UT2.30 ; v1(13.45,123.01) 13.4,123.06 11.55,123.06 10.81,123.8 10.32,123.8 DT7.1 9.21,123.87 8.59,123.26 7.67,123.26 7.21,123.72 v1(6.49,123.72)
TYPEC_RX2N: length 22.6
  TOP w0.112: v1(14.63,118.73) 14.4,118.5 12.59,118.5 12.14,118.06 11.95,118.06 DT5.1 11.13,118.06 10.62,118.06 9.66,119.02 8.09,119.02 7.78,119.32 JUSBC1.A10
  IN3 w0.135: v1(15.76,126.39) 15.74,126.39 15.4,126.73 14.78,126.73 14.13,126.08 14.13,121.47 13.81,121.15 13.81,118.55 13.98,118.39 14.2,118.39 14.54,118.73 v1(14.63,118.73)
  BOTTOM w0.112: v1(15.76,126.39) 15.94,126.57 16.06,126.57 16.6,126.02 16.6,124.81 16.84,124.57 17.01,124.57 17.11,124.46 UT2.39
TYPEC_RX2P: length 22.6
  TOP w0.112: JUSBC1.A11 7.35,118.83 7.89,118.83 7.91,118.8 9.57,118.8 10.53,117.84 DT6.1 12.23,117.84 12.68,118.28 14.49,118.28 v1(14.63,118.15)
  IN3 w0.135: v1(15.76,126.97) 14.68,126.97 13.89,126.18 13.89,121.57 13.57,121.25 13.57,118.38 13.8,118.15 v1(14.63,118.15)
  BOTTOM w0.112: v1(15.76,126.97) 15.94,126.79 16.15,126.79 16.82,126.11 16.82,124.9 16.94,124.79 17.05,124.79 17.12,124.86 UT2.40
TYPEC_SMBCLK: length 69.6
  TOP w0.112: RE31.1 32.17,88.33 32.54,88.33 v1(32.73,88.14) ; UE1.91 39.35,84.3 39.5,84.44 39.5,84.72 v1(39.44,84.78)
  IN1 w0.119: v1(31.34,114.42) 31.49,114.57 31.49,114.78 31.34,114.92 30.68,114.92 30.05,115.55 30.05,116.63 30.27,116.84 30.27,117.6 31.49,118.82 35.48,118.82 35.62,118.95 35.62,118.96 35.64,119.15 v1(35.48,119.34) ; v1(39.44,84.78) 39.63,84.96 39.63,85.23 39.45,85.4 37.76,85.4 36.95,86.22 36.95,87.09 36.18,87.86 34.15,87.86 33.69,88.32 32.91,88.32 v1(32.73,88.14)
  IN3 w0.135: v1(35.48,119.34) 35.6,119.43 35.6,125.89 36.04,126.34 36.04,127.27 34.88,128.43 34.88,130.3 v1(34.72,130.46)
  BOTTOM w0.112: UT1.17 35.64,119.92 35.7,119.85 35.7,119.56 v1(35.48,119.34) ; v1(32.73,88.14) 32.56,88.31 31.11,88.31 30.33,89.1 30.33,90.95 32.38,93.01 33.39,93.01 34.38,94 34.38,100.27 34.57,100.46 34.57,107.83 32.12,110.28 32.12,112.2 31.51,112.81 31.51,114.26 v1(31.34,114.42) ; v1(34.72,130.46) 34.72,130.2 34.54,130.03 34.54,129.28 34.27,129.01 33.88,129.01 RT119.1
TYPEC_SMBCLK_R: length 2.6
  BOTTOM w0.112: RT119.2 32.38,128.99 32.1,128.99 31.34,129.76 31.08,129.76 31,129.84 UT3.3
TYPEC_SMBDA: length 70.4
  TOP w0.112: UE1.89 40.15,84.27 39.94,84.49 39.94,84.69 v1(40.03,84.78) ; v1(32.73,88.73) 32.57,88.57 32.19,88.57 RE30.1
  IN1 w0.119: v1(36.07,119.29) 35.89,119.13 35.86,118.84 35.78,118.77 35.58,118.58 31.59,118.58 30.51,117.5 30.51,116.74 30.3,116.53 30.3,115.65 30.78,115.17 31.44,115.17 31.73,114.88 31.73,114.61 v1(31.92,114.42) ; v1(40.03,84.78) 39.87,84.93 39.87,85.33 39.55,85.65 37.86,85.65 37.19,86.32 37.19,87.19 36.28,88.11 34.25,88.11 33.79,88.57 32.89,88.57 v1(32.73,88.73)
  IN3 w0.135: v1(35.31,130.46) 35.14,130.29 35.14,128.54 36.31,127.38 36.31,126.23 35.86,125.78 35.86,119.54 v1(36.07,119.29)
  BOTTOM w0.112: v1(36.07,119.29) 35.94,119.41 35.94,119.74 36.14,119.93 UT1.16 ; v1(31.92,114.42) 31.75,114.24 31.75,112.91 32.36,112.3 32.36,110.38 34.81,107.93 34.81,100.36 34.62,100.17 34.62,93.9 33.49,92.77 32.48,92.77 30.56,90.85 30.56,89.19 31.21,88.55 32.56,88.55 v1(32.73,88.73) ; RT118.1 33.9,128.77 34.02,128.77 34.02,128.77 34.37,128.77 34.78,129.18 34.78,129.93 v1(35.31,130.46)
TYPEC_SMBDA_R: length 2.6
  BOTTOM w0.112: RT118.2 32.4,128.75 32,128.75 v4(31.69,129.06) 31.24,129.52 31.08,129.52 31,129.44 UT3.4
TYPEC_TX1N: length 9.4
  TOP w0.112: CT41.1 12.95,123.1 13.26,123.42 13.64,123.42 14.05,123.01 14.05,122.73 15.65,121.14 16.35,121.14 16.72,121.51 16.72,122.05 16.37,122.4 16.08,122.4 v1(15.91,122.56)
  BOTTOM w0.112: v1(15.91,122.56) 16.12,122.36 17.04,122.36 17.14,122.46 UT2.34
TYPEC_TX1N_C: length 4.1
  TOP w0.112: JUSBC1.A3 7.35,122.83 7.79,122.83 8.02,123.05 8.68,123.05 9.11,123.48 9.91,123.48 10.15,123.25 DT4.1 10.9,123.25 CT41.2
TYPEC_TX1P: length 9.2
  TOP w0.112: v1(15.91,121.98) 16.12,122.18 16.28,122.18 16.5,121.95 16.5,121.6 16.26,121.36 15.74,121.36 15.05,122.05 14.28,122.82 14.28,123.1 13.72,123.66 13.19,123.66 12.85,123.33 12.53,123.33 12.42,123.44 12.42,123.82 12.24,123.99 CT40.1
  BOTTOM w0.112: v1(15.91,121.98) 16.07,122.14 17.03,122.14 17.11,122.06 UT2.33
TYPEC_TX1P_C: length 4
  TOP w0.112: CT40.2 10.92,123.87 DT3.1 10.07,123.7 9.01,123.7 v4(8.8,123.5) 8.58,123.27 8.14,123.27 8.09,123.32 7.4,123.32 JUSBC1.A2
TYPEC_TX2N: length 13.5
  IN3 w0.135: v1(13.28,117.15) 13.29,117.15 13.61,116.83 14.18,116.83 16.03,118.69 16.03,119.52 15.24,120.32 15.24,123.19 15.11,123.32 14.92,123.32 v1(14.74,123.15)
  BOTTOM w0.112: v1(14.74,123.15) 15.04,123.15 15.15,123.26 15.15,123.4 15.26,123.51 15.7,123.51 15.77,123.58 16.11,123.58 16.36,123.33 17.11,123.33 17.18,123.26 UT2.36 ; CT42.1 12.4,117.24 12.76,116.88 13.01,116.88 v1(13.28,117.15)
TYPEC_TX2N_C: length 6.9
  TOP w0.112: v1(6.58,119.42) 6.43,119.58 5.75,119.58 JUSBC1.B3
  BOTTOM w0.112: CT42.2 11.43,117.27 DT9.1 10.36,117.05 9.56,117.05 9.22,117.39 9.22,117.4 8.79,117.82 8.79,117.82 7.44,119.17 6.83,119.17 v1(6.58,119.42)
TYPEC_TX2P: length 13.7
  IN3 w0.135: v1(14.74,123.73) 14.92,123.56 15.21,123.56 15.48,123.29 15.48,120.42 16.27,119.62 16.27,118.59 14.28,116.59 13.3,116.59 v1(13.28,116.56)
  BOTTOM w0.112: v1(14.74,123.73) 15.61,123.73 15.68,123.8 16.2,123.8 16.45,123.55 17.08,123.55 17.19,123.66 UT2.37 ; v1(13.28,116.56) 13.19,116.66 12.61,116.66 CT43.1
TYPEC_TX2P_C: length 6.9
  TOP w0.112: v1(6.54,118.84) 6.31,119.07 5.75,119.07 JUSBC1.B2
  BOTTOM w0.112: v1(6.54,118.84) 6.65,118.95 7.35,118.95 8.79,117.51 8.79,117.49 v4(8.88,117.41) 9.45,116.83 10.39,116.83 DT10.1 11.28,116.64 CT43.2
UART1_CTS#: length 2.9
  TOP w0.089: v1(125.86,52.56) 125.86,52.24 125.26,51.63 125.26,51.16 TP79.1
  BOTTOM w0.076: UC1.AB4 125.25,51.94 v1(125.86,52.56)
UART1_RTS#: length 4.3
  BOTTOM w0.076: 124.89,48.68 124.89,48.76 124.87,48.78 124.87,49.5 124.65,49.73 124.65,50.03 124.66,50.05 124.66,50.21 124.71,50.26 124.71,51.32 UC1.AC3
  BOTTOM w0.089: 124.89,48.68 124.89,47.91 124.77,47.79 TP88.1
UART_P80: length 12.4
  BOTTOM w0.254: RW10.2 69.15,118.11 68.42,118.83 68.42,123.76 68.86,124.21 68.86,126.52 70.74,128.4 JWLAN1.32
UG1_CHG: length 14.2
  TOP w0.089: v1(194.41,54.27) 194.41,54.25 v2(194.93,53.73)
  IN3 w0.762: v1(194.41,54.27) 195.23,53.45 199.5,53.45 200.43,52.52 200.43,46.21 200.71,45.93
  vias: v1(201.07,45.29)
UG1_VGA: length 12.7
  TOP w0.089: v2(90.92,123.17) 90.59,122.84 v1(90.25,122.84)
  IN3 w0.762: 89.95,123.53 85.84,123.53 85.2,122.89 ; 83.17,122.89 81.34,124.72 80.3,124.72 78,127.01
  vias: v1(77.65,127.63) v1(84.03,123.05) v1(84.46,122.6) v1(89.67,122.84)
UG2_CHG: length 2.4
  TOP w0.089: v1(203.77,42.24) 203.4,42.24 v2(203.21,42.43)
  IN3 w0.762: 201.51,41.43 202.92,41.43 203.16,41.66
  vias: v1(200.2,40.95) v1(200.76,41.13) v1(204.21,42.65)
UG2_VGA: length 9.9
  TOP w0.089: v1(89.73,137.35) v2(90.71,137.35)
  IN3 w0.762: 83.64,137.25 82.55,137.25 81.21,135.91 81.21,135.15 79.85,133.79 79.85,132.43 79.38,131.96 78.42,131.96 78.25,131.8
  vias: v1(77.55,131.7) v1(84.4,137.56) v1(84.4,136.95) v1(89.73,136.76)
UG_1.2V: length 8.6
  TOP w0.089: v1(44.03,28.76) v2(44.76,28.76)
  TOP w0.203: PUM01.17 38.99,28.41 v1(39.26,28.14)
  IN1 w0.635: v1(44.03,28.76) 43.54,29.24 41.23,29.24 40.55,29.93 39.49,29.93 38.66,29.1 38.66,28.4
UG_VCCSA: length 6.2
  TOP w0.089: v1(158.18,61.76) v2(158.18,62.66)
  IN1 w0.508: v1(163.04,59.8) 159.51,59.8 158.24,61.07
USB2_ID: length 2.6
  TOP w0.508: v1(123.3,51.43) 123.3,50.94 v2(123.2,50.83) 122.94,50.58 RC67.1
  BOTTOM w0.254: v1(123.3,51.43) 122.57,51.43 UC1.AG3
USB2_VBUSSENSE: length 6
  BOTTOM w0.076: UC1.AG4 122.43,51.7 122.17,51.44 122.17,50.78 122.05,50.65 122.05,50.26 122.17,50.14 122.17,49.52 121.96,49.02 121.92,48.97
  BOTTOM w0.102: 121.92,48.97 121.81,48.67 121.81,48.36 121.95,48.02 v2(121.95,47.62)
  BOTTOM w0.112: RC68.1 121.78,46.71 v2(121.95,47.62)
USB3_CRX_C_DTX_N4: length 2.4
  BOTTOM w0.112: CT37.2 19.03,127.38 19.03,126.89 19.47,126.46 19.47,126.25 19.36,126.14 UT2.4
USB3_CRX_C_DTX_P4: length 2.4
  BOTTOM w0.112: UT2.5 19.76,126.14 19.69,126.22 19.69,126.57 v4(19.47,126.79) 19.25,127 19.25,127.43 CT36.2
USB3_CRX_DTX_N1: length 155
  TOP w0.112: v1(26.46,56.82) 26.64,56.82 26.88,57.05 26.88,57.21 26.74,57.34 25.96,57.34 25.3,56.69 v4(24.14,56.69) 23.51,56.69 23.39,56.56 LU3.3 22.87,56.39 RU6.2
  IN3 w0.076: v1(132.17,53.95) 132.22,53.95 132.3,53.87 132.31,53.66 132.23,53.58 131.35,53.58 131.04,53.28 131.04,52.84 131.41,52.48 131.41,51.83 132.2,51.04 132.2,48.72 132.16,48.68
  IN3 w0.135: 132.16,48.68 132.16,46.3 131.5,45.63 131.5,42.83 130.79,42.13 130.79,41.8 129.84,40.85 129.84,40.08 129.45,39.69 129.45,38.05 129.38,37.98 129.38,35.79 127.35,33.76 127.35,32.66 126.72,32.03 119.26,32.03 117.85,33.43 114.28,33.43 113.97,33.12 112.45,33.12 112.11,33.46 111.47,33.46 110.32,32.32 107.93,32.32 107.63,32.01 100.64,32.01 100.4,31.77 93.87,31.77 93.64,31.99 88.86,31.99 88.3,31.43 87.45,31.43 86.76,30.73 81.42,30.73 80.58,31.58 76.03,31.58 74.38,33.23 73.35,33.23 73.06,33.52 71.81,33.52 71.36,33.97 68.92,33.97 68.54,34.35 61,34.35 59.13,36.22 58.76,36.22 56.2,38.77 54.19,38.77 50.53,42.42 50.53,42.66 50.12,43.07 50.12,46.24 49.72,46.64 49.72,47.9 48.89,48.74 47.73,48.74 46.81,49.66 46.81,52.4 46.44,52.77 46.44,56.27 45.11,57.6 42.69,57.6 42.46,57.37 40.11,57.37 39.37,56.62 34.72,56.62 34.1,57.25 31.23,57.25 29.28,59.19 27.42,59.19 26.96,58.73 26.96,57.16 26.62,56.82 v1(26.46,56.82)
  BOTTOM w0.076: v1(132.17,53.95) 132.18,54.12 UC1.H8
USB3_CRX_DTX_N1_C: length 14.8
  TOP w0.112: JUSB1.5 14.38,49.93 14.49,50.04 15.06,50.04 15.52,50.49 15.52,51.55 15.2,51.87 15.2,52.43 15.39,52.62 15.39,53.13 15.41,53.15 15.39,53.17 15.39,53.68 15.16,53.91 15.16,54.48 v4(17.42,56.73) 17.7,57.01 18.21,57.01 18.33,56.9 EU2601.9 EU2601.1 19.88,56.9 20.02,57.04 20.43,57.04 20.77,56.7 21.37,56.7 21.51,56.56 LU3.4 21.96,56.39 RU6.1
USB3_CRX_DTX_N2: length 139.8
  TOP w0.112: v1(128.02,32.88) 128.02,32.88 128.29,32.6 128.29,32.6 128.65,32.24 129.05,32.24 129.48,32.68 130.88,32.68 131.57,31.99 132.31,31.99 132.51,31.79 135.6,31.79 135.8,31.99 138.54,31.99 139.09,31.44 143.33,31.44 146.19,28.58 146.46,28.58 146.97,28.07 146.97,27.68 146.87,27.58 146.7,27.58 v1(146.54,27.74) ; JWWAN.8 217.58,51.24 217.72,51.38 217.92,51.38 218.06,51.24 218.48,51.24 v1(218.66,51.06)
  IN1 w0.119: v1(146.54,27.74) 146.55,27.74 146.91,27.38 148.85,27.38 150.09,28.61 152.03,28.61 152.32,28.9 154.47,28.9 155.57,30 157.4,30 159.64,32.24 165.11,32.24 165.48,31.87 168.22,31.87 169.27,32.93 177.81,32.93 179.43,34.55 181.02,34.55 182.23,33.35 187.79,33.35 188.09,33.04 195.71,33.04 196.76,31.99 209.11,31.99 213.1,35.97 214.08,35.97 216.1,37.99 216.1,38.97 218.61,41.49 218.61,47.17 219.28,47.84 219.28,51.19 219.16,51.31 218.9,51.31 218.66,51.07 v1(218.66,51.06)
  IN3 w0.076: 133.04,48.68 133.04,48.7 133.08,48.73 133.08,50.7 131.9,51.88 131.9,52.87 131.7,53.06 v1(131.56,53.06)
  IN3 w0.135: v1(128.02,32.88) 128.2,33.06 128.2,33.65 130.06,35.51 130.06,37.69 130.13,37.77 130.13,39.39 130.52,39.78 130.52,40.57 131.48,41.52 131.48,41.85 132.18,42.55 132.18,45.35 133.04,46.21 133.04,48.68
  BOTTOM w0.076: UC1.J6 131.26,53.6 131.44,53.6 131.72,53.33 131.72,53.14 131.64,53.06 v1(131.56,53.06)
USB3_CRX_DTX_N3: length 149.9
  TOP w0.112: v1(42.83,42.19) 42.43,42.19 42.08,41.84 40.28,41.84 39.55,41.11 35.73,41.11 34.83,40.21 33.04,40.21 32.87,40.04 20.97,40.04 19.99,39.05 19.99,36.65 20.38,36.27 LU6.3 20.38,35.43 RU12.2
  IN1 w0.076: v1(131.57,55.01) 131.57,55.05 131.64,55.14 131.62,55.29 131.42,55.46 131.19,55.45 131.09,55.35 131.09,55.07 131.2,54.96 131.2,52.85 131.76,52.3 131.76,48.72 131.78,48.7 131.78,48.68
  IN1 w0.119: 131.78,48.68 131.78,46.9 131.04,46.15 131.04,45.07 131.03,45.07 131.03,42.73 130.46,42.16 130.46,39.05 128.11,36.69 125.5,36.69 125.09,37.1 121.29,37.1 120.77,36.58 118.16,36.58 115.92,38.82 115.92,40.94 114.13,42.73 111.99,42.73 109.73,40.47 109.73,39.55 105.87,35.7 104.99,35.7 104.57,36.12 102.61,36.12 102.54,36.2 101.61,36.2 101.27,36.54 98.7,36.54 97.93,37.31 96.59,37.31 96.16,37.74 92.83,37.74 92.56,37.47 91.33,37.47 89.99,38.81 87.25,38.81 85.57,37.13 81.3,37.13 81.03,36.86 76.5,36.86 75.4,37.97 72.07,37.97 69.94,40.09 64.44,40.09 63.24,41.29 63.24,42.79 62.33,43.71 57.73,43.71 57.22,43.2 56.72,43.2 56.49,43.43 53.93,43.43 53.79,43.29 45.42,43.29 44.8,42.66 43.12,42.66 42.82,42.37 42.82,42.2 v1(42.83,42.19)
  BOTTOM w0.076: UC1.J10 131.55,55.07 131.55,55.05 131.57,55.02 v1(131.57,55.01)
USB3_CRX_DTX_N3_C: length 12
  TOP w0.089: JUSB2.5 14.64,25.51 14.64,25.94 14.78,26.08 15.09,26.08 17.12,28.11 17.12,28.89 v4(17.84,29.61) 18.32,30.09 18.53,30.09 EU2603.9 EU2603.1 19.53,31.09 19.53,31.21 20.22,31.9 20.22,32.19 20.23,32.19 20.23,32.69 20.22,32.7 20.22,33.26 20.32,33.35 20.32,33.93 20.38,33.99 LU6.4 20.38,34.25 RU12.1
USB3_CRX_DTX_N4: length 190.8
  IN1 w0.076: v1(134.11,55.01) 134.11,55.7 134.69,56.28 134.69,57.18 133.64,58.24 131.8,58.24 131.64,58.4 131.64,60.78 131.24,61.19 131.24,67.61 132.12,68.49 132.12,71.71 131.82,72.02 131.82,72.52 130.82,73.52 130.82,73.61 130.39,74.04 130.39,78.34 130.46,78.41 130.46,79.18 130.67,79.39 130.67,81.77 131.05,82.16 131.05,83.81 129.86,85 129.86,89.99 128.62,91.23 127.98,91.23 126.97,92.24
  IN1 w0.119: 126.97,92.24 126.97,98.08 126.97,98.77 126.97,98.77 126.97,99.22 126.22,99.98 126.22,101.82 125.32,102.72 122.98,102.72 117.03,108.66 104.14,108.66 103.67,109.14 100.9,109.14 100.45,108.68 90.96,108.68 90.25,109.39 83.06,109.39 82.15,110.3 78.98,110.3 78.33,110.94 77.01,110.94 75.59,112.36 70.75,112.36 70.1,111.71 67.99,111.71 67.35,112.35 59.57,112.35 58.34,113.58 57.69,113.58 57.51,113.4 56.73,113.4 56.12,112.78 53.46,112.78 52.91,112.23 49.37,112.23 48.52,113.08 47.35,113.08 44.12,109.85 36.58,109.85 36.32,110.11 31.06,110.11 29.82,111.35 29.82,112.92 28.67,114.06 28.67,116.75 29.32,117.4 29.32,118.31 29.98,118.97 29.98,121.94 30.56,122.53 30.56,126.12 29.79,126.89 27.83,126.89 26.91,127.81 24.05,127.81 23.41,128.44 21.45,128.44 20.66,129.23 20.66,130.09 20.15,130.6 19.34,130.6 19.06,130.32 19.06,129.94 v1(18.82,129.7)
  BOTTOM w0.076: UC1.E10 134.11,55.1 v1(134.11,55.01)
  BOTTOM w0.112: CT37.1 18.99,128.97 18.99,129.53 v1(18.82,129.7)
USB3_CRX_DTX_P1: length 155
  TOP w0.112: RU5.2 22.87,57.23 LU3.2 23.36,57.06 23.51,56.91 23.86,56.91 23.87,56.92 24.42,56.92 24.43,56.91 25.21,56.91 25.88,57.58 v4(26.36,57.58) 26.82,57.58 27.1,57.3 27.1,56.89 v1(27.2,56.79)
  IN3 w0.076: v1(132.78,53.98) 132.64,53.97 132.5,53.84 132.51,53.56 132.37,53.42 131.42,53.42 131.21,53.21 131.21,52.91 131.57,52.55 131.57,51.9 132.37,51.11 132.37,48.73 132.41,48.7 132.41,48.68
  IN3 w0.135: v1(27.2,56.79) 27.2,58.63 27.52,58.95 29.18,58.95 31.13,57.01 34,57.01 34.62,56.38 39.47,56.38 40.21,57.13 42.56,57.13 42.79,57.36 45.01,57.36 46.2,56.17 46.2,52.67 46.57,52.3 46.57,49.56 47.63,48.5 48.79,48.5 49.48,47.8 49.48,46.54 49.87,46.14 49.87,42.97 50.29,42.56 50.29,42.32 54.09,38.53 56.1,38.53 58.66,35.97 59.03,35.97 60.9,34.11 68.44,34.11 68.81,33.73 71.26,33.73 71.71,33.28 72.96,33.28 73.25,32.99 74.28,32.99 75.93,31.34 80.48,31.34 81.32,30.49 86.86,30.49 87.55,31.19 88.4,31.19 88.96,31.75 93.54,31.75 93.77,31.52 100.5,31.52 100.74,31.77 107.73,31.77 108.03,32.08 110.42,32.08 111.57,33.22 112.01,33.22 112.35,32.88 114.07,32.88 114.38,33.19 117.75,33.19 119.16,31.79 126.82,31.79 127.59,32.56 127.59,33.66 129.62,35.69 129.62,37.88 129.69,37.95 129.69,39.59 130.08,39.98 130.08,40.75 131.04,41.7 131.04,42.03 131.74,42.73 131.74,45.53 132.41,46.2 132.41,48.68
  BOTTOM w0.076: v1(132.78,53.98) 132.78,54 132.79,54.12 UC1.G8
USB3_CRX_DTX_P1_C: length 14.8
  TOP w0.112: JUSB1.6 14.38,50.37 14.49,50.26 14.97,50.26 15.29,50.58 15.29,51.46 14.98,51.78 14.98,52.52 15.17,52.71 15.17,53.59 14.94,53.81 14.94,54.57 16.98,56.6 16.98,56.62 17.59,57.23 18.18,57.23 18.35,57.4 EU2601.8 EU2601.2 19.88,57.4 20.02,57.26 20.54,57.26 v4(20.71,57.09) 20.88,56.92 21.41,56.92 21.55,57.06 LU3.1 21.96,57.23 RU5.1
USB3_CRX_DTX_P2: length 140.1
  TOP w0.112: v1(128.6,32.88) 128.57,32.85 128.57,32.65 128.75,32.46 128.96,32.46 129.39,32.9 130.97,32.9 131.66,32.21 132.41,32.21 132.6,32.01 135.51,32.01 135.71,32.21 138.63,32.21 139.18,31.66 143.42,31.66 146.28,28.8 146.55,28.8 147.19,28.16 147.19,27.59 146.96,27.36 146.75,27.36 v1(146.54,27.16) ; v1(218.66,51.65) 218.47,51.46 218.15,51.46 218.02,51.6 217.75,51.6 217.61,51.74 JWWAN.9
  IN1 w0.119: v1(146.54,27.16) 148.94,27.16 150.18,28.39 152.12,28.39 152.41,28.68 154.56,28.68 155.66,29.78 157.49,29.78 159.73,32.02 165.02,32.02 165.39,31.65 168.31,31.65 169.36,32.71 177.9,32.71 179.52,34.33 180.93,34.33 182.14,33.13 187.7,33.13 188,32.82 195.62,32.82 196.67,31.77 209.2,31.77 213.19,35.76 214.17,35.76 216.32,37.9 216.32,38.88 218.83,41.4 218.83,47.08 219.5,47.75 219.5,51.28 219.25,51.53 218.78,51.53 v1(218.66,51.65)
  IN3 w0.076: v1(132.19,53.06) 132.06,52.93 132.06,51.95 133.24,50.77 133.24,48.73 133.28,48.7 133.28,48.68
  IN3 w0.135: v1(128.6,32.88) 128.44,33.03 128.44,33.55 130.3,35.41 130.3,37.59 130.37,37.67 130.37,39.29 130.76,39.68 130.76,40.47 131.72,41.42 131.72,41.75 132.42,42.45 132.42,45.25 133.28,46.11 133.28,48.68
  BOTTOM w0.076: v1(132.19,53.06) 131.87,53.38 UC1.H6
USB3_CRX_DTX_P3: length 149.9
  TOP w0.112: RU11.2 19.88,35.42 LU6.2 19.88,35.69 20.16,35.96 20.16,36.18 19.77,36.56 19.77,39.14 20.88,40.26 32.77,40.26 32.95,40.43 34.74,40.43 35.64,41.33 39.46,41.33 40.18,42.06 41.99,42.06 42.39,42.46 v1(42.39,42.58)
  IN1 w0.076: 131.57,48.68 131.57,48.7 131.59,48.72 131.59,52.23 131.03,52.78 131.03,54.89 130.93,55 130.93,55.42 131.12,55.61 131.3,55.62 v1(131.46,55.82)
  IN1 w0.119: v1(42.39,42.58) 42.72,42.58 43.03,42.88 44.71,42.88 45.33,43.51 53.7,43.51 53.84,43.65 56.58,43.65 56.81,43.42 57.13,43.42 57.64,43.92 62.42,43.92 63.46,42.88 63.46,41.38 64.53,40.31 70.04,40.31 72.16,38.18 75.49,38.18 76.6,37.08 80.94,37.08 81.21,37.35 85.48,37.35 87.16,39.03 90.08,39.03 91.42,37.69 92.47,37.69 92.74,37.96 96.25,37.96 96.68,37.53 98.02,37.53 98.79,36.75 101.36,36.75 101.7,36.41 102.63,36.41 102.7,36.34 104.67,36.34 105.09,35.92 105.78,35.92 109.51,39.64 109.51,40.56 111.9,42.95 114.22,42.95 116.14,41.03 116.14,38.91 118.25,36.8 120.68,36.8 121.2,37.32 125.18,37.32 125.59,36.91 128.02,36.91 130.24,39.14 130.24,42.25 130.82,42.82 130.82,45.16 130.82,45.16 130.82,46.24 131.57,46.99 131.57,48.68
  BOTTOM w0.076: UC1.H10 131.87,55.4 v1(131.46,55.82)
USB3_CRX_DTX_P3_C: length 11.9
  TOP w0.089: JUSB2.6 14.64,26.99 14.64,26.44 14.8,26.27 15.01,26.27 16.93,28.19 16.93,28.97 17.48,29.53 17.48,29.54 17.87,29.92 17.88,29.92 18.2,30.24 18.2,30.47 EU2603.8 EU2603.2 19.16,31.43 19.48,31.43 20.03,31.98 v4(20.03,32.44) 20.03,33.34 20.13,33.43 20.13,33.69 19.88,33.94 LU6.1 19.88,34.26 RU11.1
USB3_CRX_DTX_P4: length 190.7
  IN1 w0.076: 126.75,92.24 126.75,92.15 126.88,92.02 126.9,92.02 127.85,91.06 128.55,91.06 129.69,89.92 129.69,84.94 130.89,83.74 130.89,82.23 130.5,81.84 130.5,79.46 130.29,79.25 130.29,78.48 130.22,78.41 130.22,73.97 130.65,73.54 130.65,73.45 131.65,72.45 131.65,71.95 131.96,71.64 131.96,68.56 131.07,67.67 131.07,61.12 131.47,60.72 131.47,58.33 131.73,58.07 133.57,58.07 134.53,57.11 134.53,56.35 133.95,55.77 133.95,55.34 133.61,55.01 v1(133.48,55.01)
  IN1 w0.119: v1(19.41,129.7) 19.28,129.83 19.28,130.23 19.43,130.38 20.06,130.38 20.44,130 20.44,129.14 21.36,128.22 23.32,128.22 23.96,127.59 26.82,127.59 27.74,126.68 29.7,126.68 30.35,126.03 30.35,122.62 29.76,122.03 29.76,119.06 29.1,118.4 29.1,117.49 28.45,116.84 28.45,113.97 29.6,112.83 29.6,111.26 30.96,109.89 36.23,109.89 36.49,109.63 44.21,109.63 47.44,112.86 48.42,112.86 49.27,112.01 53,112.01 53.55,112.57 56.21,112.57 56.82,113.18 57.6,113.18 57.78,113.36 58.25,113.36 59.48,112.14 67.26,112.14 67.9,111.49 70.19,111.49 70.84,112.14 75.5,112.14 76.92,110.72 78.24,110.72 78.89,110.08 82.06,110.08 82.97,109.17 90.16,109.17 90.86,108.47 100.54,108.47 100.99,108.92 103.58,108.92 104.05,108.45 116.94,108.45 122.89,102.5 125.23,102.5 126,101.73 126,99.89 126.75,99.13 126.75,98.68 126.75,98.17 126.75,98.17 126.75,92.24
  BOTTOM w0.076: v1(133.48,55.01) 133.58,55.11 133.58,55.25 133.38,55.46 133.23,55.46 UC1.F10
  BOTTOM w0.112: CT36.1 19.21,129 19.21,129.5 v1(19.41,129.7)
