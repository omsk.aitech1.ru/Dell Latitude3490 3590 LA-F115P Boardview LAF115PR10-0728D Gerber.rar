# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.2VP on BOTTOM (solid shape): 54.62,32.21 54.62,31.18 56.43,29.36 56.43,25.16 56.07,24.8 52.69,24.8 51.8,25.69 51.8,28.76 50.61,29.95 44.04,29.95 44.03,29.99 43.77,30.24 43.43,30.14 43.36,30.11 43.29,30.14 43.17,30.25 43.17,30.88 43.17,30.88 43.17,31.83 43.23,31.89 43.95,31.89 43.95,31.92 43.97,31.92 43.97,32.43 43.98,32.44 44.42,32.44 44.42,31.92 44.45,31.92 44.45,31.91 45.15,31.91 45.15,31.92 45.17,31.92 45.17,32.44 45.6,32.44 45.61,32.42 45.61,31.89 46.66,31.89 46.95,32.18 50.93,32.18 50.94,32.19 51.62,32.19 51.63,32.16 51.96,31.96 52.28,32.18 52.3,32.26 52.31,32.35 52.3,32.37 52.53,32.6 54.23,32.6
+1.8V_EMMC on TOP (solid shape): 94.9,32.63 94.9,31.75 94.39,31.24 93.7,31.24 93.59,31.34 93.59,31.62 93.57,31.64 93.57,32.86 93.7,32.99 94.54,32.99
+1.8V_EMMC on TOP (solid shape): 94.73,36.7 94.81,36.7 94.99,36.51 94.99,35.39 94.58,34.98 94.58,34.91 94.47,34.81 93.76,34.81 93.67,34.9 93.67,36.48 93.67,36.48 93.67,36.81 94.02,37.16 94.28,37.16
+1.8V_EMMC on TOP (solid shape): 96.02,30.47 96.02,29 96.02,28.99 96.02,28.77 95.97,28.72 95.88,28.69 95.81,28.74 95.41,28.9 95.14,28.57 95.14,28.52 93.2,28.52 93.02,28.71 93.02,30.52 93.09,30.59 95.9,30.59
+1.8V_PRIM on TOP (solid shape): 92.61,29.62 92.61,28.55 92.52,28.46 91.35,28.46 91.24,28.56 91.24,29.58 91.33,29.67 92.56,29.67
+1.8V_PRIM on TOP (solid shape): outline of 691 points within 122.16,45.66 129.14,58.69
+1.8V_PRIM on BOTTOM (solid shape): 127.51,110.33 127.51,110.24 128.14,109.61 128.14,107.39 127.9,107.16 126.83,107.16 126.47,107.51 126.47,109.19 126.78,109.49 126.78,110.34 126.86,110.42 127.43,110.42
+1.8V_PRIM on BOTTOM (solid shape): 90.69,43.4 90.69,41.36 90.69,41.35 90.67,41.25 90.69,41.14 90.7,41.11 90.54,40.95 89.67,40.95 89.54,41.08 89.54,43.37 89.76,43.58 90.51,43.58
+1.8V_PRIM on BOTTOM (solid shape): 155.42,46.3 155.42,45.83 155.42,44.87 154.88,44.87 154.88,44.36 155.42,44.36 155.42,44.07 154.88,44.07 154.88,43.56 155.42,43.56 155.42,42.08 155.2,41.86 153.02,41.86 152.26,42.63 152.26,44.36 153.55,44.36 153.55,44.33 153.56,44.28 153.58,44.23 153.6,44.18 153.63,44.13 153.66,44.1 153.71,44.06 153.75,44.04 153.8,44.02 153.85,44 153.91,44 153.96,44 154.01,44.02 154.06,44.04 154.11,44.06 154.15,44.1 154.19,44.13 154.22,44.18 154.24,44.23 154.25,44.28 154.26,44.33 154.26,44.38 154.25,44.44 154.24,44.49 154.22,44.53 154.19,44.58 154.15,44.62 154.11,44.65 154.06,44.68 154.01,44.7 153.96,44.71 153.91,44.71 153.85,44.71 153.8,44.7 153.75,44.68 153.71,44.65 153.66,44.62 153.63,44.58 153.6,44.53 153.58,44.49 153.56,44.44 153.55,44.38 153.55,44.36 152.26,44.36 152.26,46.26 152.74,46.74 154.97,46.74
+1.8V_PRIM on VCC: 90.61,39.94 89.92,40.63 89.92,42.21 94.59,42.21 101.58,49.19 112.37,49.19 112.52,49.34 112.52,51.98 124.67,51.98 127.45,49.19 150.77,49.19 151.86,50.28 151.86,51.39 154.53,51.39 157.77,48.15 157.77,46.21 156.22,44.66 151.83,44.66 150.15,46.34 103,46.34 96.6,39.94
+1.8VALWP on TOP (solid shape): 158.72,44 158.72,43.11 158.53,42.92 157.2,42.92 157.02,43.1 157.02,43.79 157.47,44.24 158.48,44.24
+1.8VALWP on BOTTOM (solid shape): 161.09,45.84 161.09,42.93 160.89,42.73 155.8,42.73 155.55,42.98 155.55,43.69 155.01,43.69 155.01,43.94 155.56,43.94 155.56,44.5 155.01,44.5 155.01,44.74 155.55,44.74 155.55,45.78 155.74,45.97 160.96,45.97
+1.8VGS on TOP (solid shape): outline of 734 points within 106.63,115.12 125.36,143.25
+1.8VGS on BOTTOM (solid shape): 113.9,117.74 113.9,116.19 113.7,115.98 113.04,115.98 112.78,116.24 112.78,117.75 112.86,117.82 113.82,117.82
+1.8VGS on BOTTOM (solid shape): 120.67,110.1 120.67,109.76 120.66,109.75 120.12,109.75 120.11,109.75 120.11,109.24 120.14,109.21 120.66,109.21 120.66,109.21 120.66,108.96 120.66,108.96 120.12,108.96 120.11,108.95 120.11,108.42 120.12,108.41 120.66,108.41 120.67,108.41 120.67,107.9 120.64,107.88 119.06,107.88 119.05,107.88 118.9,107.88 118.77,108.02 118.77,109.14 119.31,109.68 119.31,110 119.46,110.15 120.61,110.15
+1.8VGS_OUT on BOTTOM (solid shape): 125.47,110.33 125.47,109.39 125.44,109.36 125.44,109.24 123.85,107.65 121,107.65 120.8,107.85 120.8,108.55 120.8,108.56 120.26,108.56 120.25,108.56 120.25,108.81 120.26,108.81 120.79,108.81 120.81,108.83 120.81,109.35 120.8,109.36 120.26,109.36 120.26,109.36 120.26,109.61 120.26,109.61 120.79,109.61 120.8,109.62 120.8,110.08 120.81,110.09 121.12,110.09 121.16,110.05 123.17,110.05 123.26,110.14 124.35,110.14 124.64,110.42 125.38,110.42
+1.35V_MEM_GFX on TOP (solid shape): 129.55,139.19 129.55,138.53 129.52,138.45 129.44,138.43 129.05,138.19 129.2,137.77 129.25,137.7 129.22,137.61 128.96,137.36 128.95,137.35 128.76,137.05 128.93,136.73 128.93,136.27 129.08,136.12 129.08,135.58 128.91,135.42 128,135.42 127.89,135.52 127.89,137.16 127.89,137.16 127.89,138.98 128.28,139.37 129.37,139.37
+1.35V_MEM_GFX on TOP (solid shape): outline of 704 points within 132.38,143.75 155.81,150.27
+1.35V_MEM_GFX on TOP (solid shape): outline of 4087 points within 147.68,112.52 164.59,149.53
+1.35V_MEM_GFX on BOTTOM (solid shape): 156.63,115.75 156.63,114.94 157.14,114.44 159.01,114.44 159.52,113.93 159.52,112.31 159.23,112.02 158.67,112.02 158.64,112 158.47,112 158.47,112.52 157.77,112.52 157.77,112 157.27,112 157.27,112.52 156.57,112.52 156.57,112 155.87,112 155.18,112.69 155.18,113.13 155.17,113.14 155.17,113.77 155.17,113.77 155.17,116 155.23,116.07 156.31,116.07
+1.35V_MEM_GFX on BOTTOM (solid shape): 160.83,121.41 160.86,121.33 160.94,121.11 161.15,120.99 161.21,120.96 161.24,120.89 161.3,120.73 161.44,120.64 161.46,120.64 161.54,120.55 161.57,120.45 161.48,120.38 161.3,120.28 161.24,120.09 161.24,120.07 161.2,120.03 161.13,120.04 161.09,120.04 161.02,120.06 160.98,120.13 160.9,120.3 160.73,120.38 160.66,120.41 160.64,120.49 160.55,120.73 160.32,120.84 160.3,120.84 160.19,120.95 160.24,121 160.26,121 160.48,121.1 160.58,121.32 160.58,121.35 160.67,121.44 160.75,121.44
+1.35V_MEM_GFX on BOTTOM (solid shape): 127.87,131.77 128.02,131.66 128.21,131.65 128.23,131.65 128.78,131.1 128.78,130.66 128.66,130.28 129.02,130.1 129.1,130.08 129.14,130 129.14,129.78 129.12,129.75 129.12,129.6 129.08,129.52 129,129.5 128.64,129.26 128.87,128.9 128.88,128.9 129,128.78 128.99,128.76 129.12,128.42 129.48,128.4 129.49,128.41 129.8,128.41 129.89,128.32 129.89,127.17 129.51,126.79 129.1,126.79 129.07,126.82 129.02,126.84 128.72,127.14 128.72,127.99 127.77,128.94 127.77,131.15 127.61,131.3 127.61,131.32 127.58,131.35 127.52,131.5 127.57,131.65 127.59,131.67 127.69,131.77
+1.35V_MEM_GFX on BOTTOM (solid shape): 129.9,139.53 129.9,139.21 129.82,138.99 129.9,138.78 129.9,138.55 129.72,138.36 129.55,138.36 129.54,138.37 129.41,138.4 129.27,138.38 129.12,138.27 129.06,138.09 129.06,138.08 128.88,137.9 128.87,137.89 128.64,137.64 128.79,137.33 128.84,137.27 128.83,137.2 128.79,137.09 128.79,136.98 128.8,136.95 128.77,136.93 128.77,136.65 128.65,136.3 128.96,136.09 129.01,136.09 129.11,135.99 129.11,135.63 128.99,135.5 128.96,135.5 128.84,135.49 128.74,135.43 128.08,135.43 128,135.51 128,135.58 127.96,135.62 127.89,135.8 127.96,135.98 128,136.01 128,136.58 127.96,136.62 127.91,136.7 127.89,136.79 127.89,136.86 127.87,136.88 127.87,138.03 128.36,138.52 128.36,139.49 128.52,139.64 129.79,139.64
+1.35V_MEM_GFX on BOTTOM (solid shape): outline of 346 points within 153.18,142.73 164.62,149.43
+1.35V_MEM_GFX on BOTTOM (solid shape): outline of 6067 points within 148.87,116.32 164.62,144.5
+1.35V_MEM_GFX on IN1 (solid shape): outline of 1260 points within 127.49,126.79 131.74,139.94
+1.35V_MEM_GFX on IN3 (solid shape): outline of 1325 points within 127.5,126.73 132.74,140.02
+1.35V_MEM_GFX on VCC: 141.34,112.58 140.06,113.85 140.06,115.99 136.5,119.55 126.49,119.55 126.49,124.9 128.4,126.81 128.4,128.93 127.13,130.2 127.13,131.25 128.4,132.52 128.4,134.64 126.49,136.55 126.49,145.22 128.25,146.98 132.46,146.98 136.35,150.87 146.51,150.87 146.82,151.19 153.98,151.19 155.5,149.66 162.18,149.66 163.42,148.42 163.42,134.02 163.57,133.66 164.51,132.74 164.72,132.52 164.72,118.69 163.12,117.09 160.2,117.09 158.28,115.16 158.28,112.58 ; 1 cut-out
+1.35VGPUP on TOP (solid shape): 155.1,111.97 155.1,109 154.91,108.81 153.74,108.81 153.59,108.96 153.59,112.06 153.65,112.12 154.95,112.12
+1.35VGPUP on BOTTOM (solid shape): 155.82,111.87 155.86,111.87 155.92,111.81 159.11,111.81 159.27,111.65 159.27,111.23 156.66,108.63 149.48,108.63 149.3,108.81 149.3,111.41 149.49,111.6 150.47,111.6 150.9,112.04 155.64,112.04
+1VALWP on TOP (solid shape): 154.65,53.91 154.65,49.32 154.04,48.72 152.12,48.72 151.29,47.89 148.83,47.89 148.83,48.72 149.76,49.65 151.83,49.65 152,49.82 152,50.56 151.46,50.56 151.46,50.99 152.01,50.99 152.01,51.75 151.46,51.75 151.46,52.19 152,52.19 152,53.52 152.56,54.08 154.47,54.08
+1VALWP on BOTTOM (solid shape): 154.59,54.41 154.59,49.49 153.86,48.76 151.47,48.76 151.04,48.32 151.04,47.91 151.03,47.9 148.81,47.9 148.62,48.09 148.62,49.51 148.9,49.79 150.5,49.79 150.86,50.15 150.86,54.24 151.17,54.55 154.45,54.55
+2.5V_MEM on TOP (solid shape): 55.31,52.78 55.31,51.04 55.08,50.81 53.71,50.81 53.48,51.04 53.48,52.65 53.84,53 55.09,53
+2.5V_MEM on TOP (solid shape): 82.52,43.62 82.52,42.8 82.29,42.57 79.63,42.57 79.37,42.84 78.51,42.84 78.38,42.97 78.38,43.65 78.57,43.84 82.29,43.84
+2.5V_MEM on TOP (solid shape): 60.04,112.93 60.04,112.31 60.06,112.29 60.59,112.29 60.59,112.29 60.59,112.11 60.59,112.11 60.04,112.11 60.04,112.1 60.04,111.47 60.04,111.46 60.04,110.73 59.9,110.59 58.73,110.59 58.44,110.88 58.44,112.82 58.67,113.05 59.92,113.05
+2.5V_MEM on TOP (solid shape): 66.13,44.05 68.51,44.05 68.63,43.92 68.63,41.23 65.59,38.18 54.67,38.18 54.59,38.26 54.59,39.94 54.77,40.11 63.21,40.11 64.64,41.55 64.64,41.83 64.79,41.88 64.9,41.98 65.54,42.18 64.9,42.39 64.79,42.49 64.64,42.54 64.64,43.99 64.71,44.05 66.12,44.05
+2.5V_MEM on BOTTOM (solid shape): 55.29,54.2 55.29,52.14 55.11,51.96 54.04,51.96 53.78,52.21 53.78,52.88 53.78,54.15 53.99,54.35 55.14,54.35
+2.5V_MEM on BOTTOM (solid shape): 81.18,43.85 81.18,42.83 80.99,42.64 78.39,42.64 78.26,42.77 78.26,44.04 78.37,44.15 80.87,44.15
+2.5V_MEM on BOTTOM (solid shape): 68.41,43.84 68.41,42.96 68.29,42.83 67.19,42.83 66.78,43.23 65.66,43.23 65.56,43.34 65.56,44.04 65.67,44.15 68.11,44.15
+2.5V_MEM on BOTTOM (solid shape): outline of 95 points within 55.04,110.86 59.77,112.94
+2.5V_MEM on IN2 (solid shape): 81.16,43.47 81.16,42.71 80.77,42.32 78.61,42.32 78.34,42.59 78.22,42.59 78.18,42.63 78.19,42.66 78.19,42.89 78.04,43.08 78.02,43.11 77.99,43.14 77.72,43.28 77.44,43.16 77.44,43.16 76.87,43.16 76.86,43.2 76.51,43.49 76.16,43.2 76.16,43.16 74.05,43.16 74.04,43.16 73.32,43.16 73.26,43.22 72.2,43.22 72.14,43.16 71.69,43.16 71.38,42.85 67.27,42.85 67.1,43.03 67.1,43.59 67.21,43.7 69.93,43.7 69.94,43.71 74.2,43.71 74.37,43.87 80.76,43.87
+2.5VP on TOP (solid shape): 65.65,113.34 67.1,113.34 67.29,113.14 67.29,112.82 67.05,112.58 65.55,112.58 65,112.03 62.63,112.03 61.75,111.88 61.3,111.1 61.19,110.99 60.33,110.99 60.18,111.15 60.18,111.98 60.64,111.98 60.65,111.98 60.72,111.98 60.72,112.06 60.72,112.06 60.72,112.34 60.72,112.35 60.72,112.42 60.65,112.42 60.64,112.42 60.18,112.42 60.18,113.44 60.64,113.9 65.09,113.9
+3.3V_ALW_DSW on TOP (solid shape): 111.42,55.92 111.42,55.86 110.48,54.92 109.24,54.92 109.16,55 109.16,55.71 109.39,55.94 111.39,55.94
+3.3V_ALW_DSW on TOP (solid shape): 105.74,57.1 105.74,56.29 105.6,56.14 103.43,56.14 102.89,55.61 102.51,55.61 102.17,55.26 102.17,53.57 102.19,53.54 102.67,53.54 102.74,53.61 103.04,53.61 103.04,53.32 103.19,52.64 103.34,53.32 103.34,53.61 103.85,53.61 103.85,53.61 103.88,53.61 103.88,53.64 104.06,53.82 104.06,54.31 104.11,54.35 105.55,54.35 105.61,54.3 105.61,53.65 105.52,53.56 105.52,53.52 105.32,53.32 104.36,53.32 103.29,52.26 103.04,52.26 102.96,52.18 102.96,52.18 102.76,51.98 99.97,51.98 99.69,52.27 99.69,56.53 100.37,57.22 105.62,57.22
+3.3V_ALW_DSW on IN2 (solid shape): outline of 1003 points within 109.29,54.29 121.7,60.74
+3.3V_SPI on BOTTOM (solid shape): 127.82,41.48 127.87,41.46 127.87,41.41 127.95,40.96 128.41,40.96 129.28,40.96 129.3,40.93 129.3,40.02 129.55,39.77 129.55,39.19 129.5,39.13 128.86,39.13 128.71,39.29 128.71,39.68 128.3,40.09 127.49,40.09 127.15,40.43 127.15,41.85 127.27,41.97 127.33,41.97
+3.3V_VBUS_IN on TOP (solid shape): 55.81,126.65 55.89,126.57 55.97,126.53 55.99,126.52 56.1,126.5 56.22,126.52 56.23,126.52 57.43,126.52 57.9,126.06 58.33,126.06 58.46,125.93 58.46,124.68 58.17,124.39 55.9,124.39 55.8,124.48 55.8,125.2 55.3,125.7 54.58,125.7 54.1,126.18 53.27,126.18 53.12,126.33 53.12,127.05 53.27,127.2 55.26,127.2
+3.3V_VDD_PIC on TOP (solid shape): 34.8,126.04 35.64,126.04 36.03,125.65 36.03,124.91 36.03,124.66 35.96,124.59 35.58,124.59 35.3,124.87 34.66,124.87 34.36,124.57 32.64,124.57 32.52,124.69 31.71,124.69 31.48,124.92 31.48,125.37 33.96,125.37 33.96,125.31 33.98,125.26 34,125.21 34.02,125.16 34.06,125.12 34.09,125.09 34.14,125.06 34.19,125.03 34.24,125.02 34.29,125.01 34.34,125.01 34.4,125.02 34.45,125.03 34.5,125.06 34.54,125.09 34.58,125.12 34.61,125.16 34.64,125.21 34.66,125.26 34.67,125.31 34.67,125.37 34.67,125.42 34.66,125.47 34.64,125.52 34.61,125.57 34.58,125.61 34.54,125.64 34.5,125.67 34.45,125.7 34.4,125.71 34.34,125.72 34.29,125.72 34.24,125.71 34.19,125.7 34.14,125.67 34.09,125.64 34.06,125.61 34.02,125.57 34,125.52 33.98,125.47 33.96,125.42 33.96,125.37 31.48,125.37 31.48,126.93 31.84,127.28 32.18,127.28 32.29,127.4 33.44,127.4
+3.3V_VDD_PIC on BOTTOM (solid shape): 34.64,127.67 34.64,126.86 34.77,126.73 34.77,125.96 34.7,125.89 31.64,125.89 31.48,126.04 31.48,127.12 31.65,127.29 32.75,127.29 32.93,127.47 32.93,127.82 32.99,127.88 34.43,127.88
+3.3V_WLAN on TOP (solid shape): 72.49,138.16 72.49,136.2 72.29,136 69.55,136 69.38,136.16 69.38,137.23 70.4,138.24 72.4,138.24
+3.3V_WLAN on TOP (solid shape): 78.23,120.02 78.23,117.69 77.77,117.23 70.2,117.23 70,117.43 70,118.59 70.27,118.85 71.54,118.85 72.2,118.2 74.48,118.2 74.66,118.39 75.18,118.39 75.38,118.32 75.58,118.39 75.76,118.39 76.07,118.34 76.29,118.54 76.31,118.58 76.49,118.58 76.82,118.91 76.82,120.07 76.92,120.18 78.08,120.18
+3.3V_WLAN on BOTTOM (solid shape): 72.3,139.57 72.3,138.3 72.23,138.23 70.8,138.23 70.71,138.14 70.71,138.14 70.58,137.97 70.61,137.76 70.61,137.75 70.61,137.55 70.61,137.54 70.57,137.4 70.61,137.26 70.61,137.25 70.61,137.06 70.58,137.03 70.57,136.9 70.58,136.83 70.58,136.47 70.58,136.44 70.57,136.38 70.46,136.27 69.57,136.27 69.32,136.51 69.32,136.58 69.31,136.64 69.31,137.03 69.31,137.04 69.31,137.06 69.31,137.27 69.19,137.44 69.19,137.89 68.84,138.23 68.84,139.35 69.12,139.63 72.23,139.63
+3.3V_WLAN on BOTTOM (solid shape): outline of 100 points within 69.79,116.83 72.35,121.6
+3.3V_WLAN on IN2 (solid shape): outline of 857 points within 68.81,117.75 75.29,137.55
+3V_DVDD on TOP (solid shape): 30.53,10.79 30.53,10.1 31.14,9.49 31.14,7.76 30.63,7.76 30.6,7.78 30.6,9.36 30.28,9.69 30.21,9.77 30.13,9.83 29.93,10.03 29.93,10.64 29.85,10.71 29.4,10.71 29.35,10.77 29.35,11.12 29.38,11.16 30.16,11.16
+3VALW on TOP (solid shape): 14.75,86.76 14.75,85.13 14.75,84.73 14.74,84.72 13.35,84.72 13.18,84.89 13.18,86.71 13.42,86.95 14.56,86.95
+3VALW on TOP (solid shape): 29.96,86.02 29.96,85.71 29.92,85.67 29.92,83.73 29.78,83.6 29.09,83.6 28.97,83.71 28.97,85.22 28.58,85.61 28.58,86 28.76,86.18 29.8,86.18
+3VALW on TOP (solid shape): 47,60.97 47,59.97 46.89,59.86 43.69,59.86 43.38,60.17 42.11,60.17 42.07,60.21 41.44,60.21 41.31,60.33 41.31,60.69 41.51,60.89 42.51,60.89 42.74,61.12 46.86,61.12
+3VALW on TOP (solid shape): 69.5,138.04 69.5,137.58 69.44,137.52 69.38,137.47 69.33,137.41 69.2,137.28 69.2,136.75 69.21,136.74 69.21,136.38 69.13,136.3 68.24,136.3 68.02,136.52 68.02,138.09 68.23,138.29 69.26,138.29
+3VALW on TOP (solid shape): 45.19,91.94 45.86,91.94 45.98,91.82 45.98,91.26 45.96,91.24 44.96,91.24 44.89,91.31 43.48,91.31 43.31,91.14 43.21,91.14 43.11,91.04 42.59,91.04 42.53,91.06 42.46,91.07 42.36,91.17 42.36,91.53 43.05,92.22 44.9,92.22
+3VALW on TOP (solid shape): 49.25,87.67 49.25,86.91 49.21,86.88 48.61,86.88 48.01,87.47 46.12,87.47 45.88,87.56 45.64,87.47 43.24,87.47 43.16,87.55 43.16,88.24 43.25,88.33 48.59,88.33
+3VALW on TOP (solid shape): 54.94,70.86 55,70.84 55.06,70.84 55.15,70.75 55.15,69.94 55.8,69.29 55.8,68.53 55.8,68.53 55.8,68.05 55.72,67.96 55.02,67.96 54.95,68.03 54.95,68.14 54.76,68.33 54.65,68.33 54.64,68.34 54.42,68.34 54.34,68.41 54.34,70.75 54.45,70.86
+3VALW on TOP (solid shape): 174.56,44.12 174.56,41.57 174.58,41.55 174.58,41.43 174.62,41.38 174.62,41.36 175.83,40.16 175.83,39.64 175.84,39.62 175.84,39.5 176.09,39.26 176.52,39.26 176.74,39.03 176.74,36.67 176.52,36.45 175.24,36.45 175.13,36.55 175.13,37.27 175.04,37.37 174.32,37.37 174.07,37.61 174.07,38.11 173.91,38.27 173.36,38.27 173.34,38.29 173.24,38.29 173.08,38.45 173.08,39.28 172.17,40.18 172.17,41.97 172.7,41.97 172.7,42.4 172.17,42.4 172.17,43.1 172.68,43.61 172.68,44.08 172.88,44.28 174.39,44.28
+3VALW on TOP (solid shape): 224.22,59.17 224.22,42.71 224.11,42.6 218.84,42.6 218.64,42.8 218.64,46.56 219.27,46.56 219.27,45.52 221.53,45.52 221.53,46.52 221.49,46.62 221.56,46.69 221.56,46.99 221.56,47.01 221.55,47.06 221.54,47.11 221.51,47.16 221.49,47.2 221.45,47.24 221.41,47.28 221.37,47.3 221.32,47.32 221.27,47.34 221.21,47.34 221.16,47.34 221.11,47.33 221.06,47.31 221.01,47.29 220.97,47.26 220.94,47.22 220.9,47.18 220.88,47.13 220.86,47.08 220.85,47.03 220.85,46.98 220.42,46.56 218.64,46.56 218.64,48.88 219.62,49.87 219.62,53.8 219.33,54.09 219.33,54.09 219.15,54.27 219.15,55.15 218.24,56.07 216.72,56.07 216.04,56.75 215.19,56.75 214.96,56.98 214.96,58.14 215.17,58.35 215.19,58.37 215.22,58.41 215.24,58.46 215.26,58.51 215.27,58.56 215.27,58.61 215.27,58.66 215.26,58.71 215.24,58.76 215.21,58.8 215.18,58.85 215.14,58.88 215.1,58.91 215.07,58.93 215.04,58.95 215.03,58.98 215.02,59.01 215.03,59.04 215.03,59.06 215.03,59.23 215.24,59.43 223.96,59.43
+3VALW on TOP (solid shape): 78.75,116.45 78.88,116.34 79.12,116.34 79.12,116.29 79.28,116.02 79.59,115.98 79.67,115.97 79.71,115.89 80.36,115.7 79.96,116.25 79.88,116.26 79.84,116.33 79.83,116.35 79.86,116.42 79.94,116.45 80.16,116.68 82.42,116.68 82.52,116.58 82.52,115.25 81.76,114.49 81.48,114.49 81.35,114.35 81.35,113.54 81.24,113.43 80.62,113.43 80.34,113.71 80.08,113.71 79.85,113.94 79.85,114.77 79.65,114.97 77.87,114.97 77.87,114.96 76.81,114.96 76.13,114.29 75.83,114.29 75.83,114.8 75.39,114.8 75.39,114.29 74.62,114.29 74.49,114.42 74.49,116.35 74.99,116.85 78.35,116.85
+3VALW on TOP (solid shape): outline of 173 points within 31.73,51.06 39.93,63.09
+3VALW on BOTTOM (solid shape): 174.96,44.03 174.96,42.11 174.77,41.92 173.49,41.92 173.38,42.03 173.38,44.06 173.59,44.28 174.71,44.28
+3VALW on BOTTOM (solid shape): 144.35,94.98 144.35,93.6 145.11,93.6 145.2,93.52 145.2,92.72 144.96,92.49 142.75,92.49 142.6,92.64 142.6,93.73 142.66,93.79 143.28,93.79 143.43,93.95 143.43,94.95 143.54,95.05 144.28,95.05
+3VALW on BOTTOM (solid shape): 31.17,57.35 32.78,57.35 32.92,57.2 32.92,57.1 34.21,55.81 34.21,53.26 33.9,52.94 29.99,52.94 29.84,53.09 29.84,53.58 29.54,53.89 29.26,53.89 28.85,54.3 28.85,55.39 29.37,55.39 29.37,56.1 28.85,56.1 28.85,56.59 29.37,56.59 29.37,57.3 28.85,57.3 28.85,57.87 29.12,58.14 30.39,58.14
+3VALW on BOTTOM (solid shape): 103.33,35.51 103.33,33.72 103.46,33.59 103.46,32.47 103.81,32.12 103.81,32.11 103.95,31.97 103.95,29.95 103.73,29.74 103.51,29.74 103.5,29.75 102.31,29.75 102.19,29.87 102.19,30.96 102.26,31.02 102.26,31.52 102.1,31.68 100.57,31.68 100.4,31.85 100.4,33.19 100.59,33.38 101.58,33.38 101.76,33.56 101.76,35.02 102.46,35.71 103.12,35.71
+3VALW on IN3 (solid shape): 42.5,61.12 42.5,60.33 42.35,60.18 41.18,60.18 40.83,60.54 39.84,60.54 39.33,61.04 38.69,61.04 38.54,61.2 38.54,61.61 39.93,61.61 39.93,61.56 39.94,61.51 39.96,61.46 39.98,61.41 40.01,61.36 40.04,61.32 40.09,61.29 40.13,61.26 40.18,61.24 40.23,61.23 40.29,61.23 40.34,61.23 40.39,61.24 40.44,61.26 40.49,61.29 40.53,61.32 40.57,61.36 40.6,61.41 40.62,61.46 40.63,61.51 40.64,61.56 40.64,61.61 40.63,61.66 40.62,61.72 40.6,61.76 40.57,61.81 40.53,61.85 40.49,61.88 40.44,61.91 40.39,61.93 40.34,61.94 40.29,61.94 40.23,61.94 40.18,61.93 40.13,61.91 40.09,61.88 40.04,61.85 40.01,61.81 39.98,61.76 39.96,61.72 39.94,61.66 39.93,61.61 38.54,61.61 38.54,62.06 38.85,62.37 41.26,62.37
+3VALW on IN3 (solid shape): outline of 302 points within 165.5,42.32 175.06,45.13
+3VALW on VCC: outline of 111 points within 13.69,18.54 227.23,137.6 ; 2 cut-outs
+3VALW_EC on TOP (solid shape): 50.51,84.54 50.59,84.5 50.61,84.41 50.95,83.95 51.29,84.41 51.31,84.5 51.39,84.54 52.01,84.54 52.35,84.2 54.45,84.2 54.59,84.06 54.59,82.89 54.37,82.67 50.66,82.67 50.54,82.55 49.69,82.55 49.64,82.61 49.64,84.24 49.71,84.31 49.72,84.31 49.96,84.54
+3VALW_PCH on TOP (solid shape): 86.57,117.7 86.57,115.68 86.17,115.27 83.24,115.27 83.18,115.33 83.18,117.76 83.4,117.98 86.29,117.98
+3VALW_PCH on TOP (solid shape): outline of 131 points within 120.98,56.64 122.93,59.38
+3VALW_PCH on BOTTOM (solid shape): 144.96,50.4 144.96,49.73 144.17,48.94 144.17,48.63 144.07,48.53 143.31,48.53 143.22,48.62 143.22,50.42 143.31,50.51 144.85,50.51
+3VALW_PCH on BOTTOM (solid shape): 89.81,117.66 89.91,117.54 90.06,117.47 90.08,117.47 90.2,117.34 90.2,115.37 89.8,114.97 87.6,114.97 84.64,114.97 84.17,115.44 84.17,117.53 84.3,117.66
+3VALW_PCH on BOTTOM (solid shape): 92.24,47.24 92.24,45.75 92.05,45.56 92.05,44.83 91.98,44.76 89.89,44.76 89.76,44.89 89.76,45.87 89.83,45.95 89.89,46.15 89.87,46.24 89.87,47.34 90.15,47.62 91.86,47.62
+3VALW_PCH on BOTTOM (solid shape): 132.06,45.84 132.06,43.06 131.8,42.8 131.7,42.8 131.46,42.57 131.46,41.88 130.69,41.11 130.69,39.88 130.56,39.75 130.56,39.19 130.5,39.12 129.82,39.12 129.72,39.22 129.72,39.78 129.99,40.05 129.99,40.94 129.98,40.94 129.75,41.17 129.54,41.17 129.46,41.24 129.46,42.68 129.49,42.71 130.28,42.71 130.79,43.22 130.79,44.22 130.79,44.22 130.79,44.41 130.52,44.68 129.46,44.68 128.97,45.16 128.97,45.82 129.03,45.88 132.02,45.88
+3VALW_PCH on IN2 (solid shape): 93.54,45.07 93.54,43.45 93.29,43.2 89.45,43.2 89.25,43.39 89.25,44.76 89.8,45.31 93.3,45.31
+3VALW_PCH on IN2 (solid shape): outline of 5002 points within 101,43.98 137.78,62.77
+3VALWP on TOP (solid shape): 27.93,53.54 27.93,50.7 27.64,50.41 24.32,50.41 24.13,50.6 24.13,53.42 24.34,53.64 27.83,53.64
+3VALWP on BOTTOM (solid shape): outline of 186 points within 24.11,47.21 29.21,60.63
+3VGS on BOTTOM (solid shape): 108.8,125.89 110.15,125.89 110.42,125.62 110.42,124.06 110.15,123.79 108.69,123.79 108.52,123.96 108.52,125.79 108.62,125.9 108.8,125.9
+3VGS on BOTTOM (solid shape): 131.76,117.65 131.76,116.78 131.04,116.07 131,116.07 130.9,115.97 130.9,115.93 130.89,115.91 130.89,115.59 130.87,115.57 130.38,115.57 130.36,115.57 130.36,115.55 130.34,115.54 130.34,115.09 130.36,115.07 130.36,115.06 130.37,115.06 130.38,115.05 130.81,115.05 130.88,115.05 130.89,115.04 130.89,114.78 130.88,114.78 130.39,114.78 130.38,114.77 130.36,114.77 130.35,114.74 130.35,114.3 130.36,114.3 130.36,114.26 130.39,114.26 130.41,114.24 130.89,114.24 130.9,114.24 130.9,113.82 131.03,113.68 131.23,113.68 131.45,113.47 131.45,112.75 131.2,112.5 130.32,112.5 130.22,112.6 130.22,113.31 129.89,113.64 129.24,113.64 128.72,114.16 127.01,114.16 126.7,114.48 126.7,115.33 126.97,115.61 128.66,115.61 129.05,115.57 129.24,115.91 129.24,115.98 130.47,117.2 130.47,117.66 130.5,117.74 130.57,117.76 130.67,117.77 130.77,117.79 131.62,117.79
+3VGS_OUT on BOTTOM (solid shape): 133.75,118.16 133.75,116.33 133.7,116.27 132.73,116.27 132.02,115.56 132.02,114.13 131.73,113.84 131.07,113.84 131.03,113.88 131.03,114.37 131.02,114.38 130.49,114.38 130.48,114.39 130.48,114.64 130.49,114.65 131.01,114.65 131.02,114.66 131.02,115.18 130.49,115.18 130.48,115.19 130.48,115.44 130.48,115.44 131.02,115.44 131.03,115.45 131.03,115.91 131.06,115.94 131.45,115.94 132.57,117.06 132.57,117.81 133.03,118.27 133.64,118.27
+3VLP on TOP (solid shape): 21.87,45.17 21.87,43.71 21.71,43.56 21.01,43.56 20.91,43.66 20.91,45.18 21.1,45.36 21.67,45.36
+3VLP on BOTTOM (solid shape): 21.93,45.33 21.93,45.04 21.87,44.98 21.87,43.39 21.84,43.37 21.03,43.37 20.96,43.43 20.96,44.08 21.02,44.17 21.04,44.27 21.04,44.9 21.02,45.01 20.96,45.09 20.96,45.24 21.12,45.4 21.87,45.4
+3VS on TOP (solid shape): 80.97,120.36 80.97,118.92 80.74,118.69 78.62,118.69 78.54,118.77 78.54,120.38 78.75,120.58 80.74,120.58
+3VS on TOP (solid shape): 40.35,57.2 40.37,57.2 40.55,57.02 42.57,57.02 42.66,56.93 42.66,54.71 42.52,54.57 40.1,54.57 39.79,54.88 39.79,56.38 39.54,56.63 39.54,57.28 39.6,57.34 40.21,57.34
+3VS on TOP (solid shape): 78.07,44.09 78.07,43.07 78.32,42.82 78.32,42.34 78.44,42.22 78.82,42.22 79.09,41.96 79.09,41.39 78.9,41.21 78.17,41.21 77.71,41.67 77.17,42.21 77.17,43.22 76.91,43.48 76.61,43.48 76.57,43.49 76.49,43.57 76.49,44.1 76.56,44.18 77.99,44.18
+3VS on TOP (solid shape): 29.34,33.13 29.34,31.62 29.33,31.61 28.97,31.61 28.97,31.61 28.97,32.14 28.96,32.16 28.42,32.16 28.42,32.16 28.42,31.61 28.42,31.61 28.17,31.61 28.17,31.61 28.17,32.16 28.16,32.16 27.62,32.16 27.62,32.16 27.62,31.61 27.62,31.61 27.29,31.61 26.75,32.14 26.75,33.17 26.89,33.31 29.17,33.31
+3VS on TOP (solid shape): 212.85,47.9 212.85,47.3 212.81,47.25 211.78,47.25 211.29,46.76 211.27,46.76 211.17,46.75 211.08,46.72 211.07,46.71 210.91,46.71 210.87,46.76 210.81,46.8 210.68,46.92 210.68,47.04 210.72,47.04 210.93,47.18 210.99,47.42 210.99,47.44 211.53,47.98 212.77,47.98
+3VS on TOP (solid shape): 34.84,105.84 34.84,105.71 34.79,105.66 34.68,105.66 34.55,105.53 34.55,104.81 34.05,104.31 34.03,104.31 33.78,104.2 33.67,103.95 33.67,103.93 33.54,103.79 33.54,103.32 33.51,103.29 33.07,103.29 32.69,102.92 32.43,102.92 32.24,103.11 32.24,103.58 32.82,104.15 32.82,104.78 32.93,104.9 33.27,104.9 33.55,105.18 33.55,105.62 33.83,105.9 34.78,105.9
+3VS on TOP (solid shape): 36.23,21.9 36.23,21.06 36.11,20.87 36.07,20.64 36.07,20.13 36.11,19.91 36.23,19.71 36.23,17.71 36,17.48 34.93,17.48 34.76,17.66 34.76,20.63 34.77,20.65 34.71,20.7 34.71,20.76 34.66,20.76 34.65,20.76 33.52,20.76 33.4,20.89 33.4,21.39 33.39,21.4 33.39,21.48 33.31,21.48 33.14,21.65 32.81,21.65 32.63,21.83 32.63,22.28 32.79,22.44 35.69,22.44
+3VS on TOP (solid shape): 211.26,51.03 211.26,50.14 211.03,49.91 210.94,49.88 210.87,49.94 210.47,50.15 210.18,49.81 210.15,49.74 210.08,49.71 209.56,49.71 209.39,49.88 209.39,51.2 209.52,51.34 210.96,51.34
+3VS on TOP (solid shape): 182.61,34.15 182.61,33.19 182.49,33.08 182.49,32.62 182.9,32.22 182.9,31.64 182.95,31.59 182.95,31.11 182.85,31.01 182.25,31.01 182.22,31.04 182.22,31.47 182.11,31.58 182.11,31.67 182.16,31.85 182.1,32.02 182.07,32.09 182.1,32.15 182.14,32.45 181.88,32.62 181.68,32.62 181.45,32.5 181.42,32.25 180.98,31.81 179.11,31.81 178.88,32.04 178.16,32.04 178.06,32.14 178.06,32.81 178.2,32.95 178.96,32.95 179.16,32.76 179.59,32.76 179.66,32.76 180.65,32.76 180.77,32.87 180.77,33.59 180.95,33.77 181.49,33.77 181.94,34.22 182.53,34.22
+3VS on TOP (solid shape): 215.07,34.18 216.11,34.18 216.13,34.17 216.13,33.18 215.76,32.81 215.73,32.84 215.19,32.3 215.76,31.73 215.78,31.6 215.84,31.49 215.75,31.41 215.75,31.37 215.69,31.3 215.69,30.94 215.94,30.69 216.17,30.69 216.54,30.31 216.81,30.31 216.89,30.31 217.08,30.41 217.19,30.6 217.39,30.81 218.07,30.81 218.28,31.02 218.28,31.1 218.31,31.35 218.13,31.52 218.07,31.58 217.3,31.58 217.3,32.47 218.04,32.47 218.1,32.48 218.16,32.49 218.38,32.49 218.59,31.85 218.79,32.49 219.06,32.49 219.32,32.23 219.32,29.89 218.7,29.26 218.51,29.17 218.42,28.98 218.16,28.72 214.98,28.72 214.68,29.02 214.68,30.1 214.7,30.21 214.68,30.33 214.68,30.47 214.38,30.77 214.38,32.43 214.79,32.84 214.79,32.89 214.8,32.9 214.83,33.06 214.8,33.23 214.79,33.24 214.79,33.34 214.61,33.52 213.97,33.52 213.91,33.57 213.91,34.17 214,34.26 215,34.26
+3VS on TOP (solid shape): outline of 157 points within 52.92,40.24 64.63,49.18
+3VS on BOTTOM (solid shape): 137.96,117.2 137.96,116.7 137.81,116.55 137.18,116.55 137.04,116.4 136.19,116.4 136.06,116.27 135.17,116.27 135.11,116.33 135.11,116.96 135.48,117.33 137.83,117.33
+3VS on BOTTOM (solid shape): 211.26,50.82 211.24,50.79 211.22,50.76 211.2,50.73 211.2,50.54 211.26,50.48 211.26,50.17 211.12,50.03 210.81,50.03 210.6,50.15 210.36,50.11 210.33,50.09 210.06,50.36 210.06,50.79 210.26,50.99 210.77,50.99 210.78,51.01 211.26,51.01
+3VS on IN1 (solid shape): 212.76,50.35 212.76,47.44 212.08,46.76 211.29,46.76 211.2,46.76 211.11,46.73 211.02,46.68 211.01,46.66 210.96,46.66 210.7,46.92 210.7,47.04 210.73,47.05 210.82,47.08 210.9,47.15 210.98,47.28 210.99,47.45 210.99,47.47 210.99,47.78 211.32,48.12 211.34,48.15 211.37,48.17 211.57,48.43 211.48,48.74 211.45,48.81 211.48,48.88 211.53,49.31 211.13,49.47 210.89,49.7 210.89,49.76 210.85,49.98 210.68,50.13 210.65,50.14 210.65,50.56 210.28,50.94 210.28,51.95 210.44,52.11 211,52.11
+3VS on IN2 (solid shape): 212.31,46.93 212.31,46.42 212.05,46.17 211.7,46.17 211.59,46.28 211.6,46.31 211.43,46.72 210.99,46.65 210.87,46.65 210.73,46.79 210.73,47.04 210.74,47.05 210.89,47.14 210.98,47.28 210.98,47.29 211.31,47.62 211.62,47.62
+3VS on IN3 (solid shape): 210.77,56.27 210.77,55.67 210.68,55.58 209.63,55.58 209.47,55.75 209.47,56.24 209.62,56.4 210.64,56.4
+3VS on IN3 (solid shape): 32.65,23.29 32.83,23.29 33.3,22.82 33.66,22.82 33.92,22.56 33.92,21.89 33.65,21.62 32.63,21.62 31.94,22.32 31.94,23.3 32.04,23.4 32.53,23.4
+3VS on IN3 (solid shape): outline of 315 points within 25.4,31.85 39.58,39.86
+3VS on VCC: outline of 113 points within 37.8,32.13 216.89,153.23 ; 1 cut-out
+3VS_CAM on TOP (solid shape): 213.53,46.93 213.66,46.9 213.79,46.93 213.8,46.93 214.12,46.93 214.31,46.74 214.58,46.73 214.7,46.62 214.99,46.62 214.99,45.77 214.88,45.66 213.41,45.66 212.99,45.24 212.99,44.84 212.83,44.69 211.44,44.69 211.3,44.83 211.3,45.38 211.64,45.72 211.64,46.75 211.82,46.93 213.52,46.93
+3VS_CAM on BOTTOM (solid shape): 214.1,47 214.17,46.84 214.31,46.73 214.31,46.45 214.2,46.34 212.89,46.34 212.84,46.29 211.91,46.29 211.8,46.39 211.8,46.55 211.89,46.63 213,46.63 213.37,47
+3VS_SSD on TOP (solid shape): outline of 273 points within 22.77,24.38 30.23,32.89
+3VS_SSD on BOTTOM (solid shape): outline of 646 points within 20.95,23.33 39.73,31.1
+5V_AVDD on TOP (solid shape): 31.61,20.3 31.61,20.18 31.58,20.16 31.58,19.95 31.14,19.5 30.81,19.5 30.81,18.64 30.76,18.6 30.09,18.6 29.98,18.7 29.98,20 30.08,20.1 30.39,20.1 30.4,20.11 30.51,20.11 30.51,20.22 30.51,20.23 30.51,20.3 30.59,20.38 31.53,20.38
+5V_HDD on TOP (solid shape): 182.05,38.29 182.05,37.63 182.06,37.63 182.06,37.51 182.2,37.36 182.2,37.34 182.77,36.77 183.9,36.77 183.98,36.85 184.18,36.85 184.2,36.87 185.74,36.87 186.22,36.39 186.22,35.42 185.72,34.92 184.44,34.92 184.34,34.93 184.23,34.92 183.25,34.92 183.14,34.93 183.04,34.92 182.93,34.92 182.82,34.81 182.78,34.85 182.42,34.93 182.18,34.64 181.44,33.9 180.3,33.9 180.03,34.17 180.03,37.11 179.78,37.36 177.87,37.36 177.68,37.56 177.68,39.2 177.7,39.22 177.75,39.22 177.75,39.23 178.08,39.23 178.08,38.71 178.1,38.7 178.61,38.7 178.63,38.71 178.63,39.23 178.88,39.23 178.88,38.71 178.9,38.7 179.41,38.7 179.43,38.71 179.43,39.23 179.85,39.23 181.11,39.23
+5V_HDD on BOTTOM (solid shape): 185.35,37.98 185.35,37.69 185.82,37.22 185.82,35.03 185.72,34.93 185.19,34.93 185.18,34.92 184.61,34.92 184.53,35 184.53,37.42 184.53,37.43 184.53,37.85 184.74,38.05 185.28,38.05
+5V_HDMI on TOP (solid shape): 17.66,101.27 17.66,98.45 17.55,98.33 15.5,98.33 15.28,98.56 15.28,99.25 15.12,99.41 14.54,99.41 14.38,99.56 14.38,101.18 14.67,101.46 17.48,101.46
+5V_HDMI on IN1 (solid shape): 15.02,101.81 15.02,99.59 14.84,99.41 13.9,99.41 12.9,100.41 12.32,100.41 12.14,100.59 12.14,101.66 12.38,101.9 14.93,101.9
+5V_KB_BL on TOP (solid shape): 50.83,41.78 50.83,40.35 50.65,40.17 47.71,40.17 47.62,40.25 47.62,41.81 47.71,41.9 50.71,41.9
+5V_PVDD on TOP (solid shape): 26.25,10.52 26.25,9.38 26.24,9.38 26.24,8.49 26.12,8.36 25.89,8.36 25.79,8.47 25.79,9.25 25.99,9.46 25.99,10.52 26.07,10.6 26.17,10.6
+5V_PVDD on TOP (solid shape): 28.25,10.55 28.25,9.84 28.74,9.36 29.19,9.36 29.57,8.97 29.57,7.68 29.65,7.6 30.29,7.6 30.36,7.53 30.36,4.14 30.56,3.93 30.56,2.54 31.17,2.54 31.17,1.42 30.96,1.2 29.55,1.2 28.75,2 28.75,4.86 28.84,4.95 28.84,5.52 28.75,5.61 28.75,7.2 28.81,7.26 28.81,8.97 28.02,9.76 28.02,10.57 28.08,10.63 28.18,10.63
+5V_PVDD on IN2 (solid shape): 26.96,9.23 26.96,7.53 26.58,7.15 26.2,7.15 25.76,7.58 25.76,9.15 25.97,9.36 26.83,9.36
+5V_PVDD on IN2 (solid shape): 31.17,5.16 31.17,2.93 31.16,2.92 31.16,1.35 31.06,1.25 29.98,1.25 29.85,1.38 29.85,5.19 30.13,5.47 30.87,5.47
+5VALW on TOP (solid shape): 35.33,50.55 35.33,48.62 35.25,48.54 34.42,48.54 34.36,48.6 34.36,50.53 34.52,50.69 35.19,50.69
+5VALW on TOP (solid shape): 187.24,61.11 187.24,58.92 187.06,58.74 185.37,58.74 185.16,58.95 185.16,60.89 185.16,60.9 185.25,60.99 185.25,61.23 185.52,61.49 186.86,61.49
+5VALW on TOP (solid shape): 32.66,47.26 32.66,46.49 32.59,46.41 32.59,46.1 32.5,46.01 32.5,45.65 32.6,45.55 32.6,44.88 32.5,44.78 31.21,44.78 31.02,44.97 31.02,47.15 31.23,47.35 32.57,47.35
+5VALW on TOP (solid shape): 35.98,24.81 36.11,24.68 36.11,23.66 36.03,23.58 33.77,23.58 33.72,23.63 33.72,24.51 34.01,24.81 34.83,24.81 35.23,24.81
+5VALW on TOP (solid shape): 162.6,31.86 164.52,31.86 164.8,31.59 164.8,30.33 164.62,30.16 164.03,30.16 163.7,30.48 162.29,30.48 162.08,30.69 162.08,32.05 162.15,32.11 162.35,32.11
+5VALW on TOP (solid shape): 181.86,41.77 181.86,40.03 181.68,39.85 181.29,39.85 181.17,39.96 181.17,40.28 180.91,40.55 180.45,40.55 180.21,40.79 180.21,41.35 180.23,41.36 180.91,41.36 181.42,41.88 181.75,41.88
+5VALW on TOP (solid shape): 38.49,129.5 38.49,128.24 38.49,128.24 38.49,127.95 38.57,127.87 38.58,127.78 38.62,127.7 38.62,127 38.31,126.69 36.98,126.69 36.79,126.88 36.79,129.41 37.04,129.66 38.32,129.66
+5VALW on TOP (solid shape): 29.66,112.53 29.66,109.72 29.4,109.46 27.86,109.46 27.86,109.98 27.35,109.98 27.35,109.46 27.06,109.46 27.06,109.98 26.55,109.98 26.55,109.46 25.27,109.46 25.15,109.58 25.15,111.99 25.54,112.38 25.99,112.83 29.36,112.83
+5VALW on TOP (solid shape): 37.89,60.05 37.89,59.74 38.26,59.37 38.26,58.86 38.2,58.8 35.73,58.8 35.68,58.85 35.11,58.85 34.87,59.09 34.87,59.79 35.77,60.68 37.26,60.68
+5VALW on TOP (solid shape): 206.62,35.1 206.62,34.28 206.61,34.28 206.61,34.11 206.57,34.08 206.57,33.72 206.61,33.69 206.61,33.52 206.62,33.52 206.62,33.37 206.61,33.37 206.61,33.2 206.57,33.17 206.57,32.8 206.61,32.77 206.61,32.61 206.51,32.52 205.86,32.52 205.05,33.32 205.05,35.24 205.22,35.4 206.32,35.4
+5VALW on TOP (solid shape): 62.31,120.13 62.31,119.23 62.42,119.12 62.42,118.82 60.99,117.39 59.63,117.39 59.55,117.46 59.55,118.03 59.8,118.27 60.64,118.27 60.66,118.29 60.69,118.29 60.97,118.57 60.98,118.57 61.16,118.71 61.23,118.93 61.23,118.98 61.23,119.06 61.2,119.14 61.2,119.23 60.93,119.5 60.93,119.98 61.22,120.27 62.18,120.27
+5VALW on TOP (solid shape): 71.74,116.76 71.74,116.01 71.63,115.9 70.9,115.9 70.9,115.9 70.59,115.9 70.19,115.8 70.32,115.41 70.35,115.4 70.35,114.06 70.22,113.93 68.26,113.93 68.13,114.06 68.13,115.18 68.32,115.37 69.09,115.37 69.18,115.46 69.18,116.64 69.43,116.89 71.62,116.89
+5VALW on TOP (solid shape): 199.45,37.84 199.45,36.7 199.17,36.42 199.17,36.07 199.14,36.05 198.89,35.72 199.13,35.38 199.17,35.37 199.17,35.34 199.17,35.27 199.73,34.71 199.73,32.36 199.53,32.15 197.4,32.15 197.25,32.31 197.25,32.92 197.2,32.97 197.05,32.97 197.03,32.99 196.67,32.99 196.4,33.26 196.4,35.06 197.04,35.7 197.04,36.32 196.72,36.63 196.72,37.66 197.1,38.04 199.25,38.04
+5VALW on TOP (solid shape): outline of 92 points within 128.72,108.87 138.06,114.79
+5VALW on BOTTOM (solid shape): 136.32,115.37 136.32,114.85 136.52,114.65 137.61,114.65 137.83,114.44 137.83,113.71 137.65,113.53 135.92,113.53 135.47,113.98 135.47,114.84 135.09,115.22 135.09,115.49 135.15,115.55 136.14,115.55
+5VALW on BOTTOM (solid shape): 29.43,112.44 29.43,109.64 29.28,109.49 28.18,109.49 27.86,109.49 27.86,110.02 27.35,110.02 27.35,109.49 27.06,109.49 27.06,110.02 26.55,110.02 26.55,109.49 25.45,109.49 25.34,109.6 25.34,112.44 25.59,112.69 29.18,112.69
+5VALW on BOTTOM (solid shape): 128.43,111.24 128.43,111.08 129.05,111.08 129.29,110.84 129.29,110.16 129.36,110.09 130.31,110.09 130.55,109.85 130.55,109.14 130.41,109 128.99,109 128.86,109.13 128.86,109.89 128.12,110.64 128.05,110.69 127.97,110.73 127.95,110.73 127.88,110.8 127.74,110.8 127.64,110.9 127.64,110.9 127.54,110.99 126.83,110.99 126.77,111.06 126.77,111.16 126.83,111.22 127.53,111.22 127.55,111.25 128.24,111.25 128.25,111.25 128.41,111.25
+5VALW on BOTTOM (solid shape): 19.38,50.5 19.38,49.69 19.33,49.61 19.22,49.61 18.7,49.39 19.05,48.94 19.15,48.88 19.13,48.77 18.91,48.55 18.18,48.55 18.13,48.5 17.9,48.5 17.9,48.27 17.65,48.01 17.44,48.01 16.96,47.53 15.19,47.53 14.93,47.79 14.93,47.86 14.7,48.09 14.7,48.5 15.1,48.89 16.12,48.89 16.61,49.37 16.61,50.3 16.95,50.64 19.24,50.64
+5VALW on BOTTOM (solid shape): 38.46,131.68 38.46,127.8 38.66,127.6 38.68,127.6 38.74,127.57 38.79,127.55 38.97,127.53 39.14,127.6 40.21,127.6 40.7,127.11 40.71,126.63 41.2,126.61 41.38,126.42 41.38,124.34 40.97,123.93 40.13,123.93 40.01,124.04 40,124.11 39.98,124.17 39.98,124.4 40.1,124.52 40.33,124.52 40.55,124.75 40.55,124.88 40.56,124.89 40.6,125.05 40.56,125.2 40.55,125.21 40.55,125.54 40.56,125.55 40.52,125.87 40.23,126.02 40.21,126.03 40.08,126.16 39.46,126.16 38.88,126.74 38.82,126.84 38.72,126.9 38.64,126.92 38.56,126.91 38.22,126.91 38.14,126.92 38.06,126.91 37.72,126.91 37.64,126.92 37.56,126.91 37.21,126.91 37.14,126.92 37.09,126.91 36.99,127.01 36.99,129.11 37.02,129.23 36.99,129.35 36.99,129.85 37.37,130.23 37.37,131.69 37.47,131.8 38.35,131.8
+5VALW on BOTTOM (solid shape): outline of 279 points within 60.85,114.04 70.43,120.51
+5VALW on IN1 (solid shape): 31.58,46.83 31.58,44.45 31.23,44.09 30.01,44.09 29.75,44.34 29.75,46.58 30.23,47.06 31.35,47.06
+5VALW on IN1 (solid shape): 25.35,39.95 25.35,39.75 24.16,38.57 22.89,38.57 22.74,38.72 22.74,39.63 23.82,40.71 24.58,40.71
+5VALW on IN1 (solid shape): 170.75,52.23 170.75,51.89 169.85,50.99 169.03,50.17 167.84,50.17 167.61,50.4 167.61,50.87 169.23,52.49 170.49,52.49
+5VALW on IN1 (solid shape): 160.86,69.2 160.86,67.92 160.7,67.76 160.23,67.59 160.39,67.11 160.39,66.39 160.17,66.17 159.11,66.17 158.9,66.38 158.9,67.6 159.23,67.92 159.23,69.25 159.47,69.5 160.57,69.5
+5VALW on IN1 (solid shape): outline of 797 points within 39.89,118.53 62.79,125.45
+5VALW on IN2 (solid shape): 202.56,34.01 204.28,34.01 204.61,34.34 206.45,34.34 206.75,34.03 206.75,32.52 206.44,32.21 197.37,32.21 197.29,32.28 197.29,34.11 197.52,34.34 202.23,34.34
+5VALW on IN2 (solid shape): outline of 154 points within 108.16,108.47 130.56,112.35
+5VALW on IN2 (solid shape): outline of 233 points within 68.21,112.63 81.69,116.45
+5VALW on IN2 (solid shape): outline of 409 points within 136.29,111.3 147.75,117.48
+5VALW on IN2 (solid shape): outline of 1040 points within 23.81,110.83 38.61,128.52
+5VALW on IN2 (solid shape): outline of 2462 points within 155.67,65.11 167,94.05
+5VALW on IN3 (solid shape): 161.45,95.31 161.45,93.92 160.82,93.29 158.75,93.29 158.24,92.78 157.23,92.78 156.55,93.47 156.23,93.47 156.14,93.55 156.14,94.06 158.18,94.06 158.18,94.01 158.19,93.95 158.21,93.9 158.23,93.86 158.26,93.81 158.29,93.77 158.34,93.74 158.38,93.71 158.43,93.69 158.48,93.68 158.54,93.68 158.59,93.68 158.64,93.69 158.69,93.71 158.74,93.74 158.78,93.77 158.82,93.81 158.85,93.86 158.87,93.9 158.89,93.95 158.89,94.01 158.89,94.06 158.89,94.11 158.87,94.16 158.85,94.21 158.82,94.26 158.78,94.3 158.74,94.33 158.69,94.35 158.64,94.37 158.59,94.39 158.54,94.39 158.48,94.39 158.43,94.37 158.38,94.35 158.34,94.33 158.29,94.3 158.26,94.26 158.23,94.21 158.21,94.16 158.19,94.11 158.18,94.06 156.14,94.06 156.14,94.36 157.29,95.51 157.32,95.52 161.24,95.52
+5VALW on IN3 (solid shape): outline of 117 points within 36.98,123.93 41.25,128.85
+5VALW on IN3 (solid shape): outline of 305 points within 144.05,110.13 157.22,116.47
+5VALW on IN3 (solid shape): outline of 625 points within 14.7,38.03 36.83,51.24
+5VALW on IN3 (solid shape): outline of 1625 points within 158.78,60.09 186.39,71.34
+5VALW on VCC: 31.13,57.27 26.53,61.86 26.53,75.26 27.29,76.03 27.29,107.99 26.2,109.08 26.2,112.92 26.75,113.47 33.08,113.47 33.97,114.36 37.56,114.36 37.56,114.36 37.56,62.26 37.27,61.97 37.27,57.27
+5VALW on IN2: 37.61,60.42 37.61,58.03 37.18,57.6 37.18,55.36 37.15,55.28 37.08,55.25 36.76,55.05 36.81,54.66 36.84,54.6 36.81,54.53 36.78,54.48 36.77,54.47 36.76,54.45 36.74,54.31 36.76,54.17 36.77,54.16 36.77,53.88 36.74,53.8 36.74,53.72 36.74,53.65 36.77,53.57 36.77,53.3 36.76,53.29 36.72,53.13 36.76,52.97 36.77,52.95 36.77,52.68 36.76,52.67 36.74,52.54 36.76,52.4 36.77,52.39 36.77,52 36.13,51.35 36.13,49.87 35.23,48.97 35.23,45.21 34.93,44.91 34.86,44.89 34.79,44.92 34.39,45.01 34.16,44.68 34.14,44.6 34.06,44.57 30.34,44.57 29.89,45.02 29.89,48.81 33.68,52.6 33.68,60.27 34.28,60.87 37.16,60.87
+5VALWP on TOP (solid shape): 26.93,109.33 26.95,109.33 27.46,109.33 27.48,109.33 27.48,109.85 27.72,109.85 27.73,109.84 27.73,109.33 27.75,109.33 28.24,109.33 28.26,109.31 28.79,109.31 28.82,109.28 28.86,109.28 28.99,109.15 28.99,109.11 29.02,109.08 29.02,107.05 28.99,107.02 28.99,106.93 28.39,106.33 23.53,106.33 23.12,105.92 23.12,104.05 23.26,103.9 23.51,103.9 23.58,103.9 23.65,103.9 24.15,103.9 24.23,103.9 24.37,103.91 24.45,103.83 24.45,102.58 24.33,102.46 23.12,102.46 23.11,102.47 23,102.49 22.88,102.47 22.87,102.46 22.09,102.46 21.08,103.47 16.94,103.47 16.73,103.67 16.73,107.15 16.91,107.32 21.31,107.32 23.32,109.33 26.66,109.33 26.68,109.33 26.68,109.85 26.93,109.85
+5VALWP on BOTTOM (solid shape): 28.99,109.15 28.99,106.93 28.39,106.33 23.61,106.33 23.12,105.83 23.12,104.05 22.32,103.25 21.3,103.25 21.08,103.47 16.95,103.47 16.73,103.69 16.73,107.63 17.13,108.03 17.17,108.01 20.01,107.59 22.34,109.28 28.86,109.28
+5VS on TOP (solid shape): 33.69,3.79 33.69,2.65 33.54,2.5 31.53,2.5 31.4,2.62 31.4,3.92 31.43,3.95 33.54,3.95
+5VS on TOP (solid shape): 195.85,64.85 195.85,61.86 195.57,61.57 193.77,61.57 193.55,61.79 193.55,62.12 193.23,62.44 193.23,64.76 193.43,64.95 195.75,64.95
+5VS on TOP (solid shape): 218.18,25.8 218.18,25.8 218.23,25.75 218.23,24.87 218.15,24.79 216.66,24.79 216.5,24.95 216.5,25.69 216.76,25.95 218.03,25.95
+5VS on TOP (solid shape): 175.14,45.31 175.14,44.86 175.48,44.53 175.48,43.65 175.4,43.57 174.72,43.57 174.68,43.61 174.68,44.22 174.48,44.42 173.81,44.42 173.59,44.64 173.59,45.26 173.8,45.46 174.99,45.46
+5VS on TOP (solid shape): 39.59,60.58 40.83,60.58 41.33,60.08 41.38,60.08 42.02,60.08 42.06,60.04 42.82,60.04 42.96,59.9 42.96,58.89 42.43,58.35 41.11,58.35 40.72,58.73 39.72,58.73 39.59,58.86 39.59,59.5 39.35,59.74 39.19,59.74 38.84,60.09 38.84,60.75 38.86,60.76 39.41,60.76
+5VS on TOP (solid shape): 176.83,40.44 178.92,40.44 179.13,40.23 179.76,40.23 179.89,40.1 179.89,39.45 179.8,39.36 179.3,39.36 179.3,38.83 179.01,38.83 179.01,39.36 178.5,39.36 178.5,38.83 178.21,38.83 178.21,39.36 177.4,39.36 177.33,39.44 176.14,39.44 176.01,39.57 176.01,40.28 176.19,40.46 176.82,40.46
+5VS on BOTTOM (solid shape): 26.7,31.96 26.7,29.32 26.49,29.11 25.33,29.11 25.09,29.35 25.09,31.94 25.36,32.2 26.46,32.2
+5VS on BOTTOM (solid shape): 35.54,31.38 35.54,29.8 35.34,29.6 32.58,29.6 32.19,29.99 32.19,30.89 32.47,31.17 33.87,31.17 34.17,31.48 35.44,31.48
+5VS on IN2 (solid shape): outline of 97 points within 217.22,24.66 219.42,29.19
+5VS on IN2 (solid shape): outline of 1185 points within 34.12,29.75 42.91,60.36
+5VS on IN3 (solid shape): 35.44,4.73 35.44,4.3 35.29,4.13 35.16,3.94 35.15,3.94 33.79,2.57 32.7,2.57 32.5,2.78 32.5,3.74 34.12,5.37 34.81,5.37
+5VS on IN3 (solid shape): 27.09,29.85 27.71,29.85 28.28,29.28 28.28,28.62 27.95,28.29 25.65,28.29 24.93,29.01 24.93,30.2 25.23,30.5 26.44,30.5
+5VS on IN3 (solid shape): outline of 136 points within 31.86,19.11 36.03,26.5
+5VS on VCC: 181.51,60.92 182.11,60.32 186,60.32 186.98,61.29 186.98,70.32 191.66,68.14 192.4,67.94 193.17,68.02 193.53,68.12 194.56,68.27 195.59,68.13 200.98,67.06 206.47,66.73 206.47,48.51 158.13,48.51 154.74,51.9 151.86,51.9 151.86,57.18 152.46,57.78 152.46,60.64 152.99,61.17 152.99,62.77 152.28,63.48 151.86,63.48 151.86,67.64 156.68,72.46 156.68,78.14 155.07,79.75 155.07,90.26 153.83,91.5 153.83,104.43 152.62,105.65 139.43,105.65 139.35,105.57 126.13,105.57 122.43,101.87 116.18,108.12 90.78,108.12 87.61,111.29 58.19,111.29 56.14,109.24 56.14,57.46 40.53,57.46 40.29,57.7 40.29,59.24 40.12,59.42 40.12,59.97 43.31,63.17 43.31,63.38 43.29,110.24 50,117 93.15,117.03 95.75,114.42 119.96,114.42 120.97,115.43 134.17,115.43 136.61,112.99 139.41,112.99 139.81,113.39 141.13,112.07 158.42,112.07 161.58,108.92 161.58,100.64 168.36,93.58 168.64,93.3 168.64,89.06 169.2,88.5 169.2,82.86 170.11,81.94 170.11,77.47 181.39,66.2 181.39,66.18 181.37,61.28 ; 2 cut-outs
+5VS_ODD on TOP (solid shape): 193.53,68.12 194.56,68.27 195.59,68.13 195.85,68.06 197.54,67.65 199.25,67.32 199.34,67.3 199.63,67.25 199.94,67.2 200.06,67.08 200.06,65.93 200.05,65.92 200.03,65.8 200.05,65.68 200.06,65.67 200.06,63.36 200.58,62.84 200.58,62.83 200.58,61.21 200.51,61.14 199.12,61.14 198.88,60.9 198.88,60.43 198.77,60.32 197.62,60.32 197.49,60.44 197.49,61.77 197.22,62.04 196.2,62.04 195.98,62.26 195.98,63.2 196.51,63.2 196.51,63.7 195.98,63.7 195.98,64 196.51,64 196.51,64.5 195.98,64.5 195.98,64.91 195.79,65.1 193.09,65.1 192.77,65.42 192.77,67.91 192.8,67.95 192.82,67.95 193,67.98 193.17,68.02
+5VS_ODD on BOTTOM (solid shape): 195.48,67.95 195.48,63.65 195.42,63.6 192.98,63.6 192.83,63.75 192.83,67.86 192.93,67.96 193.05,67.99 193.16,68.01 195.41,68.01
+17.4V_BATT+ on BOTTOM (solid shape): 148.41,36.36 148.96,36.36 148.96,36.89 149.18,36.89 149.2,36.86 149.2,36.32 150.13,36.32 150.15,36.3 150.58,36.3 151.08,35.81 151.08,33.65 151.21,33.51 151.29,33.51 151.39,33.41 151.39,33.41 151.44,33.36 151.44,32.9 150.11,31.57 147.67,31.57 147.13,32.11 147.13,33.76 147.01,33.87 146.28,33.87 146.15,34 146.15,34.52 146.24,34.61 146.25,34.61 146.3,34.56 146.59,34.56 146.64,34.61 146.76,34.61 146.95,34.79 146.95,35.79 147,35.87 147.43,35.91 147.59,36.21 147.62,36.28 147.69,36.31 147.78,36.31 147.78,36.36 148.16,36.36 148.16,36.89 148.41,36.89
+17.4V_BATT++ on BOTTOM (solid shape): outline of 158 points within 147.12,36.48 159.55,40.92
+19V_ADPIN on TOP (solid shape): 88.17,143.86 88.19,143.86 88.19,143.85 88.69,143.85 88.69,143.86 88.72,143.86 88.72,144.38 88.95,144.38 88.97,144.36 88.97,143.86 88.99,143.86 88.99,143.85 89.57,143.85 89.57,143.86 89.78,143.86 89.86,143.83 89.89,143.76 89.92,143.63 89.99,143.52 90.04,143.48 90.1,143.45 90.13,143.43 90.13,142.31 89.8,141.99 89.8,139.86 89.7,139.76 84.33,139.76 84.19,139.9 84.19,140.57 84.19,140.57 84.19,141.1 84.29,141.26 84.32,141.43 84.32,141.71 84.16,142.07 83.78,142.19 83.75,142.19 83.65,142.29 83.65,143.23 83.87,143.44 85.82,143.44 86.23,143.85 87.89,143.85 87.89,143.86 87.92,143.86 87.92,144.38 88.17,144.38
+19V_ADPIN on BOTTOM (solid shape): 86.08,144.72 86.08,141.11 85.75,140.77 83.05,140.77 82.79,141.04 82.79,144.65 83.02,144.88 85.92,144.88
+19VB on TOP (solid shape): 69.52,23.58 69.37,23.43 58.26,23.43 58.18,23.51 58.18,24.77 58.39,24.99 67.56,24.99 67.8,25.23 69.52,25.23
+19VB on TOP (solid shape): 180.22,26.81 180.22,24.98 179.96,24.72 175.99,24.72 175.97,24.74 175.97,26.86 176.22,27.11 179.92,27.11
+19VB on TOP (solid shape): 168.67,56.06 168.67,54.87 168.51,54.7 166.1,54.7 165.92,54.87 165.92,55.26 166.46,55.26 166.46,55.7 165.92,55.7 165.92,56.14 166.08,56.3 168.43,56.3
+19VB on TOP (solid shape): 50.84,25.24 51.27,25.24 51.27,25.79 51.68,25.79 51.89,25.58 51.89,25.01 52.16,24.75 52.16,23.93 51.91,23.69 47.83,23.69 47.74,23.78 47.74,23.78 47.65,23.88 47.65,24.39 48.1,24.84 48.1,25.4 48.13,25.43 50.18,25.43 50.54,25.79 50.84,25.79
+19VB on TOP (solid shape): 188.09,46.16 188.09,43.41 188.48,43.02 189.51,43.02 190.39,42.14 190.72,42.14 191.27,41.59 191.27,39.72 191.09,39.54 185.73,39.54 185.43,39.84 185.43,41.28 184.95,41.77 184.95,43.19 184.5,43.64 180.95,43.64 180.73,43.86 180.73,46.21 180.94,46.42 187.84,46.42
+19VB on TOP (solid shape): outline of 468 points within 200.58,53.37 208.39,67.04
+19VB on BOTTOM (solid shape): 168.63,56.4 168.63,56.4 168.66,56.37 168.66,55.6 168.69,55.56 168.69,54.8 168.53,54.64 167.72,54.64 166.96,55.41 166.8,55.41 166.8,56.94 168.09,56.94
+19VB on BOTTOM (solid shape): 17.41,38.4 20.24,38.4 20.24,37.85 20.67,37.85 20.67,38.4 21.03,38.4 21.26,38.16 21.26,36.66 20.6,36.01 18.93,36.01 18.54,35.62 16.31,35.62 15.99,35.94 15.99,38.49 16.16,38.66 17.14,38.66
+19VB on BOTTOM (solid shape): 135.71,113.02 136.83,113.02 136.89,112.96 136.89,110.89 136.77,110.77 134.94,110.77 134.72,110.55 134.15,110.55 134.15,111.08 133.72,111.08 133.72,110.55 133.04,110.55 132.77,110.81 132.77,112.47 133.14,112.83 133.95,112.83 134.53,113.41 135.32,113.41
+19VB on BOTTOM (solid shape): 168.21,104.31 168.21,103.29 168.09,103.17 164.24,103.17 162.6,101.52 161.28,101.52 161.28,100.98 161.03,100.98 161.03,101.51 160.48,101.51 160.48,100.98 160.24,100.98 160.24,101.51 159.13,101.51 158.82,101.82 158.82,103.29 159.96,104.44 168.09,104.44
+19VB on BOTTOM (solid shape): 90.27,141.66 91.15,141.66 91.16,141.65 91.16,138.74 90.9,138.49 88.74,138.49 88.49,138.74 88.49,139.73 87.93,139.73 87.88,139.78 87.88,140 88.43,140 88.43,140.5 87.88,140.5 87.88,140.73 87.91,140.75 88.49,140.75 88.49,141.68 88.65,141.84 90.09,141.84
+19VB on BOTTOM (solid shape): 210.66,54.98 210.66,53.71 210.94,53.42 210.94,53.32 210.94,53.31 210.9,53.13 210.94,52.95 210.94,52.94 210.94,51.51 207.79,51.51 207.77,51.53 207.77,52.88 207.43,53.22 206.55,53.22 206.49,53.28 205.5,53.28 205.35,53.43 205.35,54.77 205.42,54.84 207.07,54.84 207.36,55.13 210.51,55.13
