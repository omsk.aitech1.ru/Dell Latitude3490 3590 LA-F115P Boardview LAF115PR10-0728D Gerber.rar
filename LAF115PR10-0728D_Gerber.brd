# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+19VB on BOTTOM (solid shape): 172.58,80.7 173.28,79.74 173.99,78.77 173.99,78.01 175.85,76.15 175.85,75.7 175.56,75.42 175.18,75.42 175.1,75.5 174.34,75.5 174.15,75.31 172.12,75.31 169.34,78.09 169.34,78.48 169.96,79.1 170.37,79.52 170.37,79.55 170.02,79.9 170.2,80.08 170.55,79.72 170.58,79.72 170.94,80.08 170.94,80.12 170.59,80.47 170.76,80.64 171.11,80.29 171.15,80.29 171.65,80.79 172.49,80.79
+19VB on BOTTOM (solid shape): outline of 162 points within 26.59,93.63 33.81,105.55
+19VB on BOTTOM (solid shape): outline of 813 points within 171.6,24.63 195.74,47.38
+19VB on IN1 (solid shape): 136,113.25 137.16,113.25 137.29,113.13 137.29,112.13 137.08,111.92 134.69,111.92 134.22,112.39 134.22,113.11 134.57,113.46 135.8,113.46
+19VB on IN1 (solid shape): outline of 271 points within 159.89,102.99 170.67,117.72
+19VB on IN1 (solid shape): outline of 1446 points within 86.54,138.63 135.13,153.9
+19VB on IN2 (solid shape): 169.17,55.82 169.17,55.44 169.4,55.2 169.4,53.83 168.66,53.83 167.65,54.84 167.65,55.96 167.93,56.24 168.74,56.24
+19VB on IN2 (solid shape): 180.15,26.86 180.15,24.99 179.78,24.62 176.14,24.62 175.87,24.9 175.87,26.25 176.02,26.41 176.98,26.41 177.53,26.96 180.04,26.96
+19VB on IN2 (solid shape): outline of 2213 points within 185.48,40.27 209.71,57.19
+19VB on IN2 (solid shape): outline of 5669 points within 16.02,21.81 148.62,97.2
+19VB on IN3 (solid shape): outline of 1589 points within 160.82,63.8 202.28,118.74
+19VB on GND1: outline of 90 points within 86.57,103.25 171.69,155.3
+19VB_1.2V on TOP (solid shape): 43.89,28.13 49.54,28.13 50.18,27.49 51.8,27.49 52.02,27.27 52.02,26 51.95,25.94 47.23,25.94 46.95,26.22 46.39,26.22 46.21,26.04 44.11,26.04 43.54,25.47 43.54,24.72 43.4,24.58 41.62,24.58 41.54,24.66 41.54,27.64 41.6,27.71 41.6,28.47 41.71,28.58 43.43,28.58
+19VB_1.2V on BOTTOM (solid shape): 46.38,29.35 46.38,27.11 46.29,27.01 43.57,27.01 43.39,26.83 43.39,25.54 43.39,25.54 43.39,24.73 43.2,24.54 41.54,24.54 41.44,24.64 41.44,28.4 41.59,28.55 43.1,28.55 43.26,28.72 43.26,28.89 43.62,28.89 43.62,28.31 43.71,28.22 43.71,27.8 43.81,27.7 44.24,27.7 44.44,27.91 44.44,28.9 44.21,29.13 43.86,29.13 43.62,28.89 43.26,28.89 43.26,28.91 43.37,29.01 43.37,29.2 43.7,29.54 43.73,29.54 43.78,29.55 43.82,29.56 43.87,29.58 43.91,29.61 43.92,29.62 46.11,29.62
+19VB_1.2V on IN1 (solid shape): 43.71,28.01 43.71,27.38 42.83,26.5 41.98,26.5 41.66,26.82 41.66,28.07 41.66,28.42 41.81,28.56 43.15,28.56
+19VB_+1.35VGPU on TOP (solid shape): 140.58,109.91 140.58,108.54 140.37,108.33 138.91,108.33 138.7,108.54 138.7,109.77 139.04,110.1 140.39,110.1
+19VB_+1.35VGPU on BOTTOM (solid shape): 136.91,110.36 139.99,110.36 140.62,109.72 140.62,109.13 140.94,108.82 143.24,108.82 143.35,108.71 143.35,108.58 143.27,108.5 140.62,108.5 140.38,108.25 139.03,108.25 138.72,107.95 133.21,107.95 132.95,108.2 132.95,110.24 133.11,110.4 136.87,110.4
+19VB_+1VALW on TOP (solid shape): 165.75,56.03 165.75,54.52 165.43,54.21 164.49,54.21 164.07,53.78 161.91,53.78 161.1,54.59 159.85,54.59 159.72,54.72 159.72,55.29 159.8,55.37 161.39,55.37 161.56,55.54 163.23,55.54 163.82,56.13 165.65,56.13
+19VB_+1VALW on BOTTOM (solid shape): 166.09,57.02 166.09,55.62 165.97,55.51 164.68,55.51 164.48,55.31 164.48,54.27 164.01,53.81 162.56,53.81 162.24,53.49 162.24,51.1 162.16,51.02 162.05,51.02 161.96,51.11 161.96,53.27 161.49,53.74 161.49,54.2 160.97,54.72 159.88,54.72 159.72,54.87 159.72,55.28 159.88,55.43 161.51,55.43 161.7,55.61 163.11,55.61 163.37,55.88 164.17,55.88 164.32,56.02 164.32,56.52 164.54,56.74 164.94,56.74 165.11,56.9 165.11,57.02 165.24,57.15 165.96,57.15
+19VB_CPU on TOP (solid shape): 169.77,81.72 169.77,77.27 169.45,76.96 166.28,76.96 165.82,77.41 165.82,82.44 165.92,82.54 168.95,82.54
+19VB_CPU on TOP (solid shape): 168.93,69.48 168.93,68.82 169.4,68.34 170.19,68.34 170.38,68.15 170.38,66.21 170.26,66.1 168.88,66.1 168.37,66.61 167.29,66.61 166.87,67.03 166.87,69.62 167.23,69.97 168.44,69.97
+19VB_CPU on BOTTOM (solid shape): 167.17,61.83 167.17,60.84 166.94,60.62 166.47,60.62 166.47,60.62 165.63,60.62 165.62,60.62 165.39,60.62 165.35,60.57 164.31,60.57 164.18,60.7 164.18,61.02 164.31,61.15 164.75,61.15 164.75,61.72 164.25,61.72 164.18,61.78 164.18,61.97 164.31,62.1 166.9,62.1
+19VB_CPU on BOTTOM (solid shape): outline of 128 points within 163.82,66.99 172.3,86.63
+19VB_CPU on IN3 (solid shape): outline of 91 points within 165.99,68.99 172.76,80.2
+19VB_VGA on TOP (solid shape): outline of 85 points within 80.95,120.98 89.49,125.83
+19VB_VGA on TOP (solid shape): outline of 102 points within 80.73,134.26 89.16,138.57
+19VB_VGA on BOTTOM (solid shape): outline of 93 points within 80.98,121 89.19,125.83
+19VB_VGA on BOTTOM (solid shape): outline of 150 points within 81.09,134.16 89.36,141.81
+19VB_VGA on IN2 (solid shape): outline of 697 points within 78.27,123.48 88.3,140
+VBUS_DC_SS on TOP (solid shape): outline of 201 points within 52.54,132.58 62.84,140.27
+VBUS_DC_SS on BOTTOM (solid shape): 205.71,56.62 205.94,56.62 207.17,56.62 207.25,56.54 207.25,55.75 205.87,55.75 205.66,55.54 205.27,55.54 205.16,55.65 205.16,56.53 205.29,56.66 205.67,56.66
+VBUS_DC_SS on IN2 (solid shape): 206.28,56.4 206.28,56.27 205.63,55.62 205.2,55.62 204.12,56.7 204.12,56.87 204.9,57.65 205.03,57.65
+VCC_CORE on TOP (solid shape): outline of 2171 points within 120.18,66.23 157.39,86.53
+VCC_CORE on BOTTOM (solid shape): 148.57,80.09 148.57,79.76 148.4,79.59 145.27,79.59 145.2,79.66 145.2,80.2 145.32,80.32 148.34,80.32
+VCC_CORE on BOTTOM (solid shape): 155.96,83.9 155.96,83.04 156.03,82.96 157.23,82.96 157.23,82.08 157.99,82.08 157.99,82.96 159.36,82.96 159.39,82.93 159.39,80.56 158.5,79.67 158.5,79.66 157.49,78.65 157.49,74.79 157.29,74.58 157.29,72.65 157.59,72.35 158.7,72.35 159.1,71.94 159.1,70.23 158.77,69.89 157.23,69.89 157.23,70.78 156.47,70.78 156.47,69.89 154.62,69.89 153.54,68.81 150.31,68.81 148.86,67.37 144.26,67.37 144.08,67.55 144.08,69.96 144.65,70.53 146.88,70.53 148.08,71.73 148.08,77 149.31,78.22 149.31,80.47 149.12,80.66 149.12,82.93 148.77,83.28 148.77,86.12 149.1,86.45 153.41,86.45
+VCC_CORE on BOTTOM (solid shape): 121.32,72.89 121.63,72.89 121.65,72.91 121.73,72.91 121.9,72.73 121.9,71.78 121.88,71.75 121.86,71.71 121.8,71.66 121.71,71.67 121.49,71.73 121.28,71.61 120.89,71.61 120.88,71.62 120.5,71.4 120.88,71.18 120.89,71.18 121.28,71.18 121.5,71.07 121.74,71.14 121.85,71.15 121.9,71.06 121.9,69.95 121.85,69.86 121.75,69.86 121.54,69.89 121.35,69.79 120.89,69.79 120.88,69.79 120.5,69.57 120.88,69.35 120.89,69.35 121.35,69.35 121.54,69.24 121.75,69.28 121.85,69.27 121.9,69.19 121.9,68.79 121.85,68.74 121.67,68.74 121.61,68.68 121.6,68.67 121.49,68.61 121.41,68.52 121.4,68.49 121.33,68.49 121.29,68.44 121.26,68.45 121.02,68.35 120.99,68.1 121,68.07 120.94,68 120.28,68 120.05,68.23 120.05,72.12 120.82,72.89 121.12,72.89 121.15,72.91 121.29,72.91
+VCC_CORE on BOTTOM (solid shape): outline of 326 points within 130.26,67.04 133.16,74.73
+VCC_CORE on IN1 (solid shape): outline of 1162 points within 120.94,65.46 131.61,77.66
+VCC_CORE on IN2 (solid shape): outline of 2076 points within 121.37,66.3 158.12,86.6
+VCC_CORE on IN3 (solid shape): outline of 1115 points within 121.34,65.34 131.63,74.56
+VCC_CORE on VCC: 139.36,63.46 135.34,67.48 118.24,67.48 118.24,72.83 118.87,73.47 118.87,78.04 134.52,78.04 134.57,77.99 134.78,77.99 148.98,92.18 150.53,92.18 152.59,94.24 153.32,94.24 153.32,91.29 154.56,90.05 154.56,79.54 156.17,77.93 156.17,72.67 151.35,67.86 151.35,63.46
+VCC_CORE_42 on TOP (solid shape): 120.96,77.71 120.96,76.74 121.22,76.48 122.28,76.48 122.5,76.71 122.5,77.22 122.64,77.36 123.35,77.36 123.57,77.14 123.57,75.01 123.57,75 123.57,74.75 123.48,74.66 121.64,74.66 121.47,74.82 121.15,74.82 120.85,75.12 120.33,75.64 120.33,77.68 120.4,77.76 120.91,77.76
+VCC_CORE_42 on BOTTOM (solid shape): 120.51,79.24 120.51,78.76 120.5,78.71 120.51,78.54 120.65,78.4 120.99,78.4 121.01,78.41 121.31,78.41 121.32,78.41 121.42,78.31 121.42,77.26 121.4,77.23 121.37,77.21 121.29,77.2 121.22,77.16 120.95,77.16 120.93,77.19 120.83,77.19 120.78,77.14 120.76,77.14 120.63,77.11 120.54,77.01 120.56,76.73 120.83,76.64 120.85,76.65 120.92,76.58 121.26,76.58 121.27,76.58 121.4,76.55 121.52,76.58 121.53,76.58 121.66,76.58 121.99,76.25 121.99,74.21 121.31,73.53 121.15,73.53 120.59,74.1 120.59,74.35 121.02,74.79 121.03,74.79 121.03,75.42 121.04,75.43 121.04,75.48 120.88,75.64 120.82,75.64 120.59,75.86 120.59,76.16 120.53,76.23 120.53,76.34 120.54,76.43 120.53,76.55 120.22,76.85 120.22,76.87 120.18,77.04 120.06,77.17 120.06,79.23 120.17,79.33 120.42,79.33
+VCC_GT on TOP (solid shape): outline of 162 points within 144.05,94.14 153.4,107.02
+VCC_GT on TOP (solid shape): outline of 3631 points within 115.69,78.81 137.34,91.72
+VCC_GT on BOTTOM (solid shape): outline of 198 points within 141.19,94.19 155.1,106.97
+VCC_GT on BOTTOM (solid shape): outline of 1458 points within 122.79,79.56 132.24,91.9
+VCC_GT on IN1 (solid shape): outline of 1348 points within 121.66,78.49 130.08,90.59
+VCC_GT on IN2 (solid shape): outline of 3991 points within 121.09,78.71 153.93,103.23
+VCC_GT on IN3 (solid shape): outline of 1338 points within 121.4,74.79 131.37,91.35
+VCC_GT on VCC: 118.87,78.54 118.87,89.98 122.68,93.79 122.68,101.41 126.34,105.06 139.56,105.06 139.64,105.14 152.41,105.14 153.32,104.22 153.32,95.69 152.38,94.75 152.35,94.75 152.21,94.6 152.21,94.58 150.32,92.69 148.77,92.69 134.63,78.54
+VCC_GT_42 on TOP (solid shape): 130.98,78.4 130.98,78.12 131.11,77.99 131.78,77.99 131.89,77.87 131.89,75.42 131.57,75.1 131.57,73.41 131.45,73.29 130.16,73.29 130.03,73.41 130.03,75.03 130.23,75.23 130.23,77.26 130.06,77.44 129.23,77.44 129.21,77.47 129.21,78.72 129.26,78.77 130.6,78.77
+VCC_GT_42 on BOTTOM (solid shape): outline of 101 points within 130.41,74.87 132.44,79.81
+VCC_GT_42 on IN2 (solid shape): outline of 193 points within 130.67,74.96 137.19,80.62
+VCC_SA on TOP (solid shape): outline of 833 points within 121.41,61.17 152.53,67.85
+VCC_SA on BOTTOM (solid shape): 131.83,67.39 131.83,66.95 131.83,66.94 131.8,66.83 131.83,66.71 131.83,66.7 131.83,66.63 132.01,66.45 132.65,66.45 132.9,66.2 132.9,65.39 132.77,65.26 131.89,65.26 131.78,65.16 131.78,64.85 131.91,64.73 132.72,64.73 132.92,64.53 132.92,64.52 132.96,64.4 133.05,64.31 133.05,64.02 131.96,62.93 131.73,62.93 131.72,62.93 131.59,62.97 131.46,62.93 131.45,62.92 130.67,62.92 130.18,63.41 130.18,67.01 130.82,67.65 131.58,67.65
+VCC_SA on BOTTOM (solid shape): 153.2,62.16 153.2,60.61 152.6,60.01 151.62,60.01 151.62,59.25 152.52,59.25 152.52,58.27 152.4,58.14 148.85,58.14 148.53,58.46 148.53,59.91 148.69,60.07 149.06,60.07 149.15,60 149.13,59.89 149.44,59.29 149.5,59.97 149.47,59.98 149.47,60.07 149.58,60.07 149.7,60.19 149.7,61.28 149.51,61.46 148.56,61.46 148.43,61.59 148.43,62.29 148.67,62.53 148.69,62.53 148.83,62.67 152.69,62.67
+VCC_SA on BOTTOM (solid shape): 122.29,65.3 122.29,63.87 122.17,63.74 122.17,63.59 121.84,63.26 121.34,63.26 121.29,63.32 121.33,63.37 121.34,63.37 121.46,63.77 121.06,63.85 121.01,63.85 120.98,63.89 120.98,63.96 120.98,63.97 121.01,64.08 120.98,64.2 120.98,64.21 120.98,64.27 121.01,64.32 121.06,64.31 121.41,64.33 121.47,64.68 121.45,64.72 121.47,64.77 121.47,65.32 121.57,65.43 122.16,65.43
+VCC_SA on VCC: 140.14,57.51 138.34,59.32 131.97,59.32 127.61,63.67 118.24,63.67 118.24,66.97 135.12,66.97 139.15,62.95 151.62,62.95 151.63,62.94 152.12,62.94 152.48,62.57 152.48,61.4 151.98,60.89 151.98,58.02 151.47,57.51
+VDD_CT on IN2 (solid shape): outline of 292 points within 112.21,135.17 120.08,137.84
+VDDR3 on TOP (solid shape): 120.26,134.9 120.26,133.46 119.9,133.1 119.36,133.1 119.18,133.29 119.18,133.32 119.08,133.61 118.78,133.71 118.76,133.71 118.02,134.45 118.02,134.63 118.11,134.72 118.29,134.72 118.64,134.36 119.36,134.36 119.54,134.54 119.54,134.9 119.63,134.99 120.17,134.99
GND on TOP (solid shape): 57.83,123.94 57.83,123.53 57.21,122.91 56.23,122.91 56.23,124.07 57.7,124.07
GND on TOP (solid shape): 10.75,127 3.85,127 3.85,133.9 10.75,133.9
GND on TOP (solid shape): 48.42,135.92 48.42,134.68 48.05,134.31 44.1,134.31 43.9,134.51 43.9,135.87 44.04,136.01 48.33,136.01
GND on TOP (solid shape): 86.5,74.24 86.5,72.94 83.92,70.37 81.68,70.37 81.49,70.56 81.49,73.6 82.23,74.34 86.39,74.34
GND on TOP (solid shape): 157.72,29.41 157.72,28.41 157.41,28.1 155.75,28.1 155.05,28.8 155.05,29.41 155.14,29.5 157.63,29.5
GND on TOP (solid shape): 182.38,48.6 182.38,47.28 182.28,47.18 180.74,47.18 180.53,47.39 180.53,48.65 180.68,48.8 182.18,48.8
GND on TOP (solid shape): 202.79,56.68 202.79,53.64 202.66,53.51 201.46,53.51 201.27,53.7 201.27,56.62 201.46,56.81 202.66,56.81
GND on TOP (solid shape): 44.42,57.72 44.42,56.08 44,55.66 43.09,55.66 42.83,55.91 42.83,57.78 42.92,57.87 44.27,57.87
GND on TOP (solid shape): 43.14,30.06 43.14,28.8 43.1,28.75 41.67,28.75 41.6,28.82 41.6,29.52 41.92,29.84 41.92,30.04 42.03,30.16 43.04,30.16
GND on TOP (solid shape): 51.52,33.52 51.52,32.54 51.32,32.33 48.3,32.33 48.16,32.47 48.16,33.55 48.2,33.58 51.46,33.58
GND on TOP (solid shape): 154.67,113.37 154.67,112.53 154.59,112.45 153.22,112.45 153.09,112.58 153.09,113.42 153.22,113.55 154.49,113.55
GND on TOP (solid shape): 159,42.41 159,41.66 158.86,41.52 157.05,41.52 156.96,41.61 156.96,42.45 157.06,42.55 158.86,42.55
GND on TOP (solid shape): 190.7,39.22 190.7,37.95 190.62,37.87 185.72,37.87 185.65,37.94 185.65,39.19 185.81,39.35 190.56,39.35
GND on TOP (solid shape): 89.43,139.53 89.43,139.02 89.29,138.88 84.21,138.88 84.01,139.09 84.01,139.38 84.25,139.62 89.33,139.62
GND on TOP (solid shape): 158.99,78.04 158.99,72.88 158.86,72.75 157.65,72.75 157.54,72.86 157.54,77.96 157.74,78.16 158.86,78.16
GND on TOP (solid shape): 37.37,27.64 37.37,26.86 38.69,25.54 38.69,24.67 38.54,24.52 38.31,24.52 38.21,24.62 38.21,25.41 37.14,26.48 37.14,27.64 37.19,27.69 37.32,27.69
GND on TOP (solid shape): 37.7,29.57 37.7,27.94 37.67,27.92 36.05,27.92 35.98,27.98 35.98,29.63 36.05,29.7 37.57,29.7
GND on TOP (solid shape): 11.1,108.9 4.05,108.9 4.05,114.8 4,115.07 3.85,115.29 3.85,115.65 11.1,115.65
GND on TOP (solid shape): 180.35,67.84 180.35,67.65 179.42,66.72 179.27,66.72 178.19,67.8 178.19,67.91 179.09,68.81 179.38,68.81
GND on TOP (solid shape): 29.73,53.4 29.73,51.05 29.54,50.86 28.58,50.86 28.36,51.09 28.36,53.4 28.51,53.55 29.57,53.55
GND on TOP (solid shape): 38.88,36.07 38.88,34.99 38.72,34.83 37.5,34.83 37.12,34.45 37.12,32.86 37.04,32.79 35.53,32.79 35.47,32.85 35.47,34.45 36.05,35.03 36.05,35.39 37.22,36.56 38.39,36.56
GND on TOP (solid shape): 87.35,149.58 87.35,148.9 87.28,148.84 86.46,148.84 86.27,148.65 86.27,148.33 86.17,148.23 85.17,148.23 84.88,148.52 81.29,148.52 81.21,148.6 81.21,149.63 81.31,149.73 87.2,149.73
GND on TOP (solid shape): 89.39,39.94 89.39,39.48 89.29,39.38 88.47,39.38 88.45,39.4 85.31,39.4 85.22,39.49 85.22,40.03 84.85,40.4 83.62,40.4 83.47,40.55 83.47,41.26 83.76,41.55 87.79,41.55
GND on TOP (solid shape): 159.75,58.85 162.61,58.85 162.67,58.79 162.67,57.33 162.56,57.22 159.4,57.22 159.05,56.87 158.62,56.87 158.45,57.03 158.45,59.33 158.57,59.45 159.14,59.45
GND on TOP (solid shape): 177.18,58.65 177.19,58.65 177.32,58.52 178.31,58.52 178.45,58.38 178.45,53.44 177.98,52.97 173.32,52.97 172.92,52.57 172.47,52.57 172.4,52.63 172.4,57.81 173.44,58.85 176.98,58.85
GND on TOP (solid shape): 204.22,48 205.68,48 206.08,47.6 206.08,44.67 205.96,44.54 203.29,44.54 203.16,44.68 203.16,45.05 202.77,45.45 202.77,48.37 202.86,48.46 203.76,48.46
GND on TOP (solid shape): 22.59,32.82 22.59,30.32 22.75,30.16 22.75,26.97 22.64,26.86 21.34,26.86 21.22,26.98 21.22,31.95 20.65,32.52 20.65,32.98 20.85,33.18 22.23,33.18
GND on TOP (solid shape): 26.57,106 26.57,102.47 26.45,102.34 25.19,102.34 25.08,102.45 25.08,103.84 25.18,103.93 25.18,104.46 25.02,104.62 23.44,104.62 23.4,104.66 23.4,105.86 23.62,106.09 26.48,106.09
GND on TOP (solid shape): 153.55,48.06 153.55,47.65 153.35,47.46 152.67,47.46 151.75,46.54 148.93,46.54 148.85,46.62 148.85,47.2 149.01,47.35 150.99,47.35 152.21,48.58 153.03,48.58
GND on TOP (solid shape): 117.99,123.97 118.41,123.55 118.41,121.53 118.2,121.31 116.69,121.31 116.55,121.45 116.11,121.45 116.11,121.45 115.65,121.45 114.89,120.7 114.66,120.7 114.49,120.87 114.49,121.35 117.48,124.34 117.62,124.34
GND on TOP (solid shape): 52.9,125.35 52.9,125.19 52.47,124.75 51.84,124.75 51.35,124.26 50.83,124.26 50.83,123.75 50.82,123.74 50.82,123.53 50.57,123.27 50.06,123.27 49.82,123.51 49.82,124.72 50.28,125.18 51.14,125.18 51.42,125.46 52.79,125.46
GND on TOP (solid shape): 217.76,62.21 217.76,61.63 217.93,61.46 218.66,61.46 218.89,61.23 218.89,60.26 218.68,60.04 218.18,60.04 217.65,60.57 216.86,60.57 216.8,60.64 216.8,62.28 216.86,62.33 216.91,62.39 217.59,62.39
GND on TOP (solid shape): 70.2,113.44 70.2,109.04 70.05,108.89 66.3,108.89 66.09,109.1 66.09,109.41 66.11,109.43 66.11,109.61 65.48,110.24 65.48,110.71 65.64,110.88 67.27,110.88 67.6,111.21 67.6,111.23 67.68,111.31 67.68,113.43 67.77,113.52 70.12,113.52
GND on TOP (solid shape): 123.62,60.23 123.62,59.58 123.85,59.35 124.13,59.35 124.25,59.24 124.25,58.97 124.12,58.84 123.8,58.84 123.4,58.44 123.4,58.36 123.24,58.19 123.02,58.19 122.88,58.34 122.88,58.68 123.01,58.81 123.01,60.27 123.02,60.28 123.57,60.28
GND on TOP (solid shape): 39.76,125.1 39.76,123.48 39.68,123.4 39.05,123.4 38.91,123.26 38.91,121.2 38.73,121.01 37.99,121.01 37.76,121.24 37.76,122.29 37.59,122.46 36.58,122.46 36.15,122.89 36.15,124.9 36.15,124.92 36.15,125.43 36.28,125.56 39.3,125.56
GND on TOP (solid shape): 145.02,80.12 145.02,79.61 145.8,78.82 147.07,78.82 147.71,79.46 148.45,79.46 148.6,79.31 148.6,78.37 148.37,78.14 145.32,78.14 145.22,78.24 145.22,78.77 145.07,78.93 144.18,78.93 144.04,79.07 144.04,79.52 144.03,79.54 144.03,80.22 144.08,80.27 144.86,80.27
GND on TOP (solid shape): 197.2,61.62 197.2,60.32 197.33,60.19 198.88,60.19 199.06,60.37 199.06,60.83 199.17,60.94 200.57,60.94 200.69,60.81 200.69,59.76 200.69,59.76 200.69,57.79 200.59,57.69 188.21,57.69 187.99,57.92 187.99,60.84 188.22,61.07 195.39,61.07 196.12,61.8 197.02,61.8
GND on TOP (solid shape): 30.51,29.83 30.51,29.09 30.29,28.86 29.98,28.86 29.69,28.57 29.69,25.81 29.51,25.63 28.59,25.63 28.51,25.72 28.51,27.14 28.85,27.48 28.85,30.27 28.96,30.39 29.96,30.39
GND on TOP (solid shape): 82.34,147.52 82.36,147.52 82.74,147.14 82.74,145.26 82.67,145.19 82.38,145.19 82.37,145.21 81.52,145.21 81.39,145.33 81.39,146.76 81.48,146.85 81.48,147.07 81.55,147.18 81.58,147.32 81.58,147.39 81.73,147.54 82.31,147.54
GND on TOP (solid shape): 115.14,128.67 115.83,128.67 116.01,128.49 116.01,127.45 113.12,124.56 112.82,124.56 112.45,124.93 112.45,125.1 112.11,125.44 111.38,125.44 111.2,125.61 111.2,126.29 111.23,126.32 113.11,126.32 114.17,127.38 114.17,128.62 114.52,128.97 114.84,128.97
GND on TOP (solid shape): 153.29,150.87 153.29,149.96 153.18,149.84 148.25,149.84 148,149.59 140.19,149.59 138.82,148.23 138.82,147.8 138.46,147.44 134.86,147.44 134.15,146.73 133.84,146.73 133.71,146.86 133.71,147.4 133.73,147.42 133.73,147.66 134.84,148.78 136.83,148.78 139.04,150.99 153.17,150.99
GND on TOP (solid shape): 179.9,37.05 179.9,34.12 180.25,33.77 180.51,33.77 180.64,33.64 180.64,33.04 180.62,33.02 180.6,33.02 180.48,32.9 179.34,32.9 179.13,33.11 178.13,33.11 177.94,33.31 177.94,36.93 178.13,37.12 179.84,37.12
GND on TOP (solid shape): 184.74,33.07 184.74,31.95 184.49,31.7 184.32,31.7 184.23,31.72 184.13,31.71 184.03,31.72 183.93,31.7 183.1,31.7 183.02,31.78 183.02,32.27 182.62,32.67 182.62,33.03 182.75,33.15 184.66,33.15
GND on TOP (solid shape): 79.7,149.35 79.7,144.94 79.3,144.53 79.3,143.51 79.05,143.26 79.05,142.26 78.96,142.17 77.92,142.17 77.86,142.22 77.86,144.71 77.4,145.17 74.71,145.17 74.71,145.65 74.15,145.65 74.15,145.17 73.91,145.17 73.91,145.65 73.33,145.65 73.33,145.17 72.3,145.17 72.13,145.34 72.13,149.59 72.25,149.71 79.34,149.71
GND on TOP (solid shape): 119,129.28 119.44,129.28 119.56,129.16 119.58,129.16 119.6,129.15 120.02,129.15 120.04,129.16 120.05,129.16 120.19,129.3 121.01,129.3 121.15,129.16 121.15,128.57 120.53,127.94 120.07,127.94 119.62,128.4 118.72,128.4 118.47,128.65 118.47,129.14 117.96,129.65 117.96,130.01 118.02,130.07 118.22,130.07
GND on TOP (solid shape): 163.67,68.94 163.67,68.1 163.83,67.93 166.16,67.93 166.67,67.42 166.67,67.04 167.26,66.45 168.25,66.45 168.77,65.92 170.21,65.92 170.4,65.73 170.4,63.94 170.09,63.62 168.94,63.62 167.42,62.1 163.47,62.1 163.25,62.33 163.25,62.35 161.99,63.61 161.99,68.8 162.28,69.1 163.51,69.1
GND on TOP (solid shape): 163.13,56.7 163.13,55.96 163,55.84 162.8,55.84 162.77,55.86 161.53,55.86 161.25,55.58 159.72,55.58 159.52,55.38 159.52,54.62 159.75,54.39 160.79,54.39 161.25,53.93 161.25,51.37 161.2,51.32 160.82,51.32 160.41,51.72 160.41,52.51 159.42,53.5 159.42,53.58 159.34,53.65 157.84,53.65 157.72,53.78 157.72,55.33 159.37,56.98 162.85,56.98
GND on TOP (solid shape): 22.35,126.36 22.35,125.38 21.59,124.62 21.59,121.39 21.52,121.32 21.24,121.32 21.04,121.12 21.04,119.85 20.96,119.77 18.37,119.77 17.97,120.18 17.97,122.87 17.46,123.38 16.6,123.38 16.47,123.51 16.47,124.77 16.7,125 18.13,125 18.4,125.28 18.4,125.61 18.51,125.71 19.85,125.71 19.87,125.7 19.96,125.78 21.39,125.78 21.51,125.9 21.51,126.37 21.65,126.5 22.21,126.5
GND on TOP (solid shape): 56.71,131.09 56.71,130.78 56.79,130.7 56.79,130.69 56.88,130.54 57.02,130.45 57.04,130.45 57.23,130.26 58.34,130.26 58.52,130.08 58.52,129.55 58.42,129.45 58.02,129.45 57.63,129.06 57.63,129.05 57.54,128.96 56.01,128.96 55.81,128.77 54.91,128.77 54.77,128.91 54.77,129.97 56.02,131.23 56.57,131.23
GND on TOP (solid shape): 196.51,37.61 196.51,36.59 196.86,36.24 196.86,35.78 196.73,35.64 195.08,35.64 194.9,35.47 194.9,34.86 194.8,34.76 194.52,34.76 194.39,34.88 194.39,35.42 194.4,35.42 194.4,35.85 194.88,36.33 195.31,36.33 195.72,36.74 195.72,37.3 195.46,37.55 194.27,37.55 193.89,37.17 193.89,36.23 193.81,36.15 193.32,36.15 193.23,36.24 193.23,37.47 193.89,38.13 195.99,38.13
GND on TOP (solid shape): 104.96,61.57 105.3,61.57 105.6,61.26 105.6,60.23 105.55,60.19 105.01,60.19 104.97,60.23 104.87,60.33 104.87,60.69 104.67,60.89 103.89,60.89 103.81,60.81 103.81,59.22 103.99,59.05 105.61,59.05 105.69,58.97 105.69,57.47 105.66,57.44 102.66,57.44 102.37,57.73 102.37,61.68 102.71,62.01 104.52,62.01
GND on TOP (solid shape): 30.41,98.14 30.41,94.12 30.11,93.81 28.01,93.81 27.48,94.34 27.48,95.07 27.41,95.13 27.41,95.14 27.35,95.22 27.27,95.28 27.24,95.31 27.2,95.31 27.1,95.33 27,95.31 26.99,95.31 25.41,95.31 25.23,95.49 25.23,97.65 26.08,98.49 30.07,98.49
GND on TOP (solid shape): 164.49,87.43 165.57,87.43 165.99,87.01 165.99,86.08 165.85,85.94 165.22,85.94 165.11,85.83 165.11,77.55 166.05,76.61 170.83,76.61 171.55,75.89 171.55,73.46 170.57,72.47 163.36,72.47 162.77,73.06 161.81,73.06 161.27,72.53 160,72.53 159.32,73.21 159.32,78.21 157.9,79.64 157.9,85.65 157.96,85.8 157.95,85.97 158.53,86.55 161.51,86.55 162.48,87.51 164.41,87.51
GND on TOP (solid shape): 159.09,111.29 159.09,102.9 164.09,97.9 164.09,96.63 163.48,96.02 162.11,96.02 156.35,101.79 156.32,101.79 153.37,104.73 152.03,104.73 151.84,104.78 151.66,104.73 151.44,104.73 151.31,104.78 151.17,104.77 150.95,105 150.95,106.89 151.08,107.02 152.1,107.02 152.46,107.37 152.46,108.24 152.66,108.44 154.92,108.44 156.35,109.86 156.35,111.26 156.37,111.29 156.37,111.39 156.78,111.79 158.58,111.79
GND on TOP (solid shape): 127.66,137.8 127.66,135.62 127.73,135.54 127.73,135.36 127.87,135.23 128.62,135.23 128.67,135.17 128.67,134.8 128.64,134.73 128.62,134.65 128.61,134.63 128.58,134.6 127.44,134.6 127.03,135.01 127.03,135.18 127.04,135.24 127.03,135.31 127.03,135.45 126.93,135.56 126.81,135.56 126.71,135.57 126.61,135.56 126.49,135.56 126.37,135.44 125.83,135.44 125.65,135.62 125.65,136.05 125.47,136.23 125.47,136.52 125.74,136.79 125.74,137.59 126.01,137.87 126.6,137.87 126.68,137.94 127.52,137.94
GND on TOP (solid shape): 160.86,41.47 160.86,41.18 160.96,41.09 161.11,41.09 161.34,41 161.57,41.09 161.8,41.09 161.96,41 162.14,41 162.16,41.01 162.43,40.74 164.4,40.74 164.61,40.53 164.61,40.06 162.72,38.17 162.72,37.58 162.65,37.5 162.03,37.5 161.93,37.6 161.93,40.05 161.74,40.24 155.91,40.24 155.74,40.42 155.74,41.21 155.91,41.38 158.94,41.38 159.2,41.64 160.69,41.64
GND on TOP (solid shape): 131.44,82.61 131.44,82.06 131.36,81.99 131.03,81.99 130.75,81.7 129.67,81.7 129.35,81.39 129.35,80.43 129.29,80.37 128.72,80.37 128.65,80.43 128.65,81.39 128.41,81.63 127.99,81.63 127.76,81.4 127.76,80.4 127.72,80.36 127.36,80.36 127.34,80.39 127.34,81.55 127.29,81.61 125.55,81.61 125.41,81.47 125.41,80.41 125.35,80.34 124.75,80.34 124.67,80.42 124.67,81.34 124.47,81.54 123.08,81.54 122.94,81.4 122.94,80.38 122.91,80.35 122.31,80.35 122.27,80.38 122.27,82.05 122.56,82.34 130.79,82.34 130.97,82.52 130.97,82.62 131.02,82.67 131.38,82.67
GND on TOP (solid shape): 151.19,108.54 151.19,107.56 150.95,107.32 149.65,107.32 149.32,106.99 149.32,106.42 149.2,106.29 144.05,106.29 143.67,105.91 143.67,104.8 143.38,104.45 143.67,104.1 143.67,101.09 141.39,98.8 135.86,98.8 135.04,99.63 135.04,103.61 133.82,104.83 133.82,107.25 134.77,108.2 142.46,108.2 143.35,107.31 146.59,107.31 146.88,107.6 148.65,107.6 149.11,108.06 149.11,108.52 149.28,108.69 151.04,108.69
GND on TOP (solid shape): 46.41,25.62 46.72,25.43 47.03,25.62 47.2,25.79 47.76,25.79 47.86,25.69 47.86,24.83 47.52,24.48 47.52,23.87 47.31,23.67 44.96,23.67 44.32,23.54 43.78,23.18 43.33,22.74 39.71,22.74 39.47,22.98 39.47,24.1 39.6,24.24 43.71,24.24 43.84,24.11 44.18,24.11 44.43,24.36 44.43,25.53 44.69,25.79 46.24,25.79
GND on TOP (solid shape): 122.09,145.62 122.09,145.02 122.22,144.89 123.23,144.89 123.61,145.27 126.47,145.27 126.79,144.95 126.79,144.38 126.6,144.19 124.76,144.19 123.8,143.24 123.8,143.11 124.18,142.54 124.22,142.51 124.34,142.51 124.39,142.51 124.52,142.65 124.78,142.64 124.88,142.53 124.88,142.29 124.57,141.97 124.57,140.57 124.76,140.38 124.77,140.38 125.14,140.27 125.14,139.72 125.07,139.66 121.87,139.66 121.83,139.7 121.83,140.32 121.72,140.44 121.27,140.44 121.16,140.55 121.16,140.83 121.91,141.58 123.6,141.58 123.6,141.59 123.74,141.59 123.99,141.84 123.99,142 124.03,142 124.03,142.16 124.03,142.22 124.03,142.29 124.03,142.39 123.42,142.99 123.42,143.67 123.42,143.75 123.17,144 121.71,144 121.33,144.38 121.33,145.65 121.41,145.73 121.98,145.73
GND on TOP (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 15.1,22.51 15.1,21.17 14.56,20.63 5.52,20.63 5.51,20.63 4.7,20.63 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on TOP (solid shape): 83.1,35.53 83.1,35.01 83.06,35 83,34.98 82.95,34.94 82.88,34.9 82.8,34.94 82.61,35.03 82.42,34.94 82.35,34.9 82.1,35.01 81.94,34.92 81.86,34.88 81.61,35.01 81.36,34.88 81.28,34.92 81.26,34.95 81.21,34.98 81.21,35.36 81.49,35.64 82.99,35.64
GND on TOP (solid shape): 165.8,109.64 169.11,112.75 171.29,112.75 171.34,112 171.65,107 171.7,106.25 169.8,106.25 169.13,106.25 168.98,106.25 168.83,106.26
GND on TOP (solid shape): 97.5,153 97.65,152.65 98,152.5 100,152.5 100.35,152.65 100.5,153 100.5,154.4 103,154.4 103,153.4 103,153.35 103,150 99.3,150 99.3,150.01 96.24,151.11 95,154.11 95,154.4 97.5,154.4
GND on TOP (solid shape): 126.11,74.43 126.11,74.07 126.22,73.96 126.34,73.96 126.34,73.96 126.44,73.94 126.54,73.96 126.55,73.96 126.64,73.96 126.79,74.11 126.79,74.42 126.89,74.52 127.12,74.52 127.25,74.39 127.25,74.07 127.38,73.95 127.59,73.95 127.65,73.94 127.71,73.95 127.88,73.95 127.97,74.04 127.97,74.21 127.98,74.27 127.97,74.39 128.09,74.51 128.31,74.51 128.44,74.38 128.44,73.33 128.32,73.2 123.85,73.2 123.76,73.29 123.76,73.95 123.83,74.02 123.88,74.02 123.89,74.01 124.16,73.95 124.38,74.11 124.42,74.15 124.42,74.27 124.42,74.4 124.52,74.51 124.84,74.51 124.94,74.4 124.94,74.09 125.09,73.93 125.46,73.93 125.62,74.1 125.63,74.27 125.62,74.4 125.75,74.53 126.01,74.53
GND on TOP (solid shape): 125.29,59.49 125.29,58.97 125.58,58.69 125.78,58.69 125.93,58.54 125.93,58.24 126.06,58.12 126.06,56.84 126.06,56.72 126,56.72 125.95,56.74 125.52,56.5 125.79,56.1 125.91,56.08 126.04,56.11 126.05,56.12 126.76,56.12 126.92,55.96 127.07,55.96 127.15,55.96 127.37,55.73 127.37,54.45 127.24,54.31 127.16,54.31 127.16,54.26 126.91,54.26 126.87,54.3 126.87,54.36 126.83,54.36 126.83,54.49 126.65,54.67 126.21,54.67 126.13,54.75 126.13,55.22 126.08,55.28 125.95,55.4 125.77,55.43 125.75,55.43 124.97,56.21 124.97,56.75 125.42,57.21 125.42,58.21 124.58,59.05 124.58,59.45 124.68,59.56 125.23,59.56
GND on TOP (solid shape): 159.29,93.97 159.29,93.57 159.57,93.29 161.76,93.29 161.83,93.21 161.83,92.49 162.09,92.23 168.17,92.23 168.44,91.97 168.44,88.96 168.2,88.72 165.53,88.72 165.49,88.81 165.54,88.89 165.61,89.44 165.06,89.39 165,89.35 164.93,89.35 164.6,89.32 164.44,89.02 164.44,88.94 164.36,88.86 164.36,87.85 164.28,87.77 162.2,87.77 162.02,87.95 162.02,88.72 161.71,89.02 160.39,89.02 160.39,89.42 160.25,89.94 160.1,89.42 160.1,89.02 157.44,89.02 156.94,89.52 156.94,91.28 156.57,91.65 155.67,91.65 155.53,91.78 155.53,93.03 155.84,93.34 157.44,93.34 157.59,93.5 157.59,93.82 158.08,94.3 158.96,94.3
GND on TOP (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,45.11 15.15,45.11 15.15,45.02 14.7,44.58 13.19,44.58 13.04,44.43 13.04,37.83 14.69,37.83 15.11,37.41 15.11,36.26 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on TOP (solid shape): outline of 120 points within 122.54,69.38 130.37,72.03
GND on TOP (solid shape): 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 10.87,66.75 11.68,65.94 11.68,64.82 15.1,61.4 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75
GND on TOP (solid shape): outline of 84 points within 80.27,122.12 95.36,133.84
GND on TOP (solid shape): outline of 137 points within 119.94,127.96 127.34,136.79
GND on TOP (solid shape): 10.71,90.66 11.01,90.36 13.32,90.36 13.78,89.9 13.78,89.24 12.05,87.51 12.05,81.94 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.2,79.2 12.2,80.85 12,81.35 11.5,81.55 7.6,81.55 7.6,82.05 7.4,82.55 6.9,82.75 6.1,82.75 5.6,82.55 5.4,82.05 5.4,81.55 0.6,81.55 0.39,81.64 0.3,81.85 0.3,83.35 0.39,83.56 0.6,83.65 2,83.65 2.5,83.85 2.7,84.35 2.7,88.6 2.79,88.81 3,88.9 10.05,88.9 10.74,89.48 10.29,90.26 10.25,90.27 10.25,91.41 10.71,91.41
GND on TOP (solid shape): 6.41,118.4 6.68,118.4 6.77,118.31 6.77,118.09 10.05,114.8 10.05,109.77 9.24,108.96 4.51,108.96 4.51,108.3 4.45,107.94 4.29,107.62 4.29,107.02 6.05,105.26 10.05,105.26 10.14,105.26 10.23,105.25 13.14,105.25 13.88,104.5 13.88,103.77 13.42,103.31 11.07,103.31 10.71,102.95 10.71,102.63 10.25,102.63 10.25,103.43 10.29,103.44 10.74,104.22 10.05,104.8 3.76,104.8 2,104.8 1.79,104.89 1.7,105.1 1.7,107.3 1.79,107.51 2,107.6 3.35,107.6 3.57,107.63 3.76,107.73 3.98,107.98 4.05,108.3 4.05,114.8 3.85,115.3 3.35,115.5 0.5,115.5 0.29,115.59 0.2,115.8 0.2,117.61 0.2,117.73 4.11,117.73 4.11,117.66 4.11,117.54 4.72,116.93 5.32,117.54 5.32,117.66 5.25,117.96 5.04,118.18 5.09,118.23 5.1,118.25 5.12,118.27 5.38,118.54 5.38,118.63 5.51,118.75 6.05,118.75
GND on TOP (solid shape): outline of 99 points within 121.07,75.18 130.12,79.29
GND on TOP (solid shape): outline of 227 points within 116.42,68.23 121.06,72.63
GND on TOP (solid shape): outline of 266 points within 116.19,77.58 118.46,82.75
GND on TOP (solid shape): outline of 326 points within 118.77,62.65 133.04,68.33
GND on TOP (solid shape): outline of 103 points within 56.75,44.11 82.51,46.63
GND on TOP (solid shape): outline of 557 points within 215.08,42.73 219.49,56.62
GND on TOP (solid shape): outline of 336 points within 0.21,0.21 228.19,155.29
GND on BOTTOM (solid shape): 29.65,53.48 29.65,51.06 29.45,50.86 28.53,50.86 28.41,50.99 28.41,53.53 28.48,53.6 29.52,53.6
GND on BOTTOM (solid shape): 106.26,119.87 106.26,116.8 105.72,116.26 102.02,116.26 101.81,116.47 101.81,119.82 102.12,120.12 106,120.12
GND on BOTTOM (solid shape): 154.67,113.39 154.67,112.56 154.54,112.43 153.17,112.43 153.07,112.53 153.07,113.44 153.2,113.57 154.49,113.57
GND on BOTTOM (solid shape): 158.85,47.05 158.85,46.6 158.72,46.48 157.07,46.48 157.01,46.54 157.01,47.11 157.07,47.18 158.72,47.18
GND on BOTTOM (solid shape): 200.09,59.99 200.09,57.03 199.68,56.62 196.88,56.62 196.44,57.06 196.44,60.05 196.63,60.24 199.84,60.24
GND on BOTTOM (solid shape): 89.35,44.57 89.35,40.74 89.12,40.51 83.54,40.51 83.46,40.58 83.46,44.48 83.63,44.65 89.28,44.65
GND on BOTTOM (solid shape): 146.37,97.64 146.37,95.21 146.34,95.18 142.29,95.18 142.1,95.37 142.1,97.57 142.22,97.69 146.32,97.69
GND on BOTTOM (solid shape): 40.39,117.76 40.39,117.61 39.91,117.13 37.79,117.13 37.64,117.28 37.64,117.92 37.7,117.98 40.18,117.98
GND on BOTTOM (solid shape): 43.14,30.01 43.14,28.77 43.05,28.68 41.5,28.68 41.45,28.73 41.45,30.04 41.58,30.17 42.97,30.17
GND on BOTTOM (solid shape): 51.52,33.46 51.52,32.56 51.31,32.35 48.55,32.35 48.06,32.84 48.06,33.56 48.12,33.61 51.37,33.61
GND on BOTTOM (solid shape): 90.92,32.24 90.92,30.12 90.86,30.05 88.95,30.05 88.86,30.14 88.86,32.06 89.2,32.39 90.76,32.39
GND on BOTTOM (solid shape): 105.29,145.55 105.29,142.27 105,141.98 101.44,141.98 101.16,142.27 101.16,145.32 101.66,145.82 105.03,145.82
GND on BOTTOM (solid shape): 148.6,79.28 148.6,78.49 148.22,78.11 145.27,78.11 145.2,78.19 145.2,79.12 145.32,79.25 147.1,79.25 147.29,79.43 148.45,79.43
GND on BOTTOM (solid shape): 159,42.41 159,41.66 158.86,41.52 157.05,41.52 156.96,41.61 156.96,42.45 157.06,42.55 158.86,42.55
GND on BOTTOM (solid shape): 159.04,77.96 159.04,72.96 158.78,72.7 157.77,72.7 157.51,72.96 157.51,74.38 157.72,74.58 157.72,78.04 157.84,78.16 158.83,78.16
GND on BOTTOM (solid shape): 202.79,57.99 202.79,53.64 202.66,53.51 201.39,53.51 201.27,53.64 201.27,56.3 201.58,56.62 201.58,58.46 201.71,58.59 202.19,58.59
GND on BOTTOM (solid shape): 42.3,33.85 42.3,33.63 42.85,33.08 42.85,31.86 42.76,31.77 40.02,31.77 39.92,31.87 39.92,31.9 38.75,33.07 38.75,34.79 41.36,34.79
GND on BOTTOM (solid shape): 152.59,65.19 152.59,63.1 152.36,62.87 149.25,62.87 149.13,62.99 149.13,65.4 149.17,65.44 152.35,65.44
GND on BOTTOM (solid shape): 196.95,36.09 196.95,35.68 196.53,35.26 196.53,32.55 196.43,32.45 194.29,32.45 194,32.74 194,35.82 194.57,36.39 196.64,36.39
GND on BOTTOM (solid shape): 25.18,104.28 25.18,99.94 24.99,99.75 24.55,99.75 24.48,99.82 24.48,103.87 24.58,103.96 24.58,104.39 24.66,104.48 24.98,104.48
GND on BOTTOM (solid shape): 28.36,105.94 28.36,104.65 24.63,104.65 24.44,104.47 24.44,104.18 24.31,104.05 23.49,104.05 23.36,104.17 23.36,105.52 23.97,106.13 28.17,106.13
GND on BOTTOM (solid shape): 116.57,114.33 117.17,114.33 118.29,113.2 118.29,112.36 118.14,112.21 115.78,112.21 114.46,113.53 114.46,114.22 114.58,114.35 116.55,114.35
GND on BOTTOM (solid shape): 120.26,129.31 120.59,129.31 120.9,129 120.9,128.38 120.97,128.31 120.97,128.11 120.86,127.99 120.65,127.99 120.47,127.81 119.59,127.81 119.29,128.11 119.29,128.35 120.26,129.32
GND on BOTTOM (solid shape): 147.7,63.35 147.7,61.43 147.99,61.15 149.39,61.15 149.47,61.06 149.47,60.24 149.42,60.19 144.31,60.19 144.02,60.48 144.02,63.3 144.18,63.46 147.6,63.46
GND on BOTTOM (solid shape): 153.2,89.47 153.2,88.7 153.07,88.58 152.43,88.58 152.18,88.32 152.18,87.43 151.99,87.24 149.01,87.24 148.88,87.37 148.88,89.4 149.13,89.66 153.01,89.66
GND on BOTTOM (solid shape): 99.55,31.23 99.55,30.06 100,29.61 100,28.14 99.98,28.12 97.67,28.12 96.84,28.95 96.84,32.37 96.91,32.44 98.34,32.44
GND on BOTTOM (solid shape): 168.28,102.85 168.28,102.4 168.29,101.49 168.33,100.57 168.33,100.55 168.21,100.44 164.66,100.44 164.47,100.63 164.47,102.85 164.59,102.98 168.15,102.98
GND on BOTTOM (solid shape): 23.9,54.96 23.9,52.21 23.69,52 21.68,52 21.43,52.25 21.43,52.81 21.12,53.12 20.67,53.12 20.53,53.26 20.53,55.03 20.84,55.33 23.52,55.33
GND on BOTTOM (solid shape): 153.52,48.05 153.52,47.66 153.3,47.45 152.73,47.45 151.72,46.44 148.85,46.44 148.73,46.57 148.73,47.2 148.9,47.38 151.01,47.38 151.84,48.21 152.22,48.59 152.98,48.59
GND on BOTTOM (solid shape): 173.44,41.12 173.44,39.23 173.11,38.9 170.06,38.9 169.1,37.93 165.07,37.93 164.96,38.04 164.96,38.63 165.49,39.16 165.49,41.08 165.82,41.41 173.15,41.41
GND on BOTTOM (solid shape): 169.22,87.56 169.46,87.56 169.63,87.38 169.63,87.14 170.02,86.75 170.02,83.31 169.96,83.24 169.71,83.24 169.58,83.12 169.01,83.12 168.88,83.24 168.88,86.67 168.87,86.68 168.87,87.56 169.21,87.56
GND on BOTTOM (solid shape): 52.65,44.57 52.65,41.06 52.62,41.03 48.08,41.03 48.05,41.06 48.05,44.39 48.05,44.4 48.05,44.59 48.82,45.36 48.82,45.7 49.11,45.99 49.13,46 49.27,46.04 49.38,46.13 51.09,46.13
GND on BOTTOM (solid shape): 168.94,47.62 168.94,45.91 169.13,45.72 169.39,45.72 169.52,45.59 169.52,41.75 169.43,41.66 168.64,41.66 168.51,41.79 168.51,42.83 168.23,43.11 167.79,43.11 167.74,43.16 167.74,45.65 168.13,46.04 168.13,47.66 168.22,47.76 168.81,47.76
GND on BOTTOM (solid shape): 185.49,39.45 190.52,39.45 190.72,39.24 190.72,37.81 190.47,37.55 185.69,37.55 185.63,37.61 185.63,37.63 185.5,37.76 185.5,38.06 185.38,38.18 184.77,38.18 184.67,38.29 184.67,39.56 184.74,39.63 185.3,39.63
GND on BOTTOM (solid shape): 78.09,121.53 78.09,120.92 78.17,120.83 79.72,120.83 79.81,120.74 79.81,120.63 79.69,120.51 79.69,118.99 79.62,118.92 77.26,118.92 77.25,118.93 76.89,118.93 76.84,118.98 76.84,121.51 76.96,121.62 77.99,121.62
GND on BOTTOM (solid shape): 164.26,58.76 164.26,58.61 164.2,58.54 163.42,58.54 162.73,57.85 162.73,57.07 162.64,56.98 159.47,56.98 159.2,56.71 158.29,56.71 158.23,56.78 158.23,57.59 158.78,58.15 158.78,58.54 158.91,58.67 161.26,58.67 161.31,58.72 163.28,58.72 163.39,58.83 164.19,58.83
GND on BOTTOM (solid shape): 193.76,34.76 193.76,32.76 194.46,32.05 194.78,32.05 194.94,31.89 194.94,30.57 194.73,30.36 187.44,30.36 186.8,31.01 186.8,31.78 186.81,31.85 186.8,31.93 186.8,32.59 187.03,32.82 189.89,32.82 190.93,33.86 190.93,34.45 191.43,34.96 193.56,34.96
GND on BOTTOM (solid shape): 26.54,82.65 26.54,79.49 26.47,79.43 23.49,79.43 23.17,79.11 23.17,78.95 23.09,78.87 22.5,78.87 22.41,78.96 22.41,80.48 22.09,80.79 22.09,82.32 22.3,82.52 22.56,82.52 22.7,82.66 22.7,83.99 22.93,84.21 24.98,84.21
GND on BOTTOM (solid shape): 169.43,73.01 169.43,70.29 169.24,70.1 167.17,70.1 166.98,69.91 166.66,69.91 166.47,70.1 166.47,70.86 166.66,71.05 167.74,71.05 167.93,71.24 167.93,71.81 167.99,71.88 168.5,71.88 168.72,72.09 168.72,72.93 168.84,73.06 169.38,73.06
GND on BOTTOM (solid shape): 30.53,97.2 30.53,93.86 30.36,93.69 28.59,93.69 28.51,93.7 28.43,93.69 28.31,93.69 28.18,93.82 28.18,96.8 27.96,97.02 27.58,97.02 27.55,97.05 26.47,97.05 26.02,96.61 25.11,96.61 24.73,96.99 24.69,97.03 23.5,97.03 22.84,96.37 22.33,96.37 22.15,96.55 22.15,96.75 22.71,97.31 24.63,97.31 25.07,97.75 29.98,97.75
GND on BOTTOM (solid shape): 164.15,56.65 164.15,56.11 164.05,56.02 163.31,56.02 163.05,55.76 161.53,55.76 161.32,55.56 159.65,55.56 159.52,55.43 159.52,54.67 159.67,54.52 160.92,54.52 161.32,54.11 161.32,53.58 161.53,53.37 161.53,51.09 161.48,51.04 161.2,51.04 160.38,51.85 160.38,52.61 159.37,53.63 157.92,53.63 157.72,53.83 157.72,55.79 158.4,56.47 159.32,56.47 159.62,56.78 164.02,56.78
GND on BOTTOM (solid shape): 52.69,112.22 52.69,108.35 52.17,107.83 47.15,107.83 47.07,107.87 47.05,107.95 46.97,108.25 46.68,108.37 46.6,108.4 46.57,108.47 46.57,111.79 46.83,112.05 47.5,112.05 47.57,112.05 47.64,112.05 47.93,112.05 48.22,112.34 52.56,112.34
GND on BOTTOM (solid shape): 150.99,108.24 150.99,107.73 150.53,107.27 149.76,107.27 149.23,106.74 149.23,106.34 148.97,106.09 144.05,106.09 143.73,105.77 143.73,105.09 143.61,104.96 142.46,104.96 142.08,105.34 141.77,105.34 140.88,104.45 140.88,102.82 139.57,101.51 139.57,99.8 138.37,98.59 136.4,98.59 135.07,99.93 135.07,100.01 134.65,100.42 134.65,104.83 133.82,105.67 133.82,107.32 134.12,107.63 138.72,107.63 139.16,108.07 143.29,108.07 143.48,107.88 143.48,107.25 143.62,107.1 148.22,107.1 149.26,108.14 149.26,108.36 149.39,108.49 150.73,108.49
GND on BOTTOM (solid shape): 135.92,148.52 135.92,147.12 135.86,147.06 135.35,147.06 135.29,147.12 135.29,148.39 135.04,148.65 134.15,148.65 133.32,147.82 132.11,147.82 131.73,147.44 131.73,146.87 131.67,146.81 131.16,146.81 131.1,146.87 131.1,147.38 130.91,147.57 130.21,147.57 130.08,147.44 130.08,147.06 129.88,146.86 129.39,146.86 129.26,146.72 129.26,146.3 128.94,145.98 126.65,145.98 126.53,146.11 126.53,146.49 126.65,146.62 128.11,146.62 128.59,147.09 128.62,147.09 129.6,147.53 130.21,148.14 131.35,148.14 131.61,148.39 132.96,148.39 133.73,149.16 135.29,149.16
GND on BOTTOM (solid shape): 46.4,25.37 47.01,25.37 47.28,25.1 47.28,23.86 47.09,23.67 44.96,23.67 44.55,23.62 44.18,23.48 44.17,23.47 43.96,23.34 43.78,23.18 43.33,22.74 39.48,22.74 39.4,22.82 39.4,23.35 39.68,23.63 41.48,23.63 41.57,23.71 41.57,24.17 41.64,24.24 43.52,24.24 43.53,24.24 43.7,24.24 43.77,24.16 44.18,24.16 44.38,24.37 44.38,24.89 44.49,24.99 44.49,25.45 44.63,25.59 46.19,25.59
GND on BOTTOM (solid shape): 17.64,43.16 18.88,43.16 19.29,43.57 20.56,43.57 20.94,43.19 21.8,43.19 21.85,43.24 21.89,43.24 21.99,43.34 21.99,43.38 22.06,43.44 22.06,43.75 22.18,43.87 22.44,43.87 22.51,43.8 22.51,43.52 22.34,43.34 22.31,43.34 21.85,42.88 20.84,42.88 20.46,42.5 19.69,42.5 19.67,42.53 18.78,42.53 18.7,42.45 17.69,42.45 16.82,41.59 15.52,41.59 15.36,41.43 14.69,41.43 14.61,41.51 14.61,41.95 14.43,42.13 13.59,42.13 13.42,41.97 13.42,38.59 13.31,38.48 12.27,38.48 12.15,38.6 12.15,40.24 12.38,40.46 12.38,43.74 12.97,44.33 16.47,44.33
GND on BOTTOM (solid shape): 163.67,70.34 163.67,68.1 163.83,67.95 163.84,67.95 163.91,67.88 166.23,67.88 166.6,67.51 166.6,66.86 166.95,66.51 168.51,66.51 168.91,66.11 168.91,63.39 167.75,62.23 163.54,62.23 163.44,62.34 163.44,63.03 163.23,63.24 159.55,63.24 159.48,63.3 159.48,64.32 159.8,64.64 165.71,64.64 165.85,64.78 165.85,65.62 165.64,65.84 162.02,65.84 161.98,65.87 161.98,66.98 162.03,67.03 162.45,67.03 162.52,67.04 162.59,67.1 162.59,67.65 162.43,67.8 161.8,67.8 161.7,67.69 161.02,67.69 160.96,67.76 160.96,67.93 161.04,68.02 161.63,68.02 161.98,68.37 161.98,69.34 162.02,69.38 163.26,69.38 163.26,69.38 163.32,69.45 163.32,69.45 163.36,69.49 163.36,70.34 163.44,70.41 163.6,70.41
GND on BOTTOM (solid shape): 131.31,88.65 131.31,88.45 131.57,88.2 131.57,85.51 131.85,85.23 131.85,84.61 131.75,84.51 131.5,84.51 131.43,84.58 131.43,85.05 131.2,85.28 130.87,85.28 130.68,85.47 130.68,85.95 130.68,85.96 130.7,86.07 130.68,86.18 130.68,86.19 130.68,86.6 130.68,86.61 130.7,86.72 130.68,86.83 130.68,86.84 130.68,87.25 130.68,87.26 130.7,87.37 130.68,87.48 130.68,87.49 130.68,87.9 130.68,87.91 130.7,88.02 130.68,88.13 130.68,88.14 130.68,88.55 130.7,88.61 130.7,88.66 130.83,88.78 131.19,88.78
GND on BOTTOM (solid shape): 164.91,88.43 164.91,87.74 165.08,87.57 165.08,87.57 166.23,87.57 166.31,87.49 166.31,86.4 166.54,86.17 167.19,86.17 167.28,86.08 167.28,85.96 167.18,85.86 166.47,85.86 166.26,86.07 164.84,86.07 164.74,85.97 164.74,82.75 165.05,82.45 165.05,75.62 164.81,75.38 164.81,74.54 164.44,74.16 160.24,74.16 160.05,74.35 160.05,78.42 160.56,78.93 160.56,80.94 160.69,81.07 161.36,81.07 161.36,83.25 162.04,83.25 162.54,83.75 162.54,83.85 162.56,83.87 162.56,87.51 162.6,87.55 163.84,87.55 163.89,87.5 163.89,87 163.95,86.94 164.47,86.94 164.53,87.01 164.55,87.01 164.55,87.02 164.59,87.07 164.59,87.74 164.55,87.78 164.55,87.85 164.53,87.85 164.53,88.43 164.59,88.5 164.85,88.5
GND on BOTTOM (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 14.66,22.94 15.09,22.51 15.09,21.17 14.56,20.64 4.71,20.64 4.71,21.46 4.71,22 4.79,22.21 5,22.29 5.66,22.29 13.5,22.29 14.2,22.88 13.74,23.66 13.71,23.68 13.71,24.54 14.16,24.54
GND on BOTTOM (solid shape): 180.49,33.88 180.49,33.87 180.7,33.66 180.7,33.54 180.69,33.52 180.8,33.04 181.29,33.13 181.29,33.13 181.91,33.75 182.87,33.75 183.5,34.39 183.5,34.72 183.61,34.82 183.63,34.82 183.73,34.81 183.83,34.84 183.86,34.86 184,34.71 184,34.68 183.98,34.54 184.03,34.4 184.04,34.39 184.04,34.23 184.02,34.21 184.02,33.58 183.65,33.21 183.65,30.79 183.52,30.67 180.67,30.67 180.3,31.03 180.3,31.8 179.99,32.12 177.89,32.12 177.89,32.12 177.84,32.12 177.66,32.31 177.66,35 177.82,35.16 179.22,35.16
GND on BOTTOM (solid shape): 191.83,48.19 192.26,48.19 193.07,47.38 194.76,47.38 194.92,47.53 194.92,48.05 195.17,48.3 198.03,48.3 198.04,48.28 198.32,48.28 198.43,48.17 198.43,47.8 198.24,47.6 198.23,47.6 198.08,47.3 198.24,47 198.24,46.28 198.13,46.02 198.31,45.8 198.32,45.79 198.69,45.42 198.69,45.42 198.85,45.25 198.85,43.92 197.94,43.01 197.94,42.47 197.72,42.25 197.52,42.25 193.76,46.01 184.95,46.01 184.03,46.92 181.31,46.92 180.73,47.51 180.02,47.51 179.76,47.25 179.76,44 179.66,43.9 179.13,43.9 179.1,43.94 179.1,45.93 178.76,46.26 177.15,46.26 176.51,46.9 176.51,47.28 176.77,47.53 177.68,47.53 178.37,48.22 180.11,48.22 181.3,49.41 182.56,49.41 183.88,50.73 189.29,50.73
GND on BOTTOM (solid shape): 165.05,109.49 169.09,113.5 171.24,113.5 171.34,112 171.65,107 171.69,106.49 171.75,105.5 169.11,105.5
GND on BOTTOM (solid shape): 116.78,61.79 116.96,61.55 117.24,61.65 117.31,61.69 117.39,61.66 117.68,61.49 117.91,61.59 118.11,61.59 118.17,61.54 118.24,61.51 118.29,61.46 118.31,61.4 118.3,61.34 118.31,61.28 118.49,61.05 118.78,61.06 118.79,61.06 119.72,61.06 119.78,61 119.78,60.81 119.53,60.56 119.53,60.27 119.11,59.85 119.03,59.82 118.86,59.82 118.39,60.29 118.39,60.65 118.25,60.79 116.79,60.79 116.71,60.8 116.63,60.79 116.53,60.79 116.01,61.31 116.01,61.73 116.13,61.84 116.78,61.84
GND on BOTTOM (solid shape): 97.5,153 97.65,152.65 98,152.5 100,152.5 100.35,152.65 100.5,153 100.5,154.4 103,154.4 103,153.85 98.91,150 95,154.03 95,154.4 97.5,154.4
GND on BOTTOM (solid shape): 118.15,83.5 118.33,83.44 118.52,83.5 118.8,83.5 118.98,83.44 119.17,83.5 119.45,83.5 119.47,83.48 119.53,83.45 119.53,83.16 119.81,82.88 119.81,82.72 119.77,82.71 119.7,82.67 119.64,82.62 119.57,82.59 119.49,82.62 119.25,82.73 118.99,82.63 118.92,82.6 118.61,82.73 118.29,82.6 118.22,82.63 117.94,82.73 117.68,82.57 117.64,82.58 117.61,82.6 117.41,82.8 117.41,82.94 117.62,83.07 117.69,83.32 117.69,83.34 117.81,83.47 117.87,83.5
GND on BOTTOM (solid shape): 120.21,88.5 120.37,88.5 120.5,88.38 120.5,87.88 120.49,87.87 120.46,87.72 120.49,87.57 120.5,87.56 120.5,87.52 120.58,87.44 120.58,87.32 120.44,87.05 120.57,86.77 120.58,86.75 120.58,86.69 120.57,86.67 120.46,86.41 120.58,86.15 120.58,86 120.51,85.91 120.47,85.79 120.47,85.77 120.42,85.72 120.35,85.72 120.21,85.86 120.22,85.89 120.2,86.14 120,86.3 119.95,86.35 119.9,86.64 119.73,86.78 119.72,86.78 119.69,86.8 119.69,87.1 119.73,87.11 119.86,87.2 119.93,87.34 119.94,87.35 119.98,87.4 119.94,87.45 119.93,87.46 119.87,87.59 119.75,87.68 119.72,87.69 119.72,88.26 119.98,88.52
GND on BOTTOM (solid shape): 165.07,112.82 165.16,112.76 165.15,112.65 164.05,109.13 165.65,105.81 165.68,105.74 165.65,105.67 165,105.02 159.84,105.02 157.42,102.59 157.42,100.82 157.1,100.5 154.56,100.5 152.69,102.37 152.69,102.83 152.15,103.37 152.15,104.24 152.1,104.68 151.67,104.74 151.62,104.7 151.55,104.68 151.49,104.7 151.45,104.73 151.42,104.75 151.31,104.78 151.19,104.78 151.11,104.8 151.07,104.88 151.07,107.55 152.01,108.49 157.66,108.49 161.99,112.82
GND on BOTTOM (solid shape): 124.62,89.84 124.62,89.41 124.61,89.32 124.62,89.23 124.62,88.76 124.61,88.67 124.62,88.58 124.62,88.11 124.61,88.02 124.62,87.93 124.62,87.46 124.61,87.37 124.62,87.28 124.62,86.81 124.61,86.72 124.62,86.63 124.62,86.33 124.37,86.08 124.36,86.07 124.24,86 124.16,85.88 124.16,85.87 123.99,85.7 123.97,85.7 123.8,85.62 123.72,85.45 123.72,85.43 123.52,85.23 123.45,85.22 123,85.22 122.87,85.34 122.87,85.51 122.91,85.55 122.94,85.61 123.1,85.76 123.12,85.77 123.34,85.9 123.38,86.15 123.38,86.15 123.38,86.63 123.39,86.72 123.38,86.8 123.38,87.28 123.39,87.37 123.38,87.45 123.38,87.94 123.39,88.02 123.38,88.11 123.38,88.38 123.41,88.39 123.54,88.49 123.6,88.66 123.6,88.68 123.76,88.84 123.76,88.9 123.78,88.92 123.78,89.49 124.16,89.88 124.58,89.88
GND on BOTTOM (solid shape): 159.49,95.58 159.49,94.69 159.29,94.5 159.29,93.47 159.49,93.27 162.6,93.27 162.68,93.2 162.68,92.38 162.72,92.33 162.73,92.32 162.78,92.27 166.17,92.27 166.35,92.45 167.8,92.45 167.86,92.39 167.86,91.82 168.18,91.5 168.18,89.02 167.96,88.79 166.16,88.79 165.71,89.24 165.71,89.26 165.43,89.54 165.06,89.39 165,89.35 164.93,89.35 164.55,89.29 164.46,88.91 164.44,88.82 164.36,88.78 163.38,88.78 163.38,88.78 161.79,88.78 161.43,89.14 161.43,89.47 161.43,89.47 161.43,89.73 161.71,90.01 161.71,90.9 161.61,91 161.61,91.01 161.54,91.07 157.85,91.07 157.79,91.13 157.79,92.28 157.82,92.31 158.52,92.31 158.64,92.43 158.64,92.62 158.35,92.92 158.34,92.93 158.3,92.97 157.01,92.97 156.91,93.07 156.91,93.2 156.97,93.26 157.52,93.26 157.76,93.5 157.76,94.6 157.86,94.7 158.05,94.7 158.18,94.83 158.18,95.48 158.18,95.56 158.27,95.65 158.4,95.65 158.5,95.56 158.5,94.91 158.62,94.78 158.94,94.78 159.17,95.01 159.17,95.57 159.26,95.66 159.41,95.66
