# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Nets (continued)
ENLDO_3V5V: PR302.1 PR303.1 PU301.11 PU501.11
EOPIO_RCOMP: RC122.1 UC1.H65
ESPI_ALERT#: RC14.2 RE84.1 UC1.AY11
ESPI_CLK: CC88.1 JESPI1.10 RC15.2 RE67.2 UE1.57
ESPI_CS#: JESPI1.7 UC1.BA12 UE1.58
ESPI_IO0: JESPI1.3 RPC2.8 UE1.59
ESPI_IO1: JESPI1.4 RPC2.7 UE1.60
ESPI_IO2: JESPI1.5 RPC2.6 UE1.61
ESPI_IO3: JESPI1.6 RPC2.5 UE1.62
ESPI_RESET#: UC1.BA11 UE1.53
EXT_PWR_GATE#: TP13.1(TP-1) UC1.AM10
FAN1_PWM: JFAN1.2 R50.1 UE1.47
FAN1_TACH: CE28.1 JFAN1.3 RE13.1 UE1.40
FB_1.2V: PCM17.1 PRM10.1 PRM11.1 PUM01.6
FB_1.8VALW: PC1807.2 PR1805.1 PR1807.2 PU1801.6
FB_2PH_CPU: PCZ13.2 PCZ15.1 PRZ21.2 PRZ24.1 PUZ01.3
FB_+1VALW: PRH08.1 PRH09.1 PRH12.2 PUH01.10
FB__+1.35VGPU: PRW09.1 PRW10.1 PRW13.2 PUW01.10
FB_GND: RV158.1 UV1.AD20
FB_VDDC: RV159.1 UV1.AC20
FB_VDDCI: TP67.1(TP-1) UV1.W1
FFS_INT1: RC35.2 UC1.M3 US1.12
FFS_INT2: QS1.2 RC36.2 UC1.AC2 US1.11
FFS_INT2_Q: JHDD.12 JHDD1.9 QS1.3 RS4.2
FP_GND: JFP.2 JFP1.4 R87.2
FP_VCC: C37.2 C46.1 C50.1 JFP.6 JFP1.8 R4.2 R7.2 R86.2
FP_VCC_R: JFP.5 JFP1.7 R86.1
FPR_SCAN#: EU4012.3 JFP1.2 R72.2 RE85.2
GPIO19_CTF: RV151.2 RV152.1 UV1.M2
GPIO28: RV21.2 UV1.R5
GPP_B23: RC39.1 UC1.AM7
GPP_C5: RC38.1 UC1.W1
GPU_PWR_LEVEL: RV260.1 UE1.10 UV1.T9
H_CATERR#: RC111.2 UC1.D63
H_CPU_SVIDALRT#: RC153.1 UC1.B63
H_CPUPWRGD: CC15.1 RC95.2 UC1.A68
H_CPUPWRGD_R: RC95.1 TP7.1(TP-1)
H_DRAMRST#: RD7.2 RD8.1 UC1.AT13
H_PECI: RE23.1 UE1.94
H_PROCHOT#: CE26.1 PQ11.1 PQ12.3 PQS10.3 PRB19.1 PRZ43.2 PRZ49.2 RC113.2 RC117.1 UE2.4
H_PROCHOT#_R: RC117.2 UC1.C65
H_THERMTRIP#: RC112.2 TP14.1(TP-1) UC1.C63
H_VCCST_PWRGD: C36.1 RC96.1 RC104.1 UC7.4
HDA_BIT_CLK: CC91.1 RC124.2 UC1.AY22
HDA_CODEC_BITCLK: RA43.2 RC124.1 UA1.6
HDA_CODEC_RST#: RC127.1 TP74.1(TP-1)
HDA_CODEC_SDIN0: RA7.2 UA1.8
HDA_CODEC_SDOUT: RC125.1 UA1.5
HDA_CODEC_SYNC: RC123.1 UA1.10
HDA_RST#: CC99.1 RC127.2 UC1.AW22
HDA_SDIN0: CC98.1 RA7.1 UC1.BA21
HDA_SDOUT: CC97.1 RC125.2 RC126.2 RC129.2 UC1.BB22
HDA_SYNC: RC123.2 UC1.BA22
HDD_DET#: RS6.1 RS7.1 UC1.M1
HDD_DEVSLP: RS1.2 UC1.J1
HDD_DEVSLP_R: JHDD.13 JHDD1.8 RS1.1
HDD_EN_PCH: RC209.2 UC1.J4 US2.4
HDMI_CLK: CI2.1 UC1.G56
HDMI_CLK#: CI1.1 UC1.F56
HDMI_CLK#_R: CI1.2 LI1.2 RI2.1 RPI2.6
HDMI_CLK#_R_C: JHDMI1.12 LI1.1 RI2.2 RI3.1
HDMI_CLK_R: CI2.2 LI1.3 RI1.1 RPI2.5
HDMI_CLK_R_C: JHDMI1.10 LI1.4 RI1.2 RI3.2
HDMI_DATA0: CI4.1 UC1.G53
HDMI_DATA0#: CI3.1 UC1.F53
HDMI_DATA0#_R: CI3.2 LI2.2 RI4.1 RPI2.8
HDMI_DATA0#_R_C: JHDMI1.9 LI2.1 RI4.2 RI6.1
HDMI_DATA0_R: CI4.2 LI2.3 RI5.1 RPI2.7
HDMI_DATA0_R_C: JHDMI1.7 LI2.4 RI5.2 RI6.2
HDMI_DATA1: CI6.1 UC1.F58
HDMI_DATA1#: CI5.1 UC1.E58
HDMI_DATA1#_R: CI5.2 LI4.2 RI11.1 RPI1.8
HDMI_DATA1#_R_C: JHDMI1.6 LI4.1 RI11.2 RI12.1
HDMI_DATA1_R: CI6.2 LI4.3 RI10.1 RPI1.7
HDMI_DATA1_R_C: JHDMI1.4 LI4.4 RI10.2 RI12.2
HDMI_DATA2: CI8.1 UC1.F55
HDMI_DATA2#: CI7.1 UC1.E55
HDMI_DATA2#_R: CI7.2 LI3.2 RI8.1 RPI1.6
HDMI_DATA2#_R_C: JHDMI1.3 LI3.1 RI8.2 RI9.1
HDMI_DATA2_R: CI8.2 LI3.3 RI7.1 RPI1.5
HDMI_DATA2_R_C: JHDMI1.1 LI3.4 RI7.2 RI9.2
HDMI_HPD_B: JHDMI1.19 QI3.1 RI16.1
HDMI_PLL_GND: QI1.1 RPI1.1 RPI1.2 RPI1.3 RPI1.4 RPI2.1 RPI2.2 RPI2.3 RPI2.4
HOST_DEBUG_TX: JDEG1.8 RE57.2 RW6.1 RW10.1 UE1.81
HPD_P1: RT8.2 RT101.2 RT114.1 UT1.18 UT5.38
HPOUT_L: CA35.1 DA4.2 JHP1.1 RA30.1 RA36.2
HPOUT_R: CA34.1 DA4.3 JHP1.2 RA34.1 RA37.2
HW_ACAV_IN: CE32.2 DZ1.1 PR31.1 PRB42.2 PUS02.2 UE1.128
HW_ACAVIN_NB: CE34.2 PR46.1 PR52.1 PRB40.1 PRS23.1 PRS39.2 PRS40.1 PU2.2 UE1.24
I2C0_SCL_TCH_PAD: Q10.1 R34.2 UC1.U6
I2C0_SDA_TCH_PAD: Q10.4 R33.2 UC1.U7
I2C_CTL_EN: RT77.1 RT78.1 UT5.2
I2C_SCL_TP: JTP1.6 Q10.6 R46.2
I2C_SDA_TP: JTP1.7 Q10.3 R47.2
I_ADP: CE25.1 RE51.1 UE1.110
I_ADP_R: PRB35.2 RE51.2
I_BATT: CE30.1 RE54.1 UE1.114
I_BATT_R: PRB34.2 RE54.2
I_SYS: PRB31.2 PRZ11.2 PUZ01.46
ICCMAX_1A_CPU: PRZ67.1 PUZ01.19
ICCMAX_1B_CPU: PRZ68.1 PUZ01.20
ICCMAX_2PH_CPU: PRZ66.1 PUZ01.18
ICSP_CLK: RE60.2 UE1.101
ICSP_CLR: RE61.2 UE1.87
ICSP_DAT: RE63.2 UE1.102
ILIM_1A_CPU: PCZ32.1 PRZ56.1 PUZ01.27
ILIM_1B_CPU: PCZ05.1 PRZ05.1 PUZ01.42
ILIM_2PH_CPU: PRZ28.2 PUZ01.5
ILMT_+1VALW: PRH03.2 PRH04.1 PUH01.12
IMON_VGA: PCV20.1 PRV16.1 PUV01.10
IMVP_VR_ON: PRZ22.2 RC107.2
INT_TP#: JTP1.4 Q9.3 R39.2
INTRUDER#: RC91.1 UC1.AP16
IO_CBL_DET#: JIOB1.9 RC206.1 UC1.U3
IOUT_1A_CPU: PCZ25.1 PRZ50.1 PUZ01.30
IOUT_1B_CPU: PCZ12.1 PRZ15.1 PUZ01.39
IOUT_2PH_CPU: PCZ14.1 PRZ23.1 PUZ01.1
IR_CAM_DETECT#: JEDP1.26 RC200.1 UC1.P4
IR_GND: JEDP1.24 JEDP1.25 R85.2
ISEN1_VGA: PCV23.1 PRV22.2 PUV01.13
ISEN2_VGA: PCV22.1 PRV03.2 PUV01.12
ISOLATE#: RL3.2 RL4.1 UL1.20
JACK_PLUG: DA7.3 JHP1.5 RA39.2
JACK_PLUG_DET: DA7.2 JHP1.6 RA40.2
JTAG_CLK: JDEG1.4 RPE7.3
JTAG_TCK: RV369.1 UV1.L3
JTAG_TDI: JDEG1.2 RE60.1 RPE7.1
JTAG_TDI_GPU: RP34.7 UV1.L5
JTAG_TDO: JDEG1.5 RE63.1 RPE7.4
JTAG_TDO_GPU: RP34.8 UV1.K4
JTAG_TMS: JDEG1.3 RE61.1 RPE7.2
JTAG_TMS_GPU: RP34.6 UV1.L1
JTAG_TRSTB: RP34.5 UV1.L6
KB_BL_CTRL#: EC3001.1 JKBBL1.4 Q8.1
KB_DET#: JKB1.1 RC45.1 UC1.AD4
KB_LED_BL_DET: R26.1 R27.1 UC1.W8
KB_LED_DET_C: JKBBL1.2 R26.2
KB_LED_PWM: Q8.2 UE1.44
KBLR_XTAL_IN: RC25.1 UC1.E3
KBLR_XTAL_IN_R: CC17.1 RC22.2 RC25.2 YC3.3
KBLR_XTAL_OUT: RC26.1 UC1.C7
KBLR_XTAL_OUT_R: CC18.1 RC22.1 RC26.2 YC3.1
KSI0: JKB1.9 RPE1.4 UE1.98
KSI1: JKB1.7 RPE1.3 UE1.99
KSI2: JKB1.5 RPE1.2 UE1.6
KSI3: JKB1.8 RPE1.1 UE1.7
KSI4: JKB1.4 RPE2.1 UE1.104
KSI5: JKB1.6 RPE2.2 UE1.105
KSI6: JKB1.3 RPE2.3 UE1.107
KSI7: JKB1.2 RPE2.4 UE1.108
KSO0: JKB1.18 RPE3.8 UE1.2
KSO1: JKB1.16 RPE3.7 UE1.14
KSO2: JKB1.17 RPE3.6 UE1.15
KSO3: JKB1.15 RPE3.5 UE1.16
KSO4: JKB1.11 RPE4.8 UE1.37
KSO5: JKB1.10 RPE4.7 UE1.38
KSO6: JKB1.13 RPE4.6 UE1.39
KSO7: JKB1.12 RPE4.5 UE1.50
KSO8: JKB1.14 RPE6.8 UE1.46
KSO9: JKB1.24 RE15.1 UE1.68
KSO10: JKB1.26 RPE5.8 UE1.72
KSO11: JKB1.25 RPE5.7 UE1.74
KSO12: JKB1.19 RPE5.6 UE1.75
KSO13: JKB1.22 RPE5.5 UE1.76
KSO14: JKB1.23 RPE6.6 UE1.77
KSO15: JKB1.21 RPE6.7 UE1.86
KSO16: JKB1.20 RPE6.5 UE1.92
L_BKLT_CTRL: R8.1 UC1.R11
LAN_MDI0N: TL1.9 UL1.2
LAN_MDI0P: TL1.10 UL1.1
LAN_MDI1N: TL1.15 UL1.5
LAN_MDI1P: TL1.16 UL1.4
LAN_MDI2N: TL2.10 UL1.7
LAN_MDI2P: TL2.9 UL1.6
LAN_MDI3N: TL2.16 UL1.10
LAN_MDI3P: TL2.15 UL1.9
LANWAKE#: RC214.1 UC1.AM15 UE1.35
LANXIN: RL8.2 UL1.28
LANXIN_R: CL10.2 RL8.1 YL1.1
LANXOUT: RL9.2 UL1.29
LANXOUT_R: CL11.2 RL9.1 YL1.3
LCD_BRIGHTNESS: L6.2 R80.2 RP2.2
LCD_BRIGHTNESS_R: JEDP1.27 L6.1 R80.1
LCD_CBL_DET#: JEDP1.14 RC205.1 UC1.W4
LCD_TST: D3.3 RP2.6 UE1.26
LCD_TST_C: JEDP1.10 RP2.3
LCD_VCC_TEST_EN: D4.3 UE1.113
LCDVDD_EN: D4.1 R10.1 U1.4
LDO1_CAP: CA20.2 RA41.2 UA1.27
LDO2_CAP: CA21.2 UA1.39
LDO3_CAP: CA22.2 UA1.7
LED0: T47.1(TP-1) UL1.27
LED1: T45.1(TP-1) UL1.25
LG1_CHG: PQB01.6 PUB01.9
LG1_VGA: PQV01.6 PQV02.6 PUV01.24
LG2_CHG: PQB02.6 PUB01.7
LG2_VGA: PQV03.6 PQV04.6 PUV01.27
LG_1.2V: PQM01.8 PUM01.15
LG_VCCSA: PQA01.8 PUA01.5
LID_CL_SIO#: CE19.1 D5.1 R22.1 RE25.2 U4.2 UE1.66
LID_CLOSE#: EC2902.1 JPWR1.3 JPWR2.5 R22.2
LIMT_+1.35VGPU: PRW03.2 PRW04.1 PUW01.12
LINE1-L_C: CA32.2 RA28.1
LINE1-L_R: CA33.2 RA32.1
LINE1_L: CA32.1 UA1.22
LINE1_R: CA33.1 UA1.21
LM393_P: PC21.1 PCB44.2 PCS01.2 PDS01.1 PR21.1 PR50.1 PRB37.2 PRS43.1 PU2.5 PUB02.5 PUS01.8
LOM_CABLE_DETECT: RL21.2 UE1.41
LOM_TCT: CL12.1 TL1.11 TL1.14 TL2.11 TL2.14
LX1_CHG: PCB25.2 PLB01.1 PQB01.7 PRB17.1 PUB01.10
LX1_VGA: PCV21.2 PLV01.4 PQV01.7 PQV02.7 PRV23.1 PUV01.23
LX2_CHG: PLB01.2 PQB02.7 PRB15.2 PRB18.1 PUB01.6
LX2_VGA: PCV08.2 PLV02.4 PQV03.7 PQV04.7 PRV06.1 PUV01.28
LX_1.2V: PCM12.2 PLM01.2 PQM01.9 PRM01.1 PUM01.16
LX_1.8VALW: PL1801.1 PR1804.1 PU1801.2 PU1801.3
LX_3V: PC307.2 PL301.1 PR305.1 PU301.6 PU301.19 PU301.20
LX_5V: PC507.2 PL501.1 PR505.1 PU501.6 PU501.19 PU501.20
LX_+1.35VGPU: PCW12.2 PLW01.1 PRW07.1 PUW01.2 PUW01.3
LX_+1VALW: PCH12.2 PLH01.1 PRH07.1 PUH01.2 PUH01.3
LX_VCCSA: PCA07.2 PLA01.1 PQA01.9 PRA02.1 PUA01.7
LX_VCORE1: PLI01.1 PRI03.1 PUI01.11 PUI01.12
LX_VCORE2: PLI02.1 PRI23.1 PUI02.11 PUI02.12
LX_VGT1: PLG01.1 PRG03.1 PUG01.11 PUG01.12
M0_MA0: UV1.K17 UV12.H4 UV13.K4
M0_MA1: UV1.J20 UV12.H5 UV13.K5
M0_MA2: UV1.H23 UV12.H11 UV13.K11
M0_MA3: UV1.G23 UV12.H10 UV13.K10
M0_MA4: UV1.G24 UV12.K11 UV13.H11
M0_MA5: UV1.H24 UV12.K10 UV13.H10
M0_MA6: UV1.J19 UV12.K5 UV13.H5
M0_MA7: UV1.K19 UV12.K4 UV13.H4
M0_MA8: UV1.G20 UV12.J5 UV13.J5
M1_MA0: UV1.J14 UV14.H4 UV15.K4
M1_MA1: UV1.K14 UV14.H5 UV15.K5
M1_MA2: UV1.J11 UV14.H11 UV15.K11
M1_MA3: UV1.J13 UV14.H10 UV15.K10
M1_MA4: UV1.H11 UV14.K11 UV15.H11
M1_MA5: UV1.G11 UV14.K10 UV15.H10
M1_MA6: UV1.J16 UV14.K5 UV15.H5
M1_MA7: UV1.L15 UV14.K4 UV15.H4
M1_MA8: UV1.G14 UV14.J5 UV15.J5
M2_SSD_PEDET: JSSD1.69 RS2.1 UC1.G4
M_ADBI0: UV1.L18 UV12.J4 UV13.J4
M_ADBI1: UV1.K16 UV14.J4 UV15.J4
M_CAS#0: UV1.G19 UV12.L3 UV13.G3
M_CAS#1: UV1.G16 UV14.L3 UV15.G3
M_CKE0: UV1.K20 UV12.J3 UV13.J3
M_CKE1: UV1.J17 UV14.J3 UV15.J3
M_CLK0: RV79.2 UV1.H26 UV12.J12 UV13.J12
M_CLK1: RV85.2 UV1.G9 UV14.J12 UV15.J12
M_CLK#0: RV370.2 UV1.H25 UV12.J11 UV13.J11
M_CLK#1: RV86.2 UV1.H9 UV14.J11 UV15.J11
M_CS0B#0: UV1.H22 UV12.G12 UV13.L12
M_CS1B#0: UV1.G13 UV14.G12 UV15.L12
M_DA0: UV1.K27 UV13.A2
M_DA1: UV1.J29 UV13.B2
M_DA2: UV1.H30 UV13.A4
M_DA3: UV1.H32 UV13.B4
M_DA4: UV1.G29 UV13.F2
M_DA5: UV1.F28 UV13.F4
M_DA6: UV1.F32 UV13.E4
M_DA7: UV1.F30 UV13.E2
M_DA8: UV1.C30 UV12.M11
M_DA9: UV1.F27 UV12.T13
M_DA10: UV1.A28 UV12.N11
M_DA11: UV1.C28 UV12.T11
M_DA12: UV1.E27 UV12.N13
M_DA13: UV1.G26 UV12.U13
M_DA14: UV1.D26 UV12.M13
M_DA15: UV1.F25 UV12.U11
M_DA16: UV1.A25 UV12.F4
M_DA17: UV1.C25 UV12.B4
M_DA18: UV1.E25 UV12.E4
M_DA19: UV1.D24 UV12.A4
M_DA20: UV1.E23 UV12.B2
M_DA21: UV1.F23 UV12.E2
M_DA22: UV1.D22 UV12.A2
M_DA23: UV1.F21 UV12.F2
M_DA24: UV1.E21 UV13.M11
M_DA25: UV1.D20 UV13.M13
M_DA26: UV1.F19 UV13.N13
M_DA27: UV1.A19 UV13.N11
M_DA28: UV1.D18 UV13.U13
M_DA29: UV1.F17 UV13.T13
M_DA30: UV1.A17 UV13.U11
M_DA31: UV1.C17 UV13.T11
M_DA32: UV1.E17 UV15.U13
M_DA33: UV1.D16 UV15.U11
M_DA34: UV1.F15 UV15.T11
M_DA35: UV1.A15 UV15.T13
M_DA36: UV1.D14 UV15.N11
M_DA37: UV1.F13 UV15.M13
M_DA38: UV1.A13 UV15.M11
M_DA39: UV1.C13 UV15.N13
M_DA40: UV1.E11 UV14.B2
M_DA41: UV1.A11 UV14.A4
M_DA42: UV1.C11 UV14.A2
M_DA43: UV1.F11 UV14.B4
M_DA44: UV1.A9 UV14.E2
M_DA45: UV1.C9 UV14.F2
M_DA46: UV1.F9 UV14.F4
M_DA47: UV1.D8 UV14.E4
M_DA48: UV1.E7 UV14.M11
M_DA49: UV1.A7 UV14.N11
M_DA50: UV1.C7 UV14.T11
M_DA51: UV1.F7 UV14.M13
M_DA52: UV1.A5 UV14.U11
M_DA53: UV1.E5 UV14.N13
M_DA54: UV1.C3 UV14.U13
M_DA55: UV1.E1 UV14.T13
M_DA56: UV1.G7 UV15.F4
M_DA57: UV1.G6 UV15.E4
M_DA58: UV1.G1 UV15.E2
M_DA59: UV1.G3 UV15.F2
M_DA60: UV1.J6 UV15.A4
M_DA61: UV1.J1 UV15.B2
M_DA62: UV1.J3 UV15.A2
M_DA63: UV1.J5 UV15.B4
M_DBI0#: UV1.H27 UV13.D2
M_DBI1#: UV1.A27 UV12.P13
M_DBI2#: UV1.C23 UV12.D2
M_DBI3#: UV1.C19 UV13.P13
M_DBI4#: UV1.C15 UV15.P13
M_DBI5#: UV1.E9 UV14.D2
M_DBI6#: UV1.C5 UV14.P13
M_DBI7#: UV1.H4 UV15.D2
M_EDC_0: UV1.H28 UV13.C2
M_EDC_1: UV1.C27 UV12.R13
M_EDC_2: UV1.A23 UV12.C2
M_EDC_3: UV1.E19 UV13.R13
M_EDC_4: UV1.E15 UV15.R13
M_EDC_5: UV1.D10 UV14.C2
M_EDC_6: UV1.D6 UV14.R13
M_EDC_7: UV1.G5 UV15.C2
M_RAS#0: UV1.G22 UV12.G3 UV13.L3
M_RAS#1: UV1.G17 UV14.G3 UV15.L3
M_WCKA0_0: UV1.E32 UV12.P4 UV13.D4
M_WCKA0_0#: UV1.E30 UV12.P5 UV13.D5
M_WCKA0_1: UV1.A21 UV12.D4 UV13.P4
M_WCKA0_1#: UV1.C21 UV12.D5 UV13.P5
M_WCKA1_0: UV1.E13 UV14.D4 UV15.P4
M_WCKA1_0#: UV1.D12 UV14.D5 UV15.P5
M_WCKA1_1: UV1.E3 UV14.P4 UV15.D4
M_WCKA1_1#: UV1.F4 UV14.P5 UV15.D5
M_WE#0: UV1.G25 UV12.L12 UV13.G12
M_WE#1: UV1.H10 UV14.L12 UV15.G12
MASK_BASE_LEDS#: Q17.2 Q17.5 Q21.2 R70.2 R71.2 U4.4
MASK_SATA_LED#: Q22.2 R23.2 RC224.1 UE1.56
MCT: CL13.1 RL14.1 RL15.1 RL19.1 RL20.1
MCT0: RL14.2 TL2.3
MCT1: RL15.2 TL2.6
MCT2: RL19.2 TL1.3
MCT3: RL20.2 TL1.6
MDO0+: JLAN1.1 TL1.7
MDO0-: JLAN1.2 TL1.8
MDO1+: JLAN1.3 TL1.1
MDO1-: JLAN1.6 TL1.2
MDO2+: JLAN1.4 TL2.8
MDO2-: JLAN1.5 TL2.7
MDO3+: JLAN1.7 TL2.2
MDO3-: JLAN1.8 TL2.1
ME_FWP: RC223.1 RE19.1 RE539.2 SW3.1 UE1.80
ME_FWP_PCH: RC126.1 RC223.2 SW3.2
MEC_XTAL1: CE3.1 RE47.2 YE1.1
MEC_XTAL1_R: RE47.1 UE1.123
MEC_XTAL2: CE4.1 RE45.1 UE1.125 YE1.2
MEM_SMBCLK: CC94.1 QC1.6 RC29.1 UC1.R7
MEM_SMBDATA: QC1.3 RC30.1 UC1.R8
MIC_CAP: CA26.1 UA1.19
MODEL_ID: CE1.1 RE3.2 RE4.2 UE1.109
MSCLK: JDEG1.6 RE55.2
MSDATA: JDEG1.7 RE56.2 RE62.1
MUX_A_EN: UT1.26 UT3.16
MUX_B_EN: UT1.36 UT3.10
MUX_DPEQ0: RT23.2 RT24.1 RT25.1 UT2.14
MUX_DPEQ1: RT20.2 RT21.1 RT22.1 UT2.2
MUX_I2C_CLK: RT52.2 UT1.29 UT2.21
MUX_I2C_DATA: RT53.2 UT1.28 UT2.22
MUX_I2C_EN: RT11.2 RT12.1 RT13.1 UT2.17
MUX_SBU1: EU4001.5 EU4001.6 JUSBC1.A8 UT2.27
MUX_SBU2: EU4002.1 EU4002.9 JUSBC1.B8 UT2.26
MUX_SSEQ0: RT14.2 RT15.1 RT16.1 UT2.11
MUX_SSEQ1: RT17.2 RT18.1 RT19.1 UT2.3
MUX_USB2_FILP: UT1.5 UT3.12 UT3.14
MUX_USB_EQ0: RT26.2 RT27.1 RT28.1 UT2.38
MUX_USB_EQ1: RT29.2 RT30.1 RT31.1 UT2.35
NB_MUTE#: RE28.1 UE1.119
NCT7718_DXN: C22.2 C23.2 Q14.3 U2.3
NCT7718_DXP: C22.1 C23.1 Q14.1 Q14.2 U2.2
NRB_BIT: RC44.2 UC1.AR7
ONE_DIMM#: RC181.2 RC182.1 UC1.AP7
OTGEN/CMIN_CHG: PRB10.1 PRB13.1 PUB01.20
OVP_TRIP_P1: PQS03.2 QT5.2 RT63.1 UT1.14
PANEL_BKEN_EC: RP2.8 UE1.117
PBAT_CHG_SMBCLK: PD5.3 PR42.2 PRB16.1 RE9.1 UE1.9
PBAT_CHG_SMBDAT: PD5.2 PR37.2 PRB14.1 RE8.1 UE1.8
PBAT_PRES#: CE16.1 PC14.1 PD6.2 PR39.2 PR41.1 PRB25.2 UE1.29
PC10: RT66.1 RT67.1 UT5.56
PC11: RT68.1 RT69.1 UT5.55
PC20: RT70.1 RT71.1 UT5.54
PC21: RT72.1 RT73.1 UT5.53
PCH_BATLOW#: RC89.1 UC1.AU13
PCH_DPWROK: RC87.1 RC97.2 UC1.BB20
PCH_ESPI_CLK: RC15.1 UC1.AW9
PCH_ESPI_IO0: RPC2.1 UC1.AY13
PCH_ESPI_IO1: RPC2.2 UC1.BA13
PCH_ESPI_IO2: RPC2.3 UC1.BB13
PCH_ESPI_IO3: RPC2.4 UC1.AY12
PCH_JTAG_TCK1: RC147.1 TPC3.1(TP-1) UC1.B56
PCH_PCIE_WAKE#: RC99.2 UC1.BB15
PCH_PLTRST#: RC108.1 UC1.AN10 UC4.1 UC4.2 UM2.2
PCH_POPIRCOMP: RC120.1 UC1.AU16
PCH_PRIM_EN: PR1890.1 PRH90.1 RC442.2 RZ21.1
PCH_RSMRST#: RE20.1 UC5.1 UE1.27
PCH_RSMRST#_Q: RC94.2 RC97.1 RC148.1 UC1.AY17 UC5.4
PCH_RTCRST#: CC5.1 JCMOS1.1 QC2.1 RC78.1 UC1.AM16
PCH_RTCX1: CC8.1 RC82.2 UC1.AM18 YC2.1
PCH_RTCX2: CC9.1 RC82.1 UC1.AM20 YC2.2
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 JVGA.12 QC1.1 RC28.2 US1.1
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 JVGA.11 QC1.4 RC27.2 US1.4
PCH_SPI_CLK: RC178.2 RC203.2 RX3.1
PCH_SPI_CLK_R: RC21.2 RC178.1 UC3.6
PCH_SPI_CLK_TPM: RX3.2 UX1.19
PCH_SPI_CS#0: RC18.2 UC1.AU3 UC3.1
PCH_SPI_CS#2: UC1.AU1 UX1.20
PCH_SPI_D0: RC40.2 RC179.2 RX2.1 UC1.AV3
PCH_SPI_D0_R: RC179.1 UC3.5
PCH_SPI_D0_TPM: RX2.2 UX1.21
PCH_SPI_D1: RC180.2 RX1.1 UC1.AW3
PCH_SPI_D1_R: RC180.1 UC3.2
PCH_SPI_D1_TPM: RX1.2 UX1.24
PCH_SPI_D2: RC19.2 RC41.2 RC176.1 UC1.AW2
PCH_SPI_D2_R: RC176.2 UC3.3
PCH_SPI_D3: RC20.2 RC177.1 UC1.AU4
PCH_SPI_D3_R: RC177.2 UC3.7
PCIE_CRX_C_LANTX_N5: CL2.1 UL1.18
PCIE_CRX_C_LANTX_P5: CL1.1 UL1.17
PCIE_CRX_LANTX_N5: CL2.2 UC1.F16
PCIE_CRX_LANTX_P5: CL1.2 UC1.E16
PCIE_CRX_NVMETX_N9: JSSD1.5 UC1.E22
PCIE_CRX_NVMETX_N10: JSSD1.17 UC1.F25
PCIE_CRX_NVMETX_N11: JSSD1.29 UC1.E28
PCIE_CRX_NVMETX_N12: JSSD1.43 UC1.E30
PCIE_CRX_NVMETX_P9: JSSD1.7 UC1.E23
PCIE_CRX_NVMETX_P10: JSSD1.19 UC1.E25
PCIE_CRX_NVMETX_P11: JSSD1.31 UC1.E27
PCIE_CRX_NVMETX_P12: JSSD1.41 UC1.F30
PCIE_CRX_WLANTX_N6: JWLAN1.43 UC1.G18
PCIE_CRX_WLANTX_P6: JWLAN1.41 UC1.F18
PCIE_CTX_C_LANRX_N5: CL4.1 UL1.14
PCIE_CTX_C_LANRX_P5: CL3.1 UL1.13
PCIE_CTX_C_NVMERX_N9: CS16.2 JSSD1.11
PCIE_CTX_C_NVMERX_N10: CS18.2 JSSD1.23
PCIE_CTX_C_NVMERX_N11: CS20.2 JSSD1.35
PCIE_CTX_C_NVMERX_N12: CS22.2 JSSD1.47
PCIE_CTX_C_NVMERX_P9: CS17.2 JSSD1.13
PCIE_CTX_C_NVMERX_P10: CS19.2 JSSD1.25
PCIE_CTX_C_NVMERX_P11: CS21.2 JSSD1.37
PCIE_CTX_C_NVMERX_P12: CS23.2 JSSD1.49
PCIE_CTX_C_WLANRX_N6: CW1.2 JWLAN1.37
PCIE_CTX_C_WLANRX_P6: CW2.2 JWLAN1.35
PCIE_CTX_LANRX_N5: CL4.2 UC1.C19
PCIE_CTX_LANRX_P5: CL3.2 UC1.D19
PCIE_CTX_NVMERX_N9: CS16.1 UC1.B23
PCIE_CTX_NVMERX_N10: CS18.1 UC1.D23
PCIE_CTX_NVMERX_N11: CS20.1 UC1.D24
PCIE_CTX_NVMERX_N12: CS22.1 UC1.A25
PCIE_CTX_NVMERX_P9: CS17.1 UC1.A23
PCIE_CTX_NVMERX_P10: CS19.1 UC1.C23
PCIE_CTX_NVMERX_P11: CS21.1 UC1.C24
PCIE_CTX_NVMERX_P12: CS23.1 UC1.B25
PCIE_CTX_WLANRX_N6: CW1.1 UC1.D20
PCIE_CTX_WLANRX_P6: CW2.1 UC1.C20
PCIE_RCOMPN: RC65.1 UC1.F5
PCIE_RCOMPP: RC65.2 UC1.E5
PCIE_WAKE#: JSSD1.54 RC99.1 RE12.1 RW15.2 UE1.4 UL1.21
PECI_EC: DE1.1 RE23.2 UC1.A54
PEG_CLKREQ#: RV153.2 RV368.2 UV1.N7
PEG_GTX_C_HRX_N0: CV2.1 UC1.G13
PEG_GTX_C_HRX_N1: CV4.1 UC1.F11
PEG_GTX_C_HRX_N2: CV6.1 UC1.G16
PEG_GTX_C_HRX_N3: CV8.1 UC1.F15
PEG_GTX_C_HRX_P0: CV1.1 UC1.H13
PEG_GTX_C_HRX_P1: CV3.1 UC1.G11
PEG_GTX_C_HRX_P2: CV5.1 UC1.H16
PEG_GTX_C_HRX_P3: CV7.1 UC1.G15
PEG_GTX_HRX_N0: CV2.2 UV1.AG31
PEG_GTX_HRX_N1: CV4.2 UV1.AF28
PEG_GTX_HRX_N2: CV6.2 UV1.AF26
PEG_GTX_HRX_N3: CV8.2 UV1.AD26
PEG_GTX_HRX_P0: CV1.2 UV1.AH30
PEG_GTX_HRX_P1: CV3.2 UV1.AG29
PEG_GTX_HRX_P2: CV5.2 UV1.AF27
PEG_GTX_HRX_P3: CV7.2 UV1.AD27
PEG_HTX_C_GRX_N0: CV306.2 UC1.A17
PEG_HTX_C_GRX_N1: CV305.2 UC1.C16
PEG_HTX_C_GRX_N2: CV309.2 UC1.C17
PEG_HTX_C_GRX_N3: CV304.2 UC1.A19
PEG_HTX_C_GRX_P0: CV312.2 UC1.B17
PEG_HTX_C_GRX_P1: CV308.2 UC1.D16
PEG_HTX_C_GRX_P2: CV307.2 UC1.D17
PEG_HTX_C_GRX_P3: CV313.2 UC1.B19
PEG_HTX_GRX_N0: CV306.1 UV1.AE31
PEG_HTX_GRX_N1: CV305.1 UV1.AD28
PEG_HTX_GRX_N2: CV309.1 UV1.AC31
PEG_HTX_GRX_N3: CV304.1 UV1.AB28
PEG_HTX_GRX_P0: CV312.1 UV1.AF30
PEG_HTX_GRX_P1: CV308.1 UV1.AE29
PEG_HTX_GRX_P2: CV307.1 UV1.AD30
PEG_HTX_GRX_P3: CV313.1 UV1.AC29
PEQ: RT83.1 RT84.1 UT5.8
PHASE_VCORE1: PCI09.2 PUI01.7
PHASE_VCORE2: PCI29.2 PUI02.7
PHASE_VGT1: PCG09.2 PUG01.7
PL0: RT79.1 UT5.60
PL1: RT80.1 RT81.1 UT5.1
PLL_ANALOG_IN: TP68.1(TP-1) UV1.AA1
PLL_ANALOG_OUT: RV83.1 UV1.AA3
PLT_RST_VGA#: RV4.1 UE1.23 UV1.AL27 UV2.4
PLTRST#: JSSD1.50 JWLAN1.52 JWWAN.16 RC108.2 RC109.1 RE65.1 UC4.4 UL1.19 UV2.1 UX1.17
PME#: TP12.1(TP-1) UC1.AU11
POK: CC10.1 DC2.1 PR35.1 PR304.2 PR504.2 PR1801.1 PRH01.1 PU301.9 PU501.9 RC102.1 RT6.2 UC5.2
POWER_SW#_MB: EC2901.1 ED2901.3 JPWR1.2 JPWR2.4 RE43.2 SW1.1 SW2.1 TPS8.1(TP-1) TPS9.1(TP-1)
POWER_SW_IN#: CE33.1 RE41.2 RE43.1 UE1.127
PRIM_PWRGD: PR1803.2 PU1801.4 UE1.30
PROCHOT: RE53.2 UE1.83 UE2.2
PROJECT_ID0: RC53.2 RC54.1 UC1.AK6
PROJECT_ID1: RC51.2 RC52.1 UC1.AK7
PS_0: CV29.1 RV8.2 RV9.1 UV1.AC19
PS_1: CV28.1 RV11.2 RV12.1 UV1.AD19
PS_2: CV11.1 RV13.1 RV28.2 UV1.AE17
PS_3: CV15.1 RV15.2 RV16.1 UV1.AE20
PS_ID: PD2.1 PR1.2 PR5.1 UE1.36
PSID: PJPDC1.3 PL3.1
PSID-1: PQ2.2 PR3.2 PR6.1
PSID-3: PQ1.3 PR1.1
PTP_DIS#: D6.1 UE1.90
PWM1_2PH_CPU: PUI01.1 PUZ01.16
PWM2_2PH_CPU: PUI02.1 PUZ01.17
PWM_1A_CPU: PUG01.1 PUZ01.22
PWM_1B_CPU: PUA01.2 PUZ01.36
PWR_LED_R#: Q20.2 Q21.1
PWR_SE1: PD11.1 PR63.1
PWR_SE2: PQS30.5 PQS30.6 PR63.2 PRS45.1
PWR_SELECT: PR64.2 PR65.2 PR66.1 RE89.2
PWR_SELECT1: PQS30.2 PR65.1 PU2.1
PWR_SELECT2: PQ15.2 PR21.2 PR46.2 PR49.1 PU2.4
PWRGD_VGA: PRV17.2 PRV20.1 PUV01.9 PUV01.20
PX_EN: TP73.1(TP-1) UV1.AB16
REGOUT: CL15.1 RL1.1 UL1.24
RESET_OUT#: CE31.1 RE16.1 UC1.BA20 UE1.73
RING2: RA25.2 RA35.1 UA1.17
RING2_R: CA36.1 CA42.1 DA5.3 JHP1.4 RA35.2
ROSC_COREGT_CPU: PRZ64.1 PUZ01.14
ROSC_SAUS_CPU: PRZ60.1 PUZ01.15
RSET: RL2.2 UL1.31
RTC_DET#: Q1.1 RC46.1 UC1.P1
RTC_PWR: D1.3 Q1.2 R1.1 R2.1
RTCRST_ON: C61.1 D7.1 Q23.2 QC2.2 R78.2 R79.2 RC164.1 UE1.31
RUNPWROK: RE42.2 UE1.48
SATA3_CRX_C_HDDTX_N0: CS3.2 EU3101.4 EU3101.7 JHDD.16 JHDD1.5
SATA3_CRX_C_HDDTX_P0: CS4.2 EU3101.5 EU3101.6 JHDD.15 JHDD1.6
SATA3_CRX_HDDTX_N0: CS3.1 UC1.F20
SATA3_CRX_HDDTX_P0: CS4.1 UC1.E20
SATA3_CTX_C_HDDRX_N0: CS2.2 EU3101.2 EU3101.8 JHDD.18 JHDD1.3
SATA3_CTX_C_HDDRX_P0: CS1.2 EU3101.1 EU3101.9 JHDD.19 JHDD1.2
SATA3_CTX_HDDRX_N0: CS2.1 UC1.B21
SATA3_CTX_HDDRX_P0: CS1.1 UC1.A21
SATA_CRX_C_ODDTX_N1: CS10.1 JODD1.9 JODD1.10
SATA_CRX_C_ODDTX_P1: CS9.1 JODD1.11 JODD1.12
SATA_CRX_ODDTX_N1: CS10.2 UC1.G21
SATA_CRX_ODDTX_P1: CS9.2 UC1.F21
SATA_CTX_C_ODDRX_N1: CS11.1 JODD1.5 JODD1.6
SATA_CTX_C_ODDRX_P1: CS12.1 JODD1.3 JODD1.4
SATA_CTX_ODDRX_N1: CS11.2 UC1.D21
SATA_CTX_ODDRX_P1: CS12.2 UC1.C21
SATA_LED#: Q25.2 R77.2 R81.1 RC69.1 UC1.H1
SATA_LED#_R: Q22.3 Q25.3 R81.2 R83.2
SATA_ODD_DA#: JODD1.23 JODD1.24 TP46.1(TP-1)
SATA_ODD_PRSNT#: JODD1.15 JODD1.16 RC194.1 UC1.AB1
SCLK_CPU: PRZ46.1 PUZ01.34
SD_RCOMP: RC130.1 UC1.AB7
SD_READ_MODE: JIOB1.1 UC1.AN5
SDIO_CPU: PRZ48.1 PUZ01.32
SIO_EXT_WAKE#: RC47.1 UC1.AD3 UE1.116
SIO_PWRBTN#: RC93.2 UC1.BA15 UE1.52
SIO_SLP_A#: TPS6.1(TP-1) UC1.AN16
SIO_SLP_LAN#: RC88.1 TP10.1(TP-1) UC1.AW15
SIO_SLP_S0#: RE90.2 RX9.2 RX10.2 TPS2.1(TP-1) UC1.AT11 UC9.2
SIO_SLP_S3#: DZ4.1 RC103.1 RZ2.1 TPS3.1(TP-1) UC1.AP15 UC9.1 UZ3.3 UZ3.5
SIO_SLP_S4#: DZ5.1 PR2501.1 PRM08.1 RZ1.1 TPS4.1(TP-1) UC1.BA16
SIO_SLP_S5#: TPS5.1(TP-1) UC1.AY16
SIO_SLP_SUS#: PR1806.1 PRH13.1 RE88.2 UC1.AN15
SIO_SLP_WLAN#: TP11.1(TP-1) UC1.BB17
SLEEVE: RA26.2 RA38.1 UA1.18
SLEEVE_R: CA37.1 CA41.1 DA5.2 JHP1.3 RA38.2
SM_RCOMP0: RC10.1 UC1.AR18
SM_RCOMP1: RC11.1 UC1.AT18
SM_RCOMP2: RC12.1 UC1.AU18
SMB_ALERT#: RC37.1 UC1.R10
SML0_SMBCLK: CC95.1 RC33.1 UC1.R9
SML0_SMBDATA: RC34.1 UC1.W2
SML1_SMBCLK: CC96.1 JWWAN.14 Q11.3 QV1.6 RC31.1 RE11.1 UC1.W3 UE1.12
SML1_SMBDATA: JWWAN.15 Q11.6 QV1.3 RC32.1 RE10.1 UC1.V3 UE1.11
SNB_VCCSA: PCA09.1 PRA02.2
SNUB1_CHG: PCB36.1 PRB17.2
SNUB2_CHG: PCB37.1 PRB18.2
SNUB_+1.35VGPU: PCW13.1 PRW07.2
SNUB_+1VALW: PCH13.1 PRH07.2
SOC_XDP_TDI: RC141.1 TPC5.1(TP-1) UC1.D59 UC1.D60
SOC_XDP_TDO: RC142.1 TPC1.1(TP-1) UC1.A56 UC1.A61
SOC_XDP_TMS: RC140.1 TPC4.1(TP-1) UC1.C59 UC1.C60
SOC_XDP_TRST#: TPC6.1(TP-1) UC1.B59 UC1.C61
SPKR: DA3.3 RC128.2 UC1.AW5
SRTCRST#: CC4.1 RC77.1 UC1.AN18
SSD_DEVSLP: JSSD1.38 UC1.J3
SUSCLK: RC74.2 RC75.2 RC110.1 UC1.BA17
SUSCLK_EC: RC75.1 RE45.2
SUSCLK_WLAN: JWLAN1.50 RC74.1
SVI2_SVC: PUV01.3 RV84.1 RV89.2 RV157.2
SVI2_SVD: PUV01.5 RV87.1 RV88.2 RV155.2
SVI2_SVT: PUV01.7 RV156.2
SW_USB_PN1: LU1.3 RU2.1 RU22.2 UU2.11
SW_USB_PP1: LU1.2 RU1.1 RU21.2 UU2.10
SYS_LED_MASK#: R71.1 RE81.2 RE540.2 U4.1
SYS_PWROK: RE68.1 UC1.B6 UE1.28
SYS_RESET#: RC86.2 TPS1.1(TP-1) UC1.B5
SYSPWR_PRES: RE29.1 RE32.1 RE88.1 UE1.120
T_CRIT#: R29.2 U2.4
TESTEN: RV17.2 RV154.2 UV1.K7
THM_SML1_CLK: Q11.4 R49.2 U2.8
THM_SML1_DATA: Q11.1 R48.2 U2.7
TON_1.2V: PRM07.2 PUM01.9
TOP_MUX_N: LT3.2 RT55.1 UT3.17
TOP_MUX_N_R: EU4001.2 EU4001.8 JUSBC1.A7 LT3.1 RT55.2
TOP_MUX_P: LT3.3 RT56.1 UT3.18
TOP_MUX_P_R: EU4001.4 EU4001.7 JUSBC1.A6 LT3.4 RT56.2
TOUCH_PAD_INTR#: DZ3.2 RC114.2 UC1.BA5
TOUCH_PANEL_PD#: RC118.2 UC1.AY5
TOUCH_SCREEN_PD#: D5.2 R19.2 RC115.2 RC118.1
TP_EN: C16.1 JEDP1.39 R19.1
TP_EN#: R38.1 UE1.49
TP_LOCK#: D6.2 JTP1.3 R41.2
TP_WAKE_KBC#: DZ3.1 Q9.1 RE14.1 UE1.33
TPM_ID: RC63.2 RC64.1 UC1.D8
TPM_SPI_IRQ#: RX4.2 UC1.M2 UX1.18
TSENSE_1PH_CPU: PCZ36.1 PRZ63.1 PUZ01.23
TSENSE_1PH_CPU_R: PHZ05.1 PRZ63.2 PRZ65.1
TSENSE_2PH_CPU: PCZ22.1 PRZ34.2 PUZ01.11
TSENSE_2PH_CPU_R: PHZ04.1 PRZ34.1 PRZ36.1
TX_P80DATA: JWLAN1.38 RW6.2
TYPEC_DP_AUXN: CT33.1 RT117.2 UT5.29
TYPEC_DP_AUXN_C: CT33.2 CT90.1 RT97.2 UT2.25
TYPEC_DP_AUXP: CT32.1 RT116.2 UT5.28
TYPEC_DP_AUXP_C: CT32.2 CT89.1 RT94.2 UT2.24
TYPEC_DP_N0: CT25.2 UT5.39
TYPEC_DP_N0_C: CT25.1 CT82.1 UT2.10
TYPEC_DP_N1: CT27.2 UT5.36
TYPEC_DP_N1_C: CT27.1 CT84.1 UT2.13
TYPEC_DP_N2: CT29.2 UT5.34
TYPEC_DP_N2_C: CT29.1 CT86.1 UT2.16
TYPEC_DP_N3: CT31.2 UT5.31
TYPEC_DP_N3_C: CT31.1 CT88.1 UT2.19
TYPEC_DP_P0: CT24.2 UT5.40
TYPEC_DP_P0_C: CT24.1 CT81.1 UT2.9
TYPEC_DP_P1: CT26.2 UT5.37
TYPEC_DP_P1_C: CT26.1 CT83.1 UT2.12
TYPEC_DP_P2: CT28.2 UT5.35
TYPEC_DP_P2_C: CT28.1 CT85.1 UT2.15
TYPEC_DP_P3: CT30.2 UT5.32
TYPEC_DP_P3_C: CT30.1 CT87.1 UT2.18
TYPEC_RX1N: DT8.1 JUSBC1.B10 UT2.31
TYPEC_RX1P: DT7.1 JUSBC1.B11 UT2.30
TYPEC_RX2N: DT5.1 JUSBC1.A10 UT2.39
TYPEC_RX2P: DT6.1 JUSBC1.A11 UT2.40
TYPEC_SMBCLK: RE31.1 RT119.1 UE1.91 UT1.17
TYPEC_SMBCLK_R: RT119.2 UT3.3
TYPEC_SMBDA: RE30.1 RT118.1 UE1.89 UT1.16
TYPEC_SMBDA_R: RT118.2 UT3.4
TYPEC_TX1N: CT41.1 UT2.34
TYPEC_TX1N_C: CT41.2 DT4.1 JUSBC1.A3
TYPEC_TX1P: CT40.1 UT2.33
TYPEC_TX1P_C: CT40.2 DT3.1 JUSBC1.A2
TYPEC_TX2N: CT42.1 UT2.36
TYPEC_TX2N_C: CT42.2 DT9.1 JUSBC1.B3
TYPEC_TX2P: CT43.1 UT2.37
TYPEC_TX2P_C: CT43.2 DT10.1 JUSBC1.B2
UART1_CTS#: TP79.1(TP-1) UC1.AB4
UART1_RTS#: TP88.1(TP-1) UC1.AC3
UART_P80: JWLAN1.32 RW10.2
UG1_CHG: PQB01.1 PUB01.11
UG1_VGA: PQV01.1 PQV02.1 PUV01.22
UG2_CHG: PQB02.1 PUB01.5
UG2_VGA: PQV03.1 PQV04.1 PUV01.29
UG_1.2V: PQM01.1 PUM01.17
UG_VCCSA: PQA01.1 PUA01.8
USB2_ID: RC67.1 UC1.AG3
USB2_VBUSSENSE: RC68.1 UC1.AG4
USB3_CRX_C_DTX_N4: CT37.2 UT2.4
USB3_CRX_C_DTX_P4: CT36.2 UT2.5
USB3_CRX_DTX_N1: LU3.3 RU6.2 UC1.H8
USB3_CRX_DTX_N1_C: EU2601.1 EU2601.9 JUSB1.5 LU3.4 RU6.1
USB3_CRX_DTX_N2: JWWAN.8 UC1.J6
USB3_CRX_DTX_N3: LU6.3 RU12.2 UC1.J10
USB3_CRX_DTX_N3_C: EU2603.1 EU2603.9 JUSB2.5 LU6.4 RU12.1
USB3_CRX_DTX_N4: CT37.1 UC1.E10
USB3_CRX_DTX_P1: LU3.2 RU5.2 UC1.G8
USB3_CRX_DTX_P1_C: EU2601.2 EU2601.8 JUSB1.6 LU3.1 RU5.1
USB3_CRX_DTX_P2: JWWAN.9 UC1.H6
USB3_CRX_DTX_P3: LU6.2 RU11.2 UC1.H10
USB3_CRX_DTX_P3_C: EU2603.2 EU2603.8 JUSB2.6 LU6.1 RU11.1
USB3_CRX_DTX_P4: CT36.1 UC1.F10
USB3_CTX_C_DRX_N4: CT35.1 UT2.7
USB3_CTX_C_DRX_P4: CT34.1 UT2.8
USB3_CTX_DRX_N1: CU2.1 UC1.C13
USB3_CTX_DRX_N1_C: EU2601.4 EU2601.7 JUSB1.8 LU2.4 RU4.1
USB3_CTX_DRX_N1_R: CU2.2 LU2.3 RU4.2
USB3_CTX_DRX_N2: JWWAN.5 UC1.B13
USB3_CTX_DRX_N3: CU4.1 UC1.B15
USB3_CTX_DRX_N3_C: EU2603.4 EU2603.7 JUSB2.8 LU5.4 RU10.1
USB3_CTX_DRX_N3_R: CU4.2 LU5.3 RU10.2
USB3_CTX_DRX_N4: CT35.2 UC1.C15
USB3_CTX_DRX_P1: CU1.1 UC1.D13
USB3_CTX_DRX_P1_C: EU2601.5 EU2601.6 JUSB1.9 LU2.1 RU3.1
USB3_CTX_DRX_P1_R: CU1.2 LU2.2 RU3.2
USB3_CTX_DRX_P2: JWWAN.6 UC1.A13
USB3_CTX_DRX_P3: CU3.1 UC1.A15
USB3_CTX_DRX_P3_C: EU2603.5 EU2603.6 JUSB2.9 LU5.1 RU9.1
USB3_CTX_DRX_P3_R: CU3.2 LU5.2 RU9.2
USB3_CTX_DRX_P4: CT34.2 UC1.D15
USB20_VCCB: CU17.1 CU21.1 CU22.1 JIOB1.13 JIOB1.14 JIOB1.15 JIOB1.16 UU3.1
USB30_VCCA: CU6.1 CU7.1 CU8.1 CU9.1 CU10.1 CU19.1 CU20.1 JP13.2 JUSB1.1 UU2.12
USB30_VCCC: CU11.1 CU12.1 CU13.1 CU14.1 CU15.1 JP13.1 JUSB2.1 UU1.1
USB_CAMERA_EDP: JEDP1.34 L3.2 R17.1
USB_CAMERA_EDP#: JEDP1.33 L3.3 R18.1
USB_EN#: RE17.1 UE1.13 UU1.4 UU3.4
USB_OC0#: RPC1.3 UC1.A9 UU1.3 UU2.13
USB_OC1#: RPC1.2 UC1.C9 UU3.3
USB_OC2#: RPC1.1 RT120.1 UC1.D9
USB_OC3#: RPC1.4 UC1.B9
USB_PN1: RU22.1 UC1.AB9 UU2.2
USB_PN1_R: EU2602.3 JUSB1.2 LU1.4 RU2.2
USB_PN2: LU9.3 RU16.1 UC1.AD6
USB_PN2_R: JIOB1.7 LU9.4 RU16.2
USB_PN3: LU4.3 RU8.1 UC1.AH3
USB_PN3_R: EU2604.3 JUSB2.2 LU4.4 RU8.2
USB_PN4: LT2.2 RT41.1 UC1.AD9
USB_PN4_R: LT2.1 RT41.2 UT3.2
USB_PN5: L3.4 R18.2 UC1.AJ1
USB_PN6: LU8.3 RU14.1 UC1.AF6
USB_PN6_R: JIOB1.4 LU8.4 RU14.2
USB_PN7: JWLAN1.5 UC1.AH1
USB_PN8: L4.4 R21.2 UC1.AF8
USB_PN8_TPNL: DA6.3 JEDP1.36 L4.3 R21.1
USB_PN9: EU2701.3 JFP.4 JFP1.6 UC1.AG1
USB_PN10: JWWAN.12 UC1.AH7
USB_POWERSHARE_VBUS_EN: RU25.1 UE1.71 UU2.5
USB_PP1: RU21.1 UC1.AB10 UU2.3
USB_PP1_R: EU2602.2 JUSB1.3 LU1.1 RU1.2
USB_PP2: LU9.2 RU15.1 UC1.AD7
USB_PP2_R: JIOB1.6 LU9.1 RU15.2
USB_PP3: LU4.2 RU7.1 UC1.AJ3
USB_PP3_R: EU2604.2 JUSB2.3 LU4.1 RU7.2
USB_PP4: LT2.3 RT42.1 UC1.AD10
USB_PP4_R: LT2.4 RT42.2 UT3.1
USB_PP5: L3.1 R17.2 UC1.AJ2
USB_PP6: LU8.2 RU13.1 UC1.AF7
USB_PP6_R: JIOB1.3 LU8.1 RU13.2
USB_PP7: JWLAN1.3 UC1.AH2
USB_PP8: L4.1 R20.2 UC1.AF9
USB_PP8_TPNL: DA6.2 JEDP1.37 L4.2 R20.1
USB_PP9: EU2701.2 JFP.3 JFP1.5 UC1.AG2
USB_PP10: JWWAN.11 UC1.AH8
USB_PWR_SHR_EN_L#: RU26.2 UE1.118 UU2.6
USBC_B2B_OVP: PQS03.5 PQS03.6 PRS13.2
USBC_B2B_S1: PDS04.1 PDS05.1 PDS06.1 PQS08.2 PRS42.1
USBC_B2B_S1_A: PCS11.1 PQS03.3 PQS04.2 PQS08.1 PRS12.2 PRS14.1
USBC_B2B_S2: PCS12.1 PQS05.2 PQS05.3 PRS25.1 PUS02.4
USBC_B2B_S2_G: PCS10.2 PQS02.4 PQS06.1 PRS09.2 PRS16.1
USBC_B2B_S3: PCS17.1 PQS07.2 PRS18.1
USBC_SW_PROCHOT: PCS19.1 PCS20.1 PQS10.6 PRS28.2
USBCOMP: RC66.1 UC1.AB6
VCI_IN1: RE70.1 UE1.126
VCIN0_PH: C32.1 C33.1 R42.2 R43.2 RE37.2 RH1.1
VCONN_MON_P1: TP89.1(TP-1) UT1.19
VCREF0: CE23.1 RE46.2 RE48.1 UE1.25
VD_IN1_C: C32.2 C33.2 R45.1 RH1.2
VGA_CBL_DET#: JVGA.7 RC207.1 UC1.U4
VGA_DP2_N0: JVGA.3 UT5.49
VGA_DP2_N1: JVGA.6 UT5.46
VGA_DP2_P0: JVGA.2 UT5.50
VGA_DP2_P1: JVGA.5 UT5.47
VGA_DP_AUXN: JVGA.9 RT93.2 UT5.27
VGA_DP_AUXP: JVGA.8 RT98.2 UT5.26
VGA_DP_HPD: JVGA.13 UT5.48
VGA_SMB_CK3: QV1.1 RV6.2 UV1.U7
VGA_SMB_DA3: QV1.4 RV5.2 UV1.U8
VIDALERT_N: PRZ41.2 PRZ47.2 RC152.2 RC153.2
VIDSCLK: PRZ40.2 PRZ46.2 UC1.A63
VIDSOUT: PRZ42.2 PRZ48.2 RC154.2 UC1.D64
VL: PC515.1 PU501.15
VR_CAP: CE24.1 TP44.1(TP-1) UE1.18
VR_HOTL#: PRZ49.1 PUZ01.31
VRALERT#: RC92.1 UC1.AM11
VRAM_ID1: RC59.2 RC60.1 UC1.AP8
VRAM_ID2: RC61.2 RC62.1 UC1.U2
VRMP_CPU: PCZ23.1 PRZ35.2 PUZ01.12
VSA_SEN+: PRZ03.1 RC159.2 UC1.H20
VSA_SEN-: PRZ07.1 RC160.1 UC1.H21
VSN_1A_CPU: PCZ28.1 PRZ52.1 PUZ01.25
VSN_1A_CPU_R: PCZ28.2 PCZ29.1 PRZ52.2 PRZ53.1
VSN_1B_CPU: PCZ07.2 PRZ08.2 PUZ01.44
VSN_2PH_CPU: PCZ11.2 PRZ19.2 PUZ01.48
VSN_2PH_CPU_R: PCZ10.2 PCZ11.1 PRZ18.2 PRZ19.1
VSNN_1B_CPU_R: PCZ06.2 PCZ07.1 PRZ07.2 PRZ08.1
VSP_1A_CPU: PCZ35.2 PRZ58.2 PUZ01.24
VSP_1A_CPU_R: PCZ29.2 PRZ58.1 PRZ59.2 PRZ61.1
VSP_1B_CPU: PCZ04.2 PRZ04.2 PUZ01.45
VSP_2PH_CPU: PCZ10.1 PRZ14.2 PUZ01.47
VSPP_1B_CPU_R: PCZ04.1 PCZ06.1 PRZ03.2 PRZ04.1
VSUM+_VGA: PCV28.1 PCV30.1 PRV07.2 PRV24.2 PRV28.1 PRV30.1 PUV01.14
VSUM-_VGA: PCV22.2 PCV23.2 PCV28.2 PCV30.2 PCV32.1 PHV02.2 PRV08.2 PRV25.2 PRV30.2 PRV33.1 PRV35.1
VTTREF_1.2V: PCM19.1 PUM01.4
WAKEB: RV162.2 RV163.1 UV1.AJ27
WHITE_LED_BAT: C62.1 Q19.1 R69.2
WHITE_LED_PWR: JPWR2.2 Q20.1
WIFI_RF_EN: DW1.1 RC3.1 RC225.1 RW13.1 UC1.B7
WWAN_CBL_DET#: JWWAN.26 RC208.1 UC1.AB11
XCLK_BIASREF: RC76.1 UC1.E42
XDP_HOOK0: RC148.2 TPC32.1(TP-1)
XDP_ITP_PMODE: RC143.2 TPC7.1(TP-1) UC1.E8
XDP_OBS0_R: TP15.1(TP-1) UC1.C55
XDP_OBS1_R: TP16.1(TP-1) UC1.D55
XDP_OBS2_R: TP17.1(TP-1) UC1.B54
XDP_OBS3_R: TP18.1(TP-1) UC1.C56
XDP_PRDY#: TPC31.1(TP-1) UC1.D56
XDP_PREQ#: TPC30.1(TP-1) UC1.D61
XDP_PRSENT_CPU: RC144.1 RC175.2 TPC33.1(TP-1)
XDP_SPI_IO2: RC41.1 RC145.1 TPC9.1(TP-1)
XDP_SPI_SI: RC40.1 RC139.2 TPC8.1(TP-1)
XTAL24_IN: RC23.1 UC1.E37
XTAL24_IN_R: CC6.1 RC23.2 RC80.2 YC1.3
XTAL24_OUT: RC24.1 UC1.E35
XTAL24_OUT_R: CC7.1 RC24.2 RC80.1 YC1.1
XTALIN: CV17.1 RV20.1 UV1.AM28 YV1.1
XTALOUT: CV18.1 RV20.2 UV1.AK28 YV1.3
N16741477: TP61.1(TP-1) UV1.AB8
N16741489: TP57.1(TP-1) UV1.AD7
N16741505: TP63.1(TP-1) UV1.AB4
N16741517: TP55.1(TP-1) UV1.AD9
N16741525: TP65.1(TP-1) UV1.Y8
N16741803: RV29.2 UV1.AC22
N16741825: RV59.2 UV1.AB22
N16751828: TP58.1(TP-1) UV1.AC8
N16751830: TP54.1(TP-1) UV1.AE8
N16751834: TP52.1(TP-1) UV1.AE9
N16751836: TP50.1(TP-1) UV1.N9
N16751838: TP64.1(TP-1) UV1.AB2
N16751842: TP60.1(TP-1) UV1.AB9
N16751844: TP56.1(TP-1) UV1.AC10
N16751848: TP51.1(TP-1) UV1.L9
N16751852: TP62.1(TP-1) UV1.AB7
N16751854: TP59.1(TP-1) UV1.AC7
N16751856: TP53.1(TP-1) UV1.Y11
N16751858: TP66.1(TP-1) UV1.Y7
N16808781: RV157.1 UV1.AJ11
N16808782: RV155.1 UV1.AK12
N16808783: RV156.1 UV1.AL11
N17003752: JDIMM1.134 RD23.2
N17004366: JDIMM2.134 RD24.2
N17213597: CT8.1 UT1.33
N17283936: QA1.3 RA5.1 RA6.1
N17389450: PC516.1 PD501.2 PR502.2 PR503.2 PR506.2 PR508.1
N17433967: CZ14.2 UZ4.6
N17442062: CZ3.1 UZ1.6
N17462309: JDEG1.9 RE58.2
N17462311: JDEG1.1 RE59.2
N17462343: JESPI1.8 RE65.2
N17569402: RA9.1 UA1.4
N17847259: TP72.1(TP-1) UV1.AL9
N17877344: TP69.1(TP-1) UV1.R1
N17877347: TP70.1(TP-1) UV1.R3
N18330820: CZ19.2 UZ5.10
N18330832: CZ18.2 UZ5.12
N18346546: Q13.1 R37.1
N18346552: C18.2 Q12.2 Q13.2 R38.2
N18346555: C18.1 Q12.3 R35.2
N18618528: TP28.1(TP-1) UC1.AY4
N18618529: TP29.1(TP-1) UC1.BB3
N18618530: TP27.1(TP-1) UC1.BB5
N18855880: R57.2 U1.3
N18983262: CE35.2 RE67.1
N18984098: CA38.2 RA43.1
N19136586: QS1.5 QS1.6 RS3.2
N19719023: TP84.1(TP-1) UT2.29
N20135010: PCV33.2 PRV33.2 PUV01.15
N20135022: PCV33.1 PRV35.2
N20135024: PCV11.1 PRV13.2 PUV01.25
N20135039: PRV19.1 PUV01.11
N20135040: PCV25.1 PCV27.1 PRV29.1 PRV34.2 PUV01.16
N20135043: PCV34.1 PRV36.2 PUV01.17
N20135074: PCV24.1 PRV23.2
N20135091: PCV21.1 PRV21.2
N20135096: PLV01.3 PRV22.1 PRV24.1
N20135098: PLV01.2 PRV25.1
N20135126: PHV01.1 PRV18.1 PRV19.2
N20135134: PCV26.1 PRV26.2 PRV29.2 PRV31.1 PRV32.1 PUV01.18
N20135137: PCV25.2 PRV26.1
N20135139: PCV31.1 PRV32.2
N20135141: PCV26.2 PCV29.2 PRV27.1 PUV01.19
N20135144: PCV29.1 PRV31.2
N20135171: PHV02.1 PRV28.2
N20135184: PLV02.3 PRV03.1 PRV07.1
N20135197: PCV09.1 PRV06.2
N20135212: PCV08.1 PRV01.2
N20135219: PLV02.2 PRV08.1
N20135248: PUV01.39 PUV01.40
N20135251: PRV02.1 PUV01.36 PUV01.37 PUV01.38
N20135257: PRV10.1 PUV01.1
N20135258: PRV09.1 PUV01.2
N20135263: PRV04.1 PUV01.34
N20135264: PRV05.1 PUV01.32 PUV01.33
N20558038: CC14.1 DZ4.2 RC103.2 UC6.2
N20834517: QT5.3 RT62.1 UT7.4
N20835268: CT17.1 DT2.2 RT121.1 UT4.5
N20835276: CT53.1 QT4.1 RT59.2 UT4.3 UT4.4
N20835295: CT54.1 QT4.2 RT6.1
N21269026: PCI32.1 PRI23.2
N21273981: PCG12.1 PRG03.2
N21379353: PC508.1 PU501.16 PU501.17
N21484820: PC1801.1 PC1808.1 PC1809.1 PC1810.1 PJP1801.2 PL1811.2 PU1801.8 PU1801.9 PU1801.10
N21562772: PDB05.2 PRB44.2
N21562775: PDB04.1 PDB05.1 PUB02.1
N21599913: RL7.2 UL2.3
N21620369: Q15.2 R65.2 R67.1
N21620701: Q4.1 R67.2
N21664134: RS5.1 US2.3
N21721769: RT82.1 UT5.20
N21721781: CT76.1 UT5.17
N21725461: TP85.1(TP-1) UT2.32
N22121555: RW12.2 UW1.3
N22253138: LED1.4 R68.1
N22253145: LED1.2 R69.1
N22308928: JHDD.4 RS6.2
N22328185: PQ1.2 PQ2.1 PR4.2 PR7.1
N22328194: PD1.2 PL3.2 PQ1.1 PR3.1
N22328218: PQ13.2 PR31.2 PR35.2 PR45.1
N22328219: PQ13.3 PR32.2
N22328225: PC13.2 PQ12.5 PR40.1
N22328232: PQ12.2 PR36.2 PR44.2
N22328238: PC14.2 PQ11.2 PR43.1
N22328240: PQ13.5 PQ13.6 PR34.2 PR38.1
N22328258: PJP2.1 PJPDC1.1 PJPDC1.2 PL2.1
N22328295: PD3.1 PR7.2
N22328311: PQ6.1 PR12.2
N22328315: PC5.2 PQ3.4 PR8.2 PR10.1
N22328320: PQ5.1 PR10.2
N22328363: PBATT1.5 PR39.1
N22328399: PQS10.2 PRS26.2 PRS27.2
N22328441: PD10.3 PR14.2 PR16.1
N22328488: PQ17.1 PR48.2
N22328506: PCS19.2 PQS10.5 PRS29.1
N22328522: PCS20.2 PQS11.2 PRS30.1
N22330692: PCS09.2 PQS01.4 PQS13.1 PRS08.2 PRS11.1
N22330700: PCS03.1 PRS01.1 PRS03.2 PRS05.1 PUS01.3
N22330701: PCS04.1 PRS01.2 PRS02.2 PRS39.1 PUS01.1
N22330705: PCS02.1 PRS04.2 PRS06.1 PUS01.2
N22330759: PQS04.1 PRS11.2
N22330768: PQS07.1 PRS15.2
N22330771: PQS05.6 PRS16.2
N22330812: PQS06.2 PRS10.2 PRS15.1
N22330841: PQS05.5 PUS03.4
N22330850: PDS03.1 PRS42.2 PUS03.2
N22330869: PDS05.2 PRS33.2
N22330872: PDS04.2 PRS32.2
N22330878: PDS06.2 PRS23.2
N22330880: PQS14.1 PRS18.2 PRS34.2 PRS45.2
N22330884: PQS14.2 PRS35.1
N22330886: PQS12.1 PRS37.2
N22330887: PQS13.2 PRS36.2 PRS37.1
N22330889: PQS12.2 PRS38.2
N22330904: PDS03.2 PRS40.2
N22330905: PDS03.3 PRS41.2
N22369403: PRS02.1 PRS43.2 PRS44.1
N22579656: RC201.1 UC1.AY3
N22579745: RC202.1 UC1.AY71
N22620462: TP86.1(TP-1) UC1.AD1
N22620469: TP87.1(TP-1) UC1.AD2
N22625387: RT99.2 UT5.43
N22625826: RT100.2 UT5.33
N22647893: RE81.1 RE541.2 UE1.21
N22693381: RX8.1 UX1.2
N22693418: CX5.1 CX6.1 CX7.1 RX6.2 RX7.2 UX1.14 UX1.22
N22693593: RX5.1 UX1.27
N22726181: RT101.1 UT2.23
N22826101: RE84.2 RE540.1 UE1.55
N22826272: TPS11.1(TP-1) UC1.AP11
N22826301: TPS10.1(TP-1) UC1.AR13
N22894187: RE85.1 UE1.42
N23005873: RL17.1 RL21.1 UL1.26
N23415623: RE89.1 UE1.96
N23416702: RE90.1 RE91.2 UE1.88
N23626434: R30.1 U3.3
N23688491: RX9.1 UX1.29
N23690231: RT115.1 UT5.18
N23832113: DW1.2 JWLAN1.56 RW13.2
N23832116: DW2.2 JWLAN1.54 RW14.2
N23832154: JWLAN1.55 RW15.1
N23832410: RX10.1 UX1.3
N23852299: Q24.1 R73.2
N23852303: C60.1 D7.2 Q24.2 R78.1
N24193884: PQS30.3 PR61.2 PR62.1 PU1.4
N24263922: JP14.2 UT7.1
N24264259: RT120.2 UT7.3
N24265247: RC227.1 SW3.3
N24321471: JSSD1.10 R77.1
N24339159: TP76.1(TP-1) UC1.AN11
N24339162: TP77.1(TP-1) UC1.AN13
N24377611: Q25.5 Q25.6 R82.2
N24460586: CZ46.2 RZ21.2 UZ7.3
N24460608: CZ33.2 UZ7.6
N24460612: RZ10.1 UZ7.7 UZ7.8
N24468099: QT3.1 RT33.2
N24557362: TP90.1(TP-1) UV1.U6
N24988672: RT39.1 UT3.15
N24988674: RT40.1 UT3.11
N25133961: DI1.3 RI13.2
N25133963: DI1.2 RI14.2
N28424999: TP30.1(TP-1) UC1.AW71
N28425002: TP31.1(TP-1) UC1.AW70
N28810503: CZ10.1 UZ3.12
N28810563: CZ11.1 UZ3.10
N28842863: CC56.1 UC1.AL1
N28843886: CC69.1 UC1.BB10
N28856399: TP19.1(TP-1) UC1.BA70
N28856402: TP20.1(TP-1) UC1.BA68
N28857231: TP21.1(TP-1) UC1.BB68
N28857234: TP22.1(TP-1) UC1.BB69
N28857237: TP23.1(TP-1) UC1.AK13
N28857240: TP24.1(TP-1) UC1.AK12
N28861827: RC138.1 UC1.C64
N28938619: RC203.1 UC1.AV2
N28938912: CC2.2 RC21.1
N29708599: TP25.1(TP-1) UC1.AU5
N29708601: TP26.1(TP-1) UC1.AT5
N32433695: RV120.1 UV14.J13
N32433703: RV116.1 UV14.J1
N32433714: RV118.1 UV14.J10
N32434049: RV121.1 UV15.J13
N32434050: RV117.1 UV15.J1
N32434053: RV119.1 UV15.J10
N32437553: RV123.1 UV12.J13
N32437559: RV132.1 UV13.J13
N32437560: RV131.1 UV13.J1
N32437563: RV133.1 UV13.J10
N32842463: RC137.2 UC1.U11 UC1.U12
N33188643: CA31.1 RA23.2 RA24.1
N37640332: RV2.2 UV1.N10
N37640410: RV3.1 UV1.AA22
N37828209: RV1.1 UV1.Y22
N38038746: CV96.1 RV36.2 RV37.2
N38038992: CV98.2 UV1.K8
N38038994: CV99.2 UV1.L7
N38038995: CV98.1 RV40.2
N38038996: CV99.1 RV41.2
N38349725: RV39.2 UV1.K25
N38996077: RV134.1 UV12.J1
N38996080: RV135.1 UV12.J10
N40598435: PC307.1 PR301.2
N40598500: PC507.1 PR501.2
N40598503: PC315.2 PR306.1
N40598539: PC517.2 PR509.1
N40598619: PD501.1 PR507.2
N40664383: JDIMM1.165 TP41.1(TP-1)
N40665360: JDIMM2.165 TP42.1(TP-1)
N40665398: JDIMM2.162 TP43.1(TP-1)
N41527020: JDIMM1.162 TP40.1(TP-1)
N42785906: PCB35.1 PRB21.1 PUB01.3
N42785908: PDB01.1 PDB02.1 PDB03.1 PRB08.1
N42785925: PRB01.3 PRB03.1
N42785929: PRB28.1 PUB01.29
N42785931: PCB40.1 PRB28.2 PRB34.1 PRB35.1
N42785953: PRB31.1 PRB33.1 PUB01.30
N42785972: PDB04.3 PRB37.1 PRB38.2
N42786037: PRB12.3 PRB36.2
N42786187: PRB42.1 PUB02.4
N42786400: PRB12.2 PRB32.2
N42787412: PRB41.2 PUB02.2
N42787418: PDB04.2 PRB40.2
N42787433: PRB27.2 PRB29.2 PUB01.26
N42787440: PCB42.1 PRB30.2
N42787460: PCB25.1 PRB06.2
N42787464: PRB29.1 ZTB01.1(TP-1)
N42787500: PCB30.2 PRB15.1
N42787538: PRB01.2 PRB02.1
N42787589: PRB14.2 PUB01.21
N42787591: PRB16.2 PUB01.22
N42787599: PRB19.2 PUB01.23 ZTB02.1(TP-1)
N45784517: PCZ02.1 PCZ08.1 PCZ09.1 PRZ06.2 PUZ01.41
N45784764: PRZ16.2 PUZ01.38
N45784907: PCZ26.2 PCZ27.2 PCZ33.1 PRZ51.2 PUZ01.28
N45784946: PCZ01.2 PRZ01.1
N45784991: PCZ13.1 PRZ20.2
N45785219: PCZ35.1 PRZ61.2
N45789065: PCI12.1 PRI03.2
N47599587: PCZ16.1 PRZ24.2
N47697054: PRH05.2 PUH01.7
N47701287: PCH11.1 PRH11.2 PUH01.11
N47701297: PCH10.1 PUH01.9
N47710281: PC2504.1 PR2504.2 PU2501.4
N47714748: PCM11.1 PRM01.2
N47719295: PCM13.1 PRM05.1 PUM01.12
N47727863: PCW11.1 PRW11.2 PUW01.11
N47727869: PCW10.1 PUW01.9
N47735962: PRW05.2 PUW01.7
N47772279: PCZ31.2 PRZ55.1
N47887852: PC1806.1 PR1804.2
N48572179: PCH14.2 PRH12.1
N48572231: PCW14.2 PRW13.1
N124752685: CD30.2 RD11.1
N124753277: CD59.2 RD22.1
N227673600: RU23.1 UU2.15
N227673690: RU24.1 UU2.16
N248688580: PRB26.1 PUB01.27
N248743791: PHZ01.2 PRZ10.1

Pads without a net: ED2901 2; EU4012 2; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JEDP1 5 6 9; JHDD 1 2 6 7; JHDMI1 13 14; JKB1 28 29; JKBBL1 3; JPWR2 1; JSSD1 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67 68; JWLAN1 6 16 17 19 20 21 22 23 24 25 27 28 29 30 31 34 36 40 42 44 46 48 58 59 60 61 62 64 65 66 67 68 70 71 73; JWWAN 25; PD1 3; PD6 3; PJPDC1 4; PU1 3; PU301 10 15; PU501 10; PU1801 1 7; PU2501 1 5; PUB01 13; PUG01 6 13 17 19; PUI01 6 13 17 19; PUI02 6 13 17 19; PUS01 5 6 7; PUV01 4 35; RP1 4 5; RP2 4 5; TL1 4 5 12 13; TL2 4 5 12 13; UA1 11 12 14 15 23 24 48; UC1 A3 A4 A6 A7 A11 A26 A27 A29 A31 A33 A36 A38 A45 A47 A52 A65 A69 AB12 AB13 AB62 AC63 AD11 AD12 AE62 AE63 AF11 AF12 AF13 AG62 AH9 AH10 AH11 AH12 AJ62 AK9 AK10 AK52 AK53 AK55 AK56 AK58 AK60 AK62 AK70 AL25 AL27 AL53 AL56 AL60 AL61 AL63 AM53 AM56 AM58 AN7 AN8 AP13 AP56 AR56 AT10 AT15 AU2 AU7 AU56 AU58 AU63 AW1 AW7 AW11 AW13 AW17 AW20 AW48 AW68 AW69 AY1 AY2 AY7 AY8 AY9 AY20 AY21 AY68 B2 B3 B11 B26 B27 B29 B31 B33 B36 B38 B45 B47 B52 B69 B70 BA3 BA4 BA7 BA8 BA9 BB2 BB4 BB7 BB9 BB11 BB57 BB66 C2 C4 C11 C12 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C54 C70 C71 D1 D3 D4 D5 D7 D12 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D54 D71 E1 E2 E38 E40 E61 F6 F50 F52 F60 F61 F65 G1 G2 G3 G50 G61 G65 H2 H3 H5 H11 H63 J2 J5 J68 J71 K45 K46 L6 M4 N1 N2 N3 N7 N9 N11 N12 P2 P62 U8 U9 V1 V2 V62 W7 W10 W11 W12; UC2 1; UC6 1; UC7 1; UE1 63 97; UE2 1; UM1 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E12 E13 E14 F1 F2 F3 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; UM2 1; UT1 3 4 6 21 22 23 24 30 34 35 37 38 39 40; UT3 6 7 19 20; UT5 4 14 22 23 41 42 44 45; UU2 9; UV1 AA5 AA6 AA29 AA31 AB23 AB25 AB26 AB27 AB30 AC1 AC3 AC5 AC6 AC16 AC23 AC25 AD2 AD4 AD10 AD11 AD13 AD16 AD22 AD23 AD24 AE1 AE3 AE5 AE6 AE10 AE11 AE13 AE16 AE19 AE22 AE23 AE24 AE25 AE26 AF2 AF4 AF6 AF7 AF8 AF9 AF10 AF11 AF13 AF16 AF17 AF22 AF24 AF25 AG1 AG3 AG5 AG6 AG7 AG8 AG9 AG10 AG11 AG13 AG15 AG16 AG17 AG18 AG19 AG20 AG21 AG22 AG24 AG25 AG26 AH1 AH3 AH5 AH6 AH8 AH12 AH16 AH18 AH20 AH22 AH24 AH26 AJ7 AJ9 AJ13 AJ15 AJ17 AJ19 AJ21 AJ23 AJ25 AK1 AK3 AK5 AK6 AK8 AK10 AK14 AK16 AK18 AK20 AK22 AK24 AK26 AL7 AL13 AL15 AL17 AL19 AL21 AL23 AL25 AM3 AM5 AM6 AM8 AM10 AM12 AM26 J8 J22 J25 K13 K30 L16 L17 L29 L31 M4 M27 M28 M30 N1 N3 N5 N6 N8 N26 N29 N31 P2 P4 P7 P8 P10 P23 P24 P26 P27 P28 P30 R6 R29 R31 T2 T4 T7 T8 T23 T24 T26 T27 T28 T30 U5 U23 U24 U26 U29 U31 V2 V4 V6 V27 V28 V30 W3 W5 W6 W7 W8 W23 W24 W29 W31 Y2 Y4 Y6 Y23 Y24 Y26 Y27 Y28 Y30; UV12 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV13 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV14 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV15 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UX1 4 5 6 7 10 11 12 13 15 25 26 28 30 31; YC1 2 4; YC3 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 6955 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 851 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 193 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 82 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 175.1
  TOP w0.254: v1(104.53,113.56) 104.53,110.6 107.63,107.5 v2(107.63,106.76) 107.63,102.93 107.41,102.71 106.74,102.71 CC90.1 106.33,103.12 RC9.2 105.5,103.11 UC2.4 ; v1(33.18,31.56) 32.98,31.56 32.73,31.31 PRM09.1 ; v1(53.91,58.99) 53.18,59.71 51.05,59.71 49.45,58.11 47.28,58.11 45.22,56.05 45.22,54.25 44.77,53.8 41.9,53.8 v1(41.81,53.7)
  IN2 w0.254: v1(33.18,31.56) 33.18,30.54 34.53,29.19 35.75,29.19 36.48,29.93 39.66,29.93 40.33,30.6 40.33,34.62 40.64,34.92 40.64,36 41.18,36.55 41.18,40.38 40.61,40.95 40.61,46.08 41.92,47.39 41.92,53.6 v1(41.81,53.7) ; v1(104.53,113.56) 103.2,114.89 99.54,114.89 98.94,115.49 92.07,115.49 91.46,116.1 84.06,116.1 82.81,117.34 77.85,117.34 77.26,116.76 75.28,116.76 74.18,115.65 72.27,115.65 72.06,115.44 68.07,115.44 66.48,113.85 65.42,113.85 64.76,113.2 60.96,113.2 59.61,111.84 58.57,111.84 57.78,111.06 56.02,111.06 53.77,108.81 53.77,105.18 53.18,104.59 53.18,103.34 52.53,102.69 52.53,93.06 53.48,92.12 53.48,90.04 52.92,89.48 52.92,88.8 54.73,86.99 54.73,75.89 54.25,75.41 54.25,70.62 55.18,69.69 55.18,61.04 53.72,59.58 53.72,59.18 v1(53.91,58.99)
1.0V_VCCST_EN: length 5.2
  TOP w0.089: CZ1.1 163.35,29.96 163.43,29.89 v3(163.84,29.89)
  TOP w0.254: UZ1.3 161.73,31.32 DZ5.2
  TOP w0.406: RZ1.2 161.01,29.96 DZ5.2
  TOP w0.508: CZ1.1 RZ1.2
1.2V_VTT_PWRGD: length 214.1
  TOP w0.089: v1(34.58,37.63) 35.32,38.36 39.39,38.36 40.12,37.63 43.17,37.63 45.54,40 45.75,40 45.96,40.2 45.96,41.91 46.92,42.87 46.92,44.14 47.64,44.86 v1(47.64,45.3) ; v1(146.19,38.34) 145.6,38.34 v2(145.58,38.31)
  TOP w0.203: 34.55,27.62 34.55,27.43 33.79,26.66 PRM06.2 ; 34.55,27.62 34.55,27.75 34.81,28.01 PUM01.10 ; 34.55,27.62 v1(34.55,27.62)
  IN1 w0.102: v1(146.19,38.34) 146.19,39.36 148.7,41.87 148.7,47.09 148.12,47.67 146.89,47.67 145.07,49.49 145.07,50.21 144.67,50.6 144.67,51.83 144.03,52.48 144.03,55.13 143.49,55.67 143.49,61.72 143.22,61.98 143.22,67.4 142.57,68.05 v1(142.57,68.11)
  IN2 w0.089: v1(47.64,45.3) 47.64,44.78 54,38.42 57.18,38.42 61.79,33.81 68.72,33.81 68.84,33.92 71.4,33.92 71.89,33.44 76.05,33.44 76.51,33.9 82.08,33.9 82.61,34.43 83.32,34.43 84.59,35.71 84.81,35.71 85.45,36.35 86.45,36.35 88.17,34.63 96.55,34.63 96.61,34.57 100.4,34.57 100.87,34.11 106.55,34.11 107.29,34.85 110.11,34.85 110.74,35.48 114.91,35.48 115.35,35.92 121.13,35.92 122.09,36.89 124.39,36.89 124.99,36.29 128.68,36.29 129.09,36.7 130.05,36.7 130.75,37.4 131.73,37.4 133.03,38.7 133.03,40.88 135.95,43.8 138.49,43.8 140.95,41.34 140.95,39.77 141.79,38.93 145.06,38.93 145.36,38.63 145.89,38.63 v1(146.19,38.34) ; v1(34.55,27.62) 32.55,29.62 32.55,30.98 31.51,32.02 31.51,34.94 33.08,36.51 33.46,36.51 v1(34.58,37.63)
  BOTTOM w0.102: RC106.1 149.3,92.62 149.54,92.39 149.54,90.62 148.57,89.65 148.57,83.09 148.93,82.73 148.93,80.53 149.01,80.45 149.01,78.25 147.93,77.17 147.93,71.79 146.81,70.68 144.55,70.68 143.93,70.05 143.93,69.05 142.98,68.11 v1(142.57,68.11)
2.5V_VIN: length 0.9
  TOP w0.089: v2(75.05,112.54) 74.56,112.54 74.3,112.8
3.3V_TS_EN: length 123.9
  TOP w0.089: RC213.1 118.75,51.75 v1(119.1,52.1) ; U3.4 214.09,32.85 214.09,30.48 214.08,30.47 v1(214.08,30.36) ; v1(169.45,28.13) 169.45,27.81 v2(170.28,26.98)
  IN1 w0.076: v1(119.1,52.1) 119.37,52.1 119.96,51.51 119.96,49.14 119.92,49.1 119.92,48.68
  IN1 w0.102: v1(124.18,38.74) 124.19,38.74 124.19,38.96 121.38,41.77 121.38,43.09 119.2,45.27 119.2,47.61 119.92,48.33 119.92,48.68
  IN2 w0.089: v1(214.08,30.36) 214.01,30.43 183.87,30.43 183.45,30.85 181.58,30.85 179.28,28.56 175.13,28.56 174.58,28.01 169.97,28.01 169.85,28.13 v1(169.45,28.13)
  BOTTOM w0.076: v1(119.1,52.1) 118.98,52.21 UC1.AP5
  BOTTOM w0.089: v1(124.18,38.74) 124.19,38.74 124.19,38.74 124.19,38.74 124.68,38.25 124.68,36.89 126.61,34.96 127.79,34.96 129.81,32.95 131.15,32.95 131.88,32.21 132.91,32.21 133.5,31.62 133.5,30.64 134.37,29.76 136.62,29.76 139.94,33.09 143.16,33.09 148.37,27.88 155.49,27.88 157.68,25.7 167.02,25.7 v1(169.45,28.13)
3V_FB: length 3.3
  BOTTOM w0.254: PC315.1 21.48,46.08 PR307.2 PR308.1 19.83,45.82 19.97,45.68 19.97,45.28 19.89,45.2 PU301.13
3V_SN: length 1.9
  TOP w0.089: PR305.2 v2(23.95,45.76)
3V_VIN: length 1.9
  TOP w0.089: v2(19.95,41.83) 18.98,41.83 18.91,41.77 PC303.1
  vias: v1(17.5,40.94) v1(18.16,40.95)
5V_FB: length 5.8
  BOTTOM w0.089: PC517.1 25.5,92.78 25.5,91.96 24.93,91.38 v2(24.74,91.38)
  BOTTOM w0.203: PU501.13 25.56,94.93 25.94,94.55 PR511.1 25.93,94.05 25.14,94.05 PR510.2 25.05,93.96 PC517.1
5V_SN: length 1.2
  TOP w0.089: PC509.1 19,100.82 v2(19,99.74)
5V_VIN: length 1
  TOP w0.089: v3(28.18,100.69) 28.62,100.25 v1(28.62,99.88)
  vias: v1(29.26,99.88)
+0.6V_DDR_VTT: length 11
  IN2 w0.762: 71.84,42.55 71.66,42.37 67.07,42.37 66.38,43.06 64.77,43.06 64.4,43.43 61.76,43.43 61.5,43.68
  vias: v1(39.37,35.66) v1(40.01,35.66) v1(60.51,42.98) v1(61.1,42.98) v1(69.3,33.14) v1(69.91,33.16) v1(70.52,33.16) v1(71.15,33.16) v1(72.53,42.82) v1(73.16,42.82) v3(70.56,37.82)
+0.6VSP: length 1.2
  TOP w0.127: 40.9,33.98 41.91,33.98 v2(42.07,33.82)
+0.95VSDGPU: length 24.3
  TOP w0.089: LV8.1 135.34,119.54 135.83,120.03
  TOP w0.102: v3(135.95,120.15) 135.83,120.03
  TOP w0.508: RV30.1 112.24,127.42 v1(111.55,126.73) ; LV8.1 133.82,117.84 132.44,116.47 128.46,116.47 127.75,115.76 126.6,115.76 125.74,116.62 125.74,117.99 125.07,118.66 123.9,118.66 123.35,118.11 122.65,118.11 122.21,118.55 119.3,118.55 v1(118.81,119.04)
  vias: v1(117.52,119.05) v1(118.15,119.05) v1(119.92,145.81) v1(120.87,145.81) v1(120.87,144.92)
+0.95VSDGPU_ON: length 6.1
  BOTTOM w0.089: CZ15.2 129.31,111.95 130.08,111.95 130.42,111.6 v2(131.92,111.6)
  BOTTOM w0.203: UZ5.3 128.8,111.5 RZ7.2
  BOTTOM w0.508: RZ7.2 128.81,111.59 128.81,111.6 CZ15.2
+0.95VSDGPU_OUT:
  vias: v2(122.97,114.02)
+1.0V_AMPHYPLL: length 19.3
  TOP w0.127: v2(132.14,46.19) 131.82,46.5 130.81,46.5 130.17,47.13 v1(130.17,47.18)
  TOP w0.508: RC169.2 131.81,48.28 131.24,48.85 CC74.1 130.17,48.34 v1(130.17,47.18) ; CC75.1 v1(129.92,57.68)
  IN1 w0.508: v1(129.92,57.68) 129.92,55.45 130.65,54.72 130.65,52.09 130.48,51.91 130.48,51.89 130.28,51.69 130.28,48.32 130.17,48.21 v1(130.17,47.18)
  BOTTOM w0.254: UC1.L15 UC1.K15
  BOTTOM w0.305: UC1.L15 130.23,58.12 129.92,57.81 v1(129.92,57.68)
+1.0V_APLL: length 0.5
  BOTTOM w0.254: v1(127.34,57.78) UC1.V15
  vias: v2(126.4,57.67)
+1.0V_APLLEBB: length 38.2
  TOP w0.508: CC63.1 CC101.1 144.4,43.67 RC162.2 144.59,43.98 143.09,45.48 v2(143.09,46.21) 143.09,46.96 v1(143.58,47.45)
  IN2 w0.254: v1(129.05,59.73) 129.21,59.73 129.64,59.3 129.64,58.22 129.45,58.03 129.45,57.19 130.08,56.56 130.08,55.62 131.12,54.57 131.12,52.84 132.34,51.62 133.13,51.62 133.45,51.94 135.11,51.94 135.73,51.31 137.64,51.31 138.71,52.38 140.46,52.38 141.12,53.05 142.53,53.05 143.77,51.8 146.18,51.8 146.87,51.11 146.87,50.53 145.94,49.6 145.73,49.6 v1(143.58,47.45)
  BOTTOM w0.305: UC1.N18 129.39,60.07 v1(129.05,59.73)
+1.0V_CLK2: length 14.6
  TOP w0.508: CC76.1 RC170.2 143.48,53.63 v2(142.03,55.08) 140.94,56.17 138.07,56.17 136.44,57.8 136.44,58.42 135.64,59.22 134.76,59.22
  BOTTOM w0.254: UC1.K19 131.4,60.43 v1(132.15,60.43)
+1.0V_CLK4: length 3.3
  TOP w0.089: v1(128.99,61.09) v2(129.52,61.09)
  TOP w0.254: v1(128.99,61.09) 128.59,60.68 RC173.2 128.08,61.71 CC84.1
  BOTTOM w0.254: v1(128.99,61.09) 129.03,61.13 129.19,61.13 UC1.N20
+1.0V_CLK5: length 29.3
  TOP w0.089: v1(143.64,78.6) v2(142.88,78.6)
  TOP w0.508: CC77.1 143.76,78.48 v1(143.64,78.6)
  IN2 w0.508: v1(143.64,78.6) 142.1,78.6 139.88,76.39 137.43,76.39 v1(137.16,76.11)
  IN3 w0.508: v1(137.16,76.11) 135.52,74.47 135.52,72.71 133.44,70.63 132.51,70.63 132.01,70.12 132.01,68.23 130.62,66.84 130.62,61.76 130.68,61.71 v1(130.7,61.72)
  BOTTOM w0.254: UC1.L19 130.7,61.15 v1(130.7,61.72)
  BOTTOM w0.508: v1(143.64,78.6) 142.88,77.84 RC76.2
+1.0V_MPHYGT:
  vias: v1(128.22,58.43) v1(129.05,59.11) v1(129.05,58.43) v2(144.23,49.72)
+1.0V_PRIM: length 266.7
  TOP w0.203: CE17.1 36,84.51 37.55,84.51 37.75,84.31 UE1.95
  TOP w0.508: 145.73,55.03 145.73,55.03 RC170.1 144.54,55.03 143.55,55.03 141.6,56.98 138.83,56.98 v1(138.67,57.15) ; v1(35.43,85.86) 34.84,85.86 CE17.1 ; CZ21.1 128.25,50.45 CC58.1 128.26,49.9 v1(128.17,49.81) 127.89,49.53 RC149.1 ; v1(130.69,59.01) 130.81,59.13 RC171.1
  TOP w1.27: 152.7,34.36 151.02,36.04 151.02,39.52 152.65,41.14 152.65,42.54 150.71,44.48 148.24,44.48 147.68,45.04 147.68,46.77 ; 151.37,54.14 152.38,55.15 155.56,55.15 156.22,55.81
  IN1 w0.508: v1(50.95,84.31) 50.95,84.04 50.49,83.59 48.81,83.59 48.29,84.11 37.78,84.11 36.03,85.86 v1(35.43,85.86) ; v1(128.17,49.81) 125.53,49.81 124.67,50.67 123.26,50.67 122.67,51.25 122.67,51.97 123.14,52.44 123.14,53.46 123.38,53.7 123.38,56.37
  IN1 w1.016: 147.4,100.08 146.39,100.08 139.3,107.17 134.51,107.17 132.41,109.28 131.5,109.28 129.07,111.72
  IN2 w0.508: v1(143.99,46.39) 143.99,46.98 147.03,50.02 v1(147.07,50.02) ; v1(50.95,84.31) 50.95,82.18 51.12,82 51.12,72.15 51.53,71.75 51.53,70.93 53.84,68.61 53.84,61.49 52.46,60.11 52.46,57.38 52.89,56.94 52.89,51.67 53.53,51.04 53.53,49.03 54.14,48.42 54.14,44.96 56.81,42.28 58.98,42.28 62.09,39.17 72.94,39.17 73,39.1 78.79,39.1 80.77,41.08 80.77,41.41 82.19,42.83 96.72,42.83 97.2,43.31 106.34,43.31 107.21,44.18 108.27,44.18 111.32,47.24 111.32,47.25 113.11,49.04 113.88,49.04 v1(114.54,48.38)
  IN3 w1.016: 156.45,57.67 156.45,62.16 154.49,64.12 154.49,69.63 156.45,71.59 156.45,77.12 154.48,79.09 154.48,89.3 155.38,90.2 155.38,91.34 154.61,92.11 154.61,98.67 153.49,99.79 151.94,99.79 151.58,100.16 149.74,100.16 149.67,100.24
  BOTTOM w0.203: v1(128.17,49.81) 128.2,49.81 128.41,50.01 128.41,50.3 UC1.T1 ; UC1.A14 136.25,57.77 136.86,57.77 137.48,57.15 v1(138.67,57.15) ; UC1.A10 136.68,55.32 v1(136.8,55.43)
  BOTTOM w0.254: UC1.AF19 123.61,60.72 v1(123.95,61.06) ; UC1.L21 130.27,62.18 v1(129.92,62.53) ; UC1.V20 126.86,61.43 126.86,61.96 UC1.V21 v1(127.34,62.27) ; UC1.AB20 125.52,61.65 125.57,61.69 v1(125.66,61.69) ; v1(130.89,49.81) 130.87,49.81 130.87,50.14 UC1.L1 ; UC1.K17 131.1,59.42 v1(130.69,59.01) ; UC1.P18 128.52,60.07 v1(128.22,59.77) ; v1(123.95,60.41) 123.61,60.07 UC1.AF18 ; UC1.AK20 121.12,61.37 121.47,61.72 v1(121.49,61.72) ; UC1.AB17 v1(125.66,59.74) UC1.Y18 125.72,60.42 v1(125.64,60.42) 125.35,60.72 UC1.AB19
  vias: v1(127.38,113.43) v1(127.46,112.75) v1(127.97,113.43) v1(128.04,112.75) v1(128.55,113.43) v1(138.96,57.69) v1(146.05,56.81) v1(146.05,56) v1(147.37,52.43) v1(147.37,51.79) v1(147.37,51.18) v1(147.37,50.55) v1(148.5,100.47) v1(148.47,99.86) v1(150.49,53.52) v1(150.49,52.89) v1(150.49,52.28) v1(150.49,51.64) v1(150.49,50.98) v1(150.49,50.35) v1(156.02,56.83) v1(156.78,56.83) v3(148.32,52.7)
