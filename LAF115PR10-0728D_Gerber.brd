# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D19: length 52.7
  IN1 w0.076: 107.53,92.33 107.53,92.29 108.82,91 109.1,91 109.53,90.57 110.4,90.57 v1(110.85,90.12)
  IN1 w0.119: 107.53,92.33 105.64,94.22 100.33,94.22 99.69,94.85 81.75,94.85 81.63,94.97 81.63,95.56 80.96,96.24 78.05,96.24 77.98,96.31 74.32,96.31 74.2,96.43 74.2,96.84 73.93,97.11 73.02,97.11 72.75,96.84 v1(72.75,95.48)
  BOTTOM w0.076: v1(110.85,90.12) 110.73,89.99 110.73,89.41 111.42,88.72 111.42,87.39 113.14,85.67 113.63,85.67 113.77,85.81 114.03,85.81 114.14,85.75 114.28,85.75 114.51,85.81 114.65,85.81 114.86,85.74 115.12,85.74 UC1.AY63
  BOTTOM w0.112: JDIMM1.58 72.07,95.74 72.33,95.48 v1(72.75,95.48)
DDR_A_D20: length 52.2
  IN1 w0.114: v1(112.16,91.58) 112.16,91.94 111.54,92.56 110.42,92.56
  IN1 w0.119: v1(74.32,98.15) 74.32,98.99 74.44,99.11 81.1,99.11 83.35,96.86 105.95,96.86 110.25,92.56 110.42,92.56
  BOTTOM w0.076: v1(112.16,91.58) 112.16,91.02 112.08,90.93 112.08,89.37 112.35,89.09 112.35,87.88 113.1,87.13 114.02,87.13 114.27,87.01 114.27,87.01 114.28,87.01 114.42,86.86 UC1.BA65
  BOTTOM w0.112: JDIMM1.50 72.23,97.74 72.39,97.58 73.76,97.58 v1(74.32,98.15)
DDR_A_D21: length 52.9
  IN1 w0.114: v1(112.71,91.34) 112.71,91.68 111.54,92.86 110.72,92.86
  IN1 w0.119: 110.72,92.86 110.68,92.9 110.39,92.9 106.09,97.2 83.49,97.2 81.24,99.45 74.1,99.45 v1(72.8,98.15)
  BOTTOM w0.076: v1(112.71,91.34) 112.24,90.87 112.24,89.43 112.54,89.13 112.54,88 113.24,87.3 114.06,87.3 114.22,87.22 114.3,87.18 114.33,87.18 114.47,87.13 114.75,87.13 115.01,86.86 UC1.AY65
  BOTTOM w0.112: JDIMM1.46 72.21,98.74 v1(72.8,98.15)
DDR_A_D22: length 52.6
  IN1 w0.114: 108.3,90.61 108.65,90.61 v1(109.04,90.21)
  IN1 w0.119: 108.3,90.61 105.36,93.55 96.64,93.55 96.01,94.18 81.08,94.18 80.96,94.3 80.96,95.29 80.68,95.56 80.02,95.56 79.9,95.45 79.9,94.3 79.78,94.18 79.54,94.18 79.42,94.3 79.42,95.45 79.3,95.56 78.99,95.56 78.87,95.45 78.87,94.3 78.75,94.18 78.51,94.18 78.39,94.3 78.39,95.45 78.27,95.56 78.03,95.56 77.92,95.45 77.92,94.3 77.8,94.18 77.56,94.18 77.44,94.3 77.44,94.55 77.32,94.67 77.12,94.67 77,94.79 77,95.36 77.12,95.48 v1(77.32,95.48)
  BOTTOM w0.076: v1(109.04,90.21) 110.2,89.05 110.38,89.05 111.09,88.35 111.09,87.22 113.04,85.27 114.09,85.27 114.36,85.54 UC1.BA63
  BOTTOM w0.112: v1(77.32,95.48) 77.33,95.49 JDIMM1.59
DDR_A_D23: length 51.6
  IN1 w0.114: v1(109.62,90.22) 109.03,90.81 108.73,90.81
  IN1 w0.119: v1(74.27,95.48) 74.77,95.97 77.84,95.97 77.91,95.9 80.82,95.9 81.3,95.42 81.3,94.64 81.42,94.52 96.69,94.52 96.91,94.3 96.91,94 97.03,93.88 97.27,93.88 97.39,94 97.39,94.3 97.51,94.42 97.75,94.42 97.87,94.3 97.87,94 97.98,93.88 98.22,93.88 98.34,94 98.34,94.3 98.46,94.42 98.7,94.42 98.82,94.3 98.82,94 98.94,93.88 99.18,93.88 99.3,94 99.3,94.3 99.42,94.42 99.66,94.42 99.78,94.3 99.78,94 99.89,93.88 105.5,93.88 108.16,91.23 108.57,90.81 108.73,90.81
  BOTTOM w0.076: v1(109.62,90.22) 111.26,88.59 111.26,87.32 113.11,85.46 113.84,85.46 UC1.BB63
  BOTTOM w0.112: JDIMM1.62 73.53,94.74 v1(74.27,95.48)
DDR_A_D24: length 50.5
  IN1 w0.114: 104.91,92.09 106.23,90.77 108.45,88.46 108.89,88.46 v1(109.27,88.09)
  IN1 w0.119: v1(75.79,92.57) 75.79,92.87 75.91,92.98 90.73,92.98 90.95,92.76 90.95,92.47 91.07,92.35 91.31,92.35 91.43,92.47 91.43,92.76 91.55,92.88 91.78,92.88 91.9,92.76 91.9,92.47 92.02,92.35 92.26,92.35 92.38,92.47 92.38,92.76 92.5,92.88 92.74,92.88 92.86,92.76 92.86,92.47 92.98,92.35 93.22,92.35 93.34,92.47 93.34,92.76 93.46,92.88 93.69,92.88 93.81,92.76 93.81,92.47 93.93,92.35 94.17,92.35 94.29,92.47 94.29,92.76 94.41,92.88 94.65,92.88 94.77,92.76 94.77,92.47 94.89,92.35 95.13,92.35 95.25,92.47 95.25,92.76 95.37,92.88 95.61,92.88 95.73,92.76 95.73,92.47 95.85,92.35 104.65,92.35 104.91,92.09
  BOTTOM w0.076: v1(109.27,88.09) 109.98,87.38 110.15,87.38 112.75,84.78 114.08,84.78 114.35,84.51 UC1.BA61
  BOTTOM w0.112: JDIMM1.67 76.71,93.49 v1(75.79,92.57)
DDR_A_D25: length 51.7
  IN1 w0.114: v1(110.47,88.09) 109.89,88.67 108.81,88.67 107.45,90.03
  IN1 w0.119: v1(72.74,92.57) 72.74,93.59 72.86,93.71 73.23,93.71 73.35,93.59 73.35,93.14 73.47,93.02 73.71,93.02 73.83,93.14 73.83,93.67 73.95,93.78 74.19,93.78 74.31,93.67 74.31,93.44 74.43,93.32 95.65,93.32 96.28,92.69 104.79,92.69 107.45,90.03
  BOTTOM w0.076: UC1.AW61 115.74,84.41 115.42,84.73 115.19,84.73 115.06,84.71 114.84,84.71 114.84,84.71 114.83,84.71 114.6,84.94 112.85,84.94 110.47,87.31 v1(110.47,88.09)
  BOTTOM w0.112: JDIMM1.70 72.16,92.74 72.33,92.57 v1(72.74,92.57)
DDR_A_D26: length 50.5
  IN1 w0.114: v1(107.51,86.16) 107.39,86.16 107.02,86.53 106.69,86.53 106.01,87.21 106.01,87.92 104.56,89.37
  IN1 w0.119: v1(75.79,89.27) 75.79,89.46 76.17,89.83 77.76,89.83 77.99,89.61 78.24,89.61 78.46,89.83 78.72,89.83 78.94,89.61 79.19,89.61 79.42,89.83 79.66,89.83 79.87,90.04 93.91,90.04 94.03,89.92 94.03,89.5 94.15,89.39 94.39,89.39 94.51,89.5 94.51,89.92 94.63,90.04 94.87,90.04 94.99,89.92 94.99,89.5 95.11,89.39 95.35,89.39 95.47,89.5 95.47,89.92 95.58,90.04 95.82,90.04 95.94,89.92 95.94,89.5 96.06,89.39 96.3,89.39 96.42,89.5 96.42,89.92 96.54,90.04 96.78,90.04 96.9,89.92 96.9,89.5 97.02,89.39 97.26,89.39 97.38,89.5 97.38,89.92 97.49,90.04 97.73,90.04 97.85,89.92 97.85,89.5 97.97,89.39 104.54,89.39 104.56,89.37
  BOTTOM w0.076: UC1.BB59 113.82,83.08 112.55,83.08 110.4,85.24 109.22,85.24 109.04,85.42 v2(108.53,85.42) 108.25,85.42 v1(107.51,86.16)
  BOTTOM w0.112: JDIMM1.79 77.01,90.49 v1(75.79,89.27)
DDR_A_D27: length 52.1
  IN1 w0.114: 104.67,89.72 106.21,88.19 106.21,87.9 107.57,86.54 108.43,86.54 v1(108.81,86.16)
  IN1 w0.119: 104.67,89.72 100.34,89.72 100.22,89.84 100.22,90.26 100.1,90.37 99.86,90.37 99.74,90.26 99.74,89.84 99.62,89.72 99.39,89.72 99.27,89.84 99.27,90.26 99.15,90.37 98.91,90.37 98.79,90.26 98.79,89.84 98.67,89.72 98.43,89.72 98.31,89.84 98.31,90.26 98.19,90.37 79.73,90.37 79.57,90.21 76.07,90.21 75.65,89.78 73.26,89.78 v1(72.75,89.27)
  BOTTOM w0.076: v1(108.81,86.16) 109.21,86.55 110.24,86.55 112.51,84.28 113.49,84.28 113.69,84.08 114.05,84.08 114.05,84.08 114.14,84.11 114.34,84.11 114.43,84.08 114.43,84.08 114.44,84.08 114.45,84.07 114.67,84.07 114.8,84.11 115.05,84.11 115.15,84.04 115.37,84.04 115.41,84.08 115.68,84.08 115.87,83.89 UC1.AW59
  BOTTOM w0.112: v1(72.75,89.27) 72.75,88.99 72.63,88.87 72.32,88.87 71.95,89.24 JDIMM1.84
DDR_A_D28: length 49.3
  IN1 w0.076: v1(108.59,88.09) 108.22,87.72 107.14,87.72 106.92,87.94 106.92,88.32
  IN1 w0.114: 104.77,91.43 106.92,89.27 106.92,88.32
  IN1 w0.119: 104.77,91.43 104.52,91.68 81.71,91.68 81.22,92.17 77.99,92.17 77.93,92.12 75.33,92.12 74.98,91.77 74.02,91.77 73.85,91.94 73.85,92.39 74.03,92.57 v1(74.27,92.57)
  BOTTOM w0.076: UC1.BB61 113.73,84.51 113.63,84.61 112.68,84.61 110.22,87.07 109.61,87.07 v2(109.13,87.55) v1(108.59,88.09)
  BOTTOM w0.112: JDIMM1.66 73.1,93.74 v1(74.27,92.57)
DDR_A_D29: length 51.6
  IN1 w0.114: 107.35,89.04 v1(107.35,88.07)
  IN1 w0.119: 107.35,89.04 107.35,89.18 104.51,92.02 90.46,92.02 90.34,92.14 90.34,92.43 90.22,92.55 89.98,92.55 89.86,92.43 89.86,92.14 89.74,92.02 89.5,92.02 89.38,92.14 89.38,92.43 89.26,92.55 89.02,92.55 88.9,92.43 88.9,92.14 88.78,92.02 88.55,92.02 88.43,92.14 88.43,92.43 88.31,92.55 88.07,92.55 87.95,92.43 87.95,92.14 87.83,92.02 87.59,92.02 87.47,92.14 87.47,92.43 87.35,92.55 87.11,92.55 86.99,92.43 86.99,92.14 86.87,92.02 86.64,92.02 86.52,92.14 86.52,92.43 86.4,92.55 86.16,92.55 86.04,92.43 86.04,92.14 85.92,92.02 85.68,92.02 85.56,92.14 85.56,92.43 85.44,92.55 85.2,92.55 85.08,92.43 85.08,92.14 84.96,92.02 84.72,92.02 84.6,92.14 84.6,92.53 84.48,92.65 84.24,92.65 84.12,92.53 84.12,92.14 84,92.02 83.76,92.02 83.64,92.14 83.64,92.53 83.52,92.65 83.28,92.65 83.17,92.53 83.17,92.14 83.05,92.02 82.81,92.02 82.69,92.14 82.69,92.53 82.57,92.65 82.33,92.65 82.21,92.53 82.21,92.14 82.09,92.02 81.84,92.02 81.29,92.57 v1(77.32,92.57)
  BOTTOM w0.076: v1(107.35,88.07) 108.6,86.82 110.24,86.82 112.62,84.45 113.56,84.45 113.76,84.24 114.02,84.24 114.11,84.28 114.13,84.28 114.37,84.28 114.46,84.24 114.67,84.24 114.75,84.27 114.75,84.27 114.85,84.31 115.12,84.31 UC1.AY61
  BOTTOM w0.112: JDIMM1.71 79.15,92.49 77.81,92.49 77.73,92.57 v1(77.32,92.57)
DDR_A_D30: length 51.5
  IN1 w0.114: 104.51,89.02 105.8,87.73 105.8,87.13 106.77,86.16 v1(106.86,86.16)
  IN1 w0.119: 104.51,89.02 104.48,89.05 93.54,89.05 93.42,89.17 93.42,89.58 93.3,89.7 93.06,89.7 92.94,89.58 92.94,89.17 92.82,89.05 92.58,89.05 92.46,89.17 92.46,89.58 92.34,89.7 92.1,89.7 91.98,89.58 91.98,89.17 91.86,89.05 91.62,89.05 91.5,89.17 91.5,89.58 91.38,89.7 91.14,89.7 91.03,89.58 91.03,89.17 90.91,89.05 90.66,89.05 90.54,89.17 90.54,89.58 90.42,89.7 90.18,89.7 90.06,89.58 90.06,89.17 89.94,89.05 89.7,89.05 89.59,89.17 89.59,89.58 89.47,89.7 89.23,89.7 89.11,89.58 89.11,89.17 88.99,89.05 88.75,89.05 88.63,89.17 88.63,89.58 88.51,89.7 88.27,89.7 88.15,89.58 88.15,89.17 88.03,89.05 87.79,89.05 87.68,89.17 87.68,89.58 87.56,89.7 87.32,89.7 87.2,89.58 87.2,89.17 87.08,89.05 86.84,89.05 86.72,89.17 86.72,89.58 86.6,89.7 86.36,89.7 86.24,89.58 86.24,89.17 86.12,89.05 85.88,89.05 85.77,89.17 85.77,89.58 85.65,89.7 81.57,89.7 81.46,89.58 81.46,89.46 81.34,89.34 81.1,89.34 80.98,89.46 80.98,89.58 80.86,89.7 80.01,89.7 79.58,89.27 v1(77.32,89.27)
  BOTTOM w0.076: UC1.BA59 114.16,82.98 114.02,82.92 112.47,82.92 110.34,85.04 107.97,85.04 v1(106.86,86.16)
  BOTTOM w0.112: JDIMM1.83 78.02,89.49 77.8,89.27 v1(77.32,89.27)
DDR_A_D31: length 52.6
  IN1 w0.114: v1(105.58,86.16) 105.6,86.18 105.6,87.48 105.17,87.91
  IN1 w0.119: v1(74.27,89.27) 74.27,88.97 74.39,88.86 81.4,88.86 81.54,88.71 81.79,88.71 81.91,88.83 81.91,89.25 82.03,89.37 82.27,89.37 82.39,89.25 82.39,88.83 82.51,88.71 82.74,88.71 82.86,88.83 82.86,89.25 82.98,89.37 83.22,89.37 83.34,89.25 83.34,88.83 83.46,88.71 83.7,88.71 83.82,88.83 83.82,89.25 83.94,89.37 84.18,89.37 84.3,89.25 84.3,88.83 84.42,88.71 84.66,88.71 84.78,88.83 84.78,89.25 84.9,89.37 85.14,89.37 85.26,89.25 85.26,88.83 85.38,88.71 104.37,88.71 105.17,87.91
  BOTTOM w0.076: UC1.AY59 115.01,83.18 114.75,82.92 114.55,82.92 114.12,82.78 114.05,82.75 112.39,82.75 110.29,84.85 106.88,84.85 v1(105.58,86.16)
  BOTTOM w0.112: v1(74.27,89.27) 73.69,89.85 72.68,89.85 72.29,90.24 JDIMM1.80
DDR_A_D32: length 51.9
  IN1 w0.114: 103.27,71.67 105.18,71.67 v1(105.36,71.49)
  IN1 w0.119: 103.27,71.67 102.99,71.67 102.86,71.54 98.29,71.54 92.2,65.45 82.44,65.45 82.32,65.33 82.32,65.01 82.2,64.89 81.96,64.89 81.84,65.01 81.84,65.33 81.72,65.45 80.32,65.45 80.2,65.33 80.2,65.01 80.09,64.89 79.85,64.89 79.73,65.01 79.73,65.33 79.61,65.45 79.37,65.45 79.25,65.33 79.25,65.01 79.13,64.89 78.89,64.89 78.77,65.01 78.77,65.33 78.65,65.45 78.41,65.45 78.29,65.33 78.29,65.01 78.18,64.89 77.94,64.89 77.82,65.01 77.82,65.33 77.7,65.45 74.34,65.45 74.22,65.33 v1(74.22,64.95)
  BOTTOM w0.076: v1(105.36,71.49) 106.6,72.73 111.63,72.73 111.99,72.36 112.64,72.36 112.77,72.49 113.58,72.49 113.66,72.57 114.06,72.57 114.19,72.51 114.21,72.51 114.47,72.41 114.75,72.41 115.01,72.14 UC1.AY39
  BOTTOM w0.102: JDIMM1.174 71.99,64.74 72.2,64.53 73.8,64.53 v1(74.22,64.95)
DDR_A_D33: length 49.3
  IN1 w0.114: v1(111.32,71.49) 110.94,71.88 103.3,71.88 103.3,71.88
  IN1 w0.119: 103.3,71.88 98.15,71.88 92.06,65.79 80.41,65.79 80.4,65.8 73.55,65.8 v1(72.69,64.95)
  BOTTOM w0.076: UC1.AW39 115.87,71.49 115.58,71.2 115.08,71.2 114.79,71.21 114.73,71.23 114.41,71.23 114.34,71.21 114.13,71.21 114.01,71.23 113.67,71.23 113.48,71.04 113,71.04 112.63,71.42 v2(111.84,71.42) 111.4,71.42 v1(111.32,71.49)
  BOTTOM w0.102: JDIMM1.170 71.9,65.74 v1(72.69,64.95)
DDR_A_D34: length 51.3
  IN1 w0.076: v1(110.67,71.49) 110.67,70.65 110.46,70.43 104.05,70.43 103.06,69.44 102.86,69.44
  IN1 w0.119: 102.86,69.44 98.93,69.44 92.4,62.91 84.52,62.91 84.4,62.79 84.4,62.53 84.28,62.41 84.04,62.41 83.92,62.53 83.92,62.79 83.8,62.91 83.56,62.91 83.44,62.79 83.44,62.53 83.32,62.41 83.08,62.41 82.96,62.53 82.96,62.79 82.84,62.91 82.61,62.91 82.49,62.79 82.49,62.53 82.37,62.41 82.13,62.41 82.01,62.53 82.01,62.79 81.89,62.91 81.65,62.91 81.53,62.79 81.53,62.53 81.41,62.41 81.17,62.41 81.05,62.53 81.05,62.79 80.93,62.91 79.83,62.91 79.2,62.28 75.75,62.28 75.64,62.16 v1(75.64,61.8)
  BOTTOM w0.076: v1(110.67,71.49) 111.04,71.12 112.66,71.12 112.9,70.88 113.55,70.88 113.74,71.07 113.99,71.07 114.19,71.03 114.31,71.03 114.47,71.07 114.71,71.07 114.86,71.01 115.12,71.01 UC1.AY37
  BOTTOM w0.112: v1(75.64,61.8) 76.05,61.38 77.6,61.38 77.71,61.49 JDIMM1.187
DDR_A_D35: length 52.5
  IN1 w0.076: 102.89,68.26 104.01,69.38 106.9,69.38 v1(107.42,69.91)
  IN1 w0.119: 102.89,68.26 99.18,68.26 92.17,61.26 79.6,61.26 79.39,61.05 76.37,61.05 75.58,60.26 74.88,60.26 74.76,60.38 74.76,60.61 74.64,60.73 74.4,60.73 74.28,60.61 74.28,60.38 74.16,60.26 73.81,60.26 73.69,60.38 73.69,60.69 73.57,60.81 73.33,60.81 73.22,60.69 73.22,60.38 73.1,60.26 72.71,60.26 72.59,60.38 v1(72.59,61.8)
  BOTTOM w0.076: UC1.AW37 115.65,70.91 115.34,70.6 114.8,70.6 114.57,70.38 113.55,70.38 113.55,70.38 112.7,70.38 112.45,70.63 108.87,70.63 108.75,70.51 v2(108.44,70.51) 108.02,70.51 v1(107.42,69.91)
  BOTTOM w0.112: JDIMM1.186 72.53,61.74 v1(72.59,61.8)
DDR_A_D36: length 49.6
  IN1 w0.076: v1(107.42,71.49) 107.42,71.02 107.35,70.95 103.72,70.95 103.63,71.03
  IN1 w0.119: 103.63,71.03 103.25,71.03 103,70.78 98.48,70.78 91.92,64.22 91.67,64.22 91.55,64.34 91.55,64.66 91.43,64.78 91.19,64.78 91.08,64.66 91.08,64.34 90.96,64.22 79.07,64.22 78.95,64.1 78.95,63.82 78.83,63.7 78.59,63.7 78.47,63.82 78.47,64.1 78.35,64.22 77.03,64.22 76.71,64.55 76.33,64.55 76.01,64.22 75.47,64.22 75.35,64.34 75.35,64.83 75.47,64.95 v1(75.74,64.95)
  BOTTOM w0.076: v1(107.42,71.49) 107.42,71.91 107.67,72.16 v2(108.66,72.16) 108.69,72.16 108.86,72.34 111.55,72.34 111.86,72.03 112.78,72.03 112.91,72.16 113.9,72.16 UC1.BB39
  BOTTOM w0.102: JDIMM1.169 76.51,65.99 75.74,65.22 v1(75.74,64.95)
DDR_A_D37: length 50.2
  IN1 w0.076: v1(106.77,71.49) 106.42,71.14 103.79,71.14 103.71,71.22 102.96,71.22 102.88,71.14 102.86,71.16
  IN1 w0.119: 102.86,71.16 98.38,71.16 92.34,65.12 90.54,65.12 90.42,65 90.42,64.68 90.3,64.56 90.06,64.56 89.94,64.68 89.94,65 89.82,65.12 89.58,65.12 89.46,65 89.46,64.68 89.35,64.56 89.11,64.56 88.99,64.68 88.99,65 88.87,65.12 88.63,65.12 88.51,65 88.51,64.68 88.39,64.56 88.15,64.56 88.03,64.68 88.03,65 87.91,65.12 87.67,65.12 87.55,65 87.55,64.68 87.43,64.56 87.19,64.56 87.07,64.68 87.07,65 86.95,65.12 86.71,65.12 86.59,65 86.59,64.68 86.47,64.56 86.23,64.56 86.11,64.68 86.11,65 86,65.12 85.76,65.12 85.64,65 85.64,64.68 85.52,64.56 85.28,64.56 85.16,64.68 85.16,65 85.04,65.12 84.8,65.12 84.68,65 84.68,64.68 84.56,64.56 84.32,64.56 84.2,64.68 84.2,65 84.08,65.12 83.85,65.12 83.73,65 83.73,64.68 83.61,64.56 83.37,64.56 83.25,64.68 83.25,65 83.13,65.12 82.89,65.12 82.77,65 82.77,64.68 82.65,64.56 77.38,64.56 77.26,64.68 v1(77.26,64.95)
  BOTTOM w0.076: UC1.BA39 114.42,72.14 114.28,72.28 114.27,72.28 114.27,72.29 114.02,72.41 113.73,72.41 113.65,72.33 112.84,72.33 112.71,72.2 111.92,72.2 111.59,72.53 107.81,72.53 v1(106.77,71.49)
  BOTTOM w0.102: JDIMM1.173 77.31,64.99 v1(77.26,64.95)
DDR_A_D38: length 51.4
  IN1 w0.076: v1(105.99,69.91) 105.99,69.62 105.92,69.54 103.79,69.54 103.1,68.85
  IN1 w0.119: 103.1,68.85 102.85,68.6 99.04,68.6 92.57,62.13 92.4,62.13 92.29,62.24 92.02,62.24 91.9,62.12 91.9,61.8 91.84,61.74 79.61,61.74 79.25,61.38 75.68,61.38 75.56,61.26 75.56,60.72 75.44,60.6 75.21,60.6 75.09,60.72 75.09,61.26 74.97,61.38 74.58,61.38 74.11,60.92 73.94,60.92 73.67,61.19 73.67,61.36 v1(74.11,61.8)
  BOTTOM w0.076: UC1.BA37 114.36,70.81 114.09,70.55 113.62,70.55 112.77,70.55 112.52,70.79 106.88,70.79 v1(105.99,69.91)
  BOTTOM w0.112: v1(74.11,61.8) 73.17,62.74 JDIMM1.182
DDR_A_D39: length 50.3
  IN1 w0.076: 102.86,68.97 104.16,70.27 105.21,70.27 105.28,70.19 v1(105.28,69.91)
  IN1 w0.119: v1(77.16,61.8) 79.19,61.8 79.47,62.07 84.76,62.07 84.88,62.19 84.88,62.45 85,62.57 85.24,62.57 85.36,62.45 85.36,62.19 85.48,62.07 85.72,62.07 85.84,62.19 85.84,62.45 85.95,62.57 86.19,62.57 86.31,62.45 86.31,62.19 86.43,62.07 86.67,62.07 86.79,62.19 86.79,62.45 86.91,62.57 87.15,62.57 87.27,62.45 87.27,62.19 87.39,62.07 87.63,62.07 87.75,62.19 87.75,62.45 87.86,62.57 88.1,62.57 88.22,62.45 88.22,62.19 88.34,62.07 88.58,62.07 88.7,62.19 88.7,62.45 88.82,62.57 89.06,62.57 89.18,62.45 89.18,62.19 89.3,62.07 89.54,62.07 89.66,62.19 89.66,62.45 89.78,62.57 90.01,62.57 90.13,62.45 90.13,62.19 90.25,62.07 90.49,62.07 90.61,62.19 90.61,62.45 90.73,62.57 90.98,62.57 91.1,62.45 91.1,62.19 91.22,62.07 91.45,62.07 91.57,62.19 91.57,62.45 91.69,62.57 92.54,62.57 98.93,68.97 102.86,68.97
  BOTTOM w0.076: v1(105.28,69.91) 105.09,69.91 104.7,70.3 104.7,70.9 104.89,71.09 v2(110.37,71.09) 110.69,71.09 110.82,70.96 112.59,70.96 112.83,70.71 113.62,70.71 113.72,70.81 UC1.BB37
  BOTTOM w0.112: v1(77.16,61.8) 77.85,62.49 JDIMM1.183
DDR_A_D40: length 52.5
  IN1 w0.076: 102.23,67.74 102.63,67.74 104.11,69.21 108.16,69.21 108.24,69.29 108.24,69.74 v1(108.07,69.91)
  IN1 w0.119: 102.23,67.74 100.03,67.74 93.04,60.75 92.69,60.75 92.68,60.73 82.71,60.73 82.59,60.61 82.59,60.13 82.47,60.01 82.23,60.01 82.12,60.13 82.12,60.61 82,60.73 81.76,60.73 81.64,60.61 81.64,60.13 81.52,60.01 81.28,60.01 81.16,60.13 81.16,60.61 81.04,60.73 79.82,60.73 79.49,60.4 79.49,60.13 79.37,60.01 79.13,60.01 79.01,60.13 79.01,60.4 78.89,60.52 78.65,60.52 78.54,60.4 78.54,60.13 78.42,60.01 78.18,60.01 78.06,60.13 78.06,60.4 77.94,60.52 76.58,60.52 v1(75.74,59.68)
  BOTTOM w0.076: v1(108.07,69.91) 108.07,69.75 108.46,69.36 v2(109.81,69.36) 109.92,69.26 111.74,69.26 112.2,69.72 113.25,69.72 113.45,69.52 114.02,69.52 114.11,69.55 114.13,69.55 114.37,69.55 114.46,69.52 114.67,69.52 114.75,69.55 114.75,69.55 114.85,69.59 115.12,69.59 UC1.AY35
  BOTTOM w0.112: v1(75.74,59.68) 76.19,59.22 77.6,59.22 77.86,59.49 JDIMM1.195
DDR_A_D41: length 52.9
  IN1 w0.076: 102.29,67.4 102.53,67.4 104.18,69.05 109.3,69.05 109.37,69.13 v1(109.37,69.91)
  IN1 w0.119: 102.29,67.4 100.17,67.4 93.16,60.39 87.94,60.39 87.82,60.28 87.82,59.79 87.7,59.68 87.46,59.68 87.35,59.79 87.35,60.28 87.23,60.39 86.99,60.39 86.87,60.28 86.87,59.79 86.75,59.68 86.51,59.68 86.39,59.79 86.39,60.28 86.27,60.39 86.03,60.39 85.91,60.28 85.91,59.79 85.79,59.68 85.55,59.68 85.43,59.79 85.43,60.28 85.32,60.39 85.08,60.39 84.96,60.28 84.96,59.79 84.84,59.68 84.6,59.68 84.48,59.79 84.48,60.28 84.36,60.39 84.12,60.39 84,60.28 84,59.79 83.88,59.68 83.64,59.68 83.52,59.79 83.52,60.28 83.41,60.39 83.17,60.39 83.05,60.28 83.05,59.79 82.93,59.68 v1(77.26,59.68)
  BOTTOM w0.076: v1(109.37,69.91) 109.19,70.09 109.19,70.33 109.32,70.46 112.38,70.46 112.63,70.22 113.48,70.22 113.49,70.22 114.6,70.22 114.81,70.01 115.33,70.01 115.65,69.69 UC1.AW35
  BOTTOM w0.112: v1(77.26,59.68) 77.26,60.09 77.67,60.49 JDIMM1.191
DDR_A_D42: length 52.6
  IN1 w0.114: v1(107.06,67.87) 107.06,67.61 106.95,67.5 104.67,67.5 103.62,66.45
  IN1 w0.119: 103.62,66.45 103.62,66.13 102.58,65.09 101.07,65.09 93.11,57.13 86.69,57.13 86.57,57.01 86.57,56.1 86.45,55.98 86.21,55.98 86.09,56.1 86.09,57.01 85.97,57.13 85.73,57.13 85.61,57.01 85.61,56.1 85.49,55.98 83.7,55.98 83.3,56.38 82.75,56.38 82.34,55.98 80.07,55.98 79.64,56.4 76.16,56.4 v1(75.74,56.82)
  BOTTOM w0.076: v1(107.06,67.87) 107.55,67.39 v2(109.48,67.39) 111.76,67.39 112.42,68.05 113.03,68.05 113.19,68.21 113.51,68.21 113.57,68.15 113.57,68.15 113.69,68.03 114.06,68.03 114.3,68.14 114.4,68.19 114.74,68.19 115.01,68.46 UC1.AY33
  BOTTOM w0.112: JDIMM1.207 77.91,56.49 77.6,56.18 76.38,56.18 v1(75.74,56.82)
DDR_A_D43: length 51.4
  IN1 w0.114: 103.25,66.46 104.66,67.87 v1(106.41,67.87)
  IN1 w0.119: v1(77.26,56.82) 79.75,56.82 80.12,56.45 82.34,56.45 83.36,57.47 83.6,57.47 83.72,57.35 83.72,56.43 83.84,56.31 84.08,56.31 84.2,56.43 84.2,57.35 84.32,57.47 84.56,57.47 84.68,57.35 84.68,56.43 84.8,56.31 85.04,56.31 85.16,56.43 85.16,57.35 85.28,57.47 92.97,57.47 100.93,65.42 102.44,65.42 103.25,66.23 103.25,66.46
  BOTTOM w0.076: v1(106.41,67.87) 107.59,69.06 v2(108.44,69.06) 111.77,69.06 112.27,69.56 113.18,69.56 113.38,69.35 114.05,69.35 114.05,69.35 114.14,69.39 114.34,69.39 114.43,69.35 114.43,69.35 114.44,69.35 114.45,69.35 114.67,69.35 114.8,69.39 115.05,69.39 115.15,69.32 115.66,69.32 115.87,69.11 UC1.AW33
  BOTTOM w0.112: v1(77.26,56.82) 77.94,57.49 JDIMM1.203
DDR_A_D44: length 50.8
  IN1 w0.076: v1(111.32,69.91) 111.56,69.67 111.56,68.87 111.41,68.72 104.37,68.72 102.65,67 102.65,66.99 102.54,66.88 102.53,66.88 102.38,66.73 102.23,66.73
  IN1 w0.114: 73.5,58.87 73.51,58.87
  IN1 w0.119: v1(72.69,59.68) 73.5,58.87 ; 73.51,58.87 73.53,58.85 89.62,58.85 89.74,58.97 89.74,59.6 89.85,59.72 90.09,59.72 90.21,59.6 90.21,58.97 90.33,58.85 90.57,58.85 90.69,58.97 90.69,59.6 90.81,59.72 93.44,59.72 100.44,66.73 102.23,66.73
  BOTTOM w0.076: UC1.BB35 113.82,69.89 v2(111.88,69.89) 111.34,69.89 v1(111.32,69.91)
  BOTTOM w0.112: v1(72.69,59.68) 72.28,59.68 72.22,59.74 JDIMM1.194
DDR_A_D45: length 51.6
  IN1 w0.076: 102.46,67.07 104.28,68.88 110.05,68.88 110.23,69.06 110.23,69.7 v1(110.02,69.91)
  IN1 w0.114: 74.67,59.22 75.96,59.22
  IN1 w0.119: 102.46,67.07 100.3,67.07 93.3,60.06 89.37,60.06 89.25,59.94 89.25,59.34 89.13,59.22 88.89,59.22 88.77,59.34 88.77,59.94 88.65,60.06 88.41,60.06 88.29,59.94 88.29,59.34 88.17,59.22 75.96,59.22 ; v1(74.22,59.68) 74.67,59.22
  BOTTOM w0.076: v1(110.02,69.91) 110.41,70.29 112.24,70.29 112.47,70.05 113.42,70.05 113.42,70.05 114.08,70.05 114.35,69.79 UC1.BA35
  BOTTOM w0.112: v1(74.22,59.68) 73.15,60.74 JDIMM1.190
DDR_A_D46: length 51.6
  IN1 w0.076: v1(110.96,67.87) 110.24,67.15 105.08,67.15 104.19,66.26 104.19,65.75 102.86,64.42
  IN1 w0.119: 102.86,64.42 102.75,64.3 101.23,64.3 93.39,56.46 88.55,56.46 88.43,56.34 88.43,55.43 88.31,55.31 88.01,55.31 87.89,55.43 87.89,55.67 87.77,55.79 87.53,55.79 87.41,55.67 87.41,55.43 87.29,55.31 79.79,55.31 79.37,55.73 73.78,55.73 v1(72.69,56.82)
  BOTTOM w0.076: v1(110.96,67.87) 111.79,67.87 v2(111.9,67.98) 112.15,68.23 112.98,68.23 113.12,68.37 113.58,68.37 113.76,68.19 114.02,68.19 114.27,68.31 114.27,68.32 114.28,68.32 114.42,68.46 UC1.BA33
  BOTTOM w0.112: JDIMM1.208 70.95,56.24 72.2,56.24 72.4,56.44 72.4,56.53 v1(72.69,56.82)
DDR_A_D47: length 51.2
  IN1 w0.076: v1(110.31,67.87) 109.75,67.32 105.02,67.32 104.03,66.33 104.03,66.06 102.86,64.89
  IN1 w0.119: 102.86,64.89 102.65,64.68 101.14,64.68 93.25,56.8 87.98,56.8 87.86,56.68 87.86,56.25 87.74,56.13 87.51,56.13 87.39,56.25 87.39,56.68 87.27,56.8 87.02,56.8 86.9,56.68 86.9,55.76 86.78,55.64 79.93,55.64 79.51,56.07 74.34,56.07 74.22,56.19 v1(74.22,56.82)
  BOTTOM w0.076: v1(110.31,67.87) 110.31,67.98 v2(110.62,68.29) 110.73,68.4 112.91,68.4 113.05,68.54 113.69,68.54 113.77,68.46 UC1.BB33
  BOTTOM w0.112: v1(74.22,56.82) 73.79,57.24 JDIMM1.204
DDR_A_D48: length 53.6
  IN1 w0.076: 102.86,63.11 102.9,63.11 105.49,65.7 v1(105.49,65.99)
  IN1 w0.114: 75.74,53.88 75.86,53.76 77.05,53.76
  IN1 w0.119: 102.86,63.11 102.85,63.1 101.72,63.1 93.89,55.26 93.06,55.26 92.94,55.14 92.94,54.42 92.82,54.3 92.58,54.3 92.46,54.42 92.46,55.14 92.34,55.26 91.97,55.26 91.86,55.14 91.86,53.98 91.74,53.86 91.41,53.86 91.29,53.98 91.29,54.47 91.17,54.59 90.94,54.59 90.82,54.47 90.82,53.98 90.7,53.86 77.51,53.86 77.41,53.76 77.05,53.76 ; v1(75.74,54.2) 75.74,53.88
  BOTTOM w0.076: UC1.AY31 115.01,67.16 114.75,67.43 114.47,67.43 114.05,67.59 113.69,67.59 113.52,67.42 112.64,67.42 112.32,67.1 106.6,67.1 v1(105.49,65.99)
  BOTTOM w0.112: v1(75.74,54.2) 75.74,54.61 76.62,55.49 JDIMM1.211
DDR_A_D49: length 53.1
  IN1 w0.076: v1(111.32,65.99) 110.76,66.56 104.73,66.56 104.36,66.19 104.36,65.29 102.86,63.79
  IN1 w0.119: v1(72.69,54.2) 73.7,55.21 79.15,55.21 79.83,54.53 88.83,54.53 88.95,54.65 88.95,55.82 89.07,55.93 93.61,55.93 101.45,63.78 102.85,63.78 102.86,63.79
  BOTTOM w0.076: v1(111.32,65.99) 111.43,66.1 v2(111.83,66.1) 112.04,66.1 112.16,65.97 113.24,65.97 113.53,66.27 114.06,66.27 114.09,66.25 114.17,66.22 114.29,66.22 114.51,66.28 114.65,66.28 114.8,66.23 115.07,66.23 115.09,66.25 115.65,66.25 115.87,66.47 UC1.AW31
  BOTTOM w0.112: v1(72.69,54.2) 72.28,54.2 72.24,54.24 JDIMM1.216
DDR_A_D50: length 52.5
  IN1 w0.076: v1(110.67,65.99) 110.67,65.3 110.13,64.75 105.6,64.75 105.36,64.51 105.36,64.19 103.36,62.19 103.36,61.75 102.86,61.24
  IN1 w0.119: v1(75.55,51.04) 75.97,51.45 78.17,51.45 78.93,52.21 79.18,52.21 79.3,52.09 79.3,51.86 79.42,51.74 79.66,51.74 79.77,51.86 79.77,52.09 79.89,52.21 80.13,52.21 80.25,52.09 80.25,51.86 80.37,51.74 80.61,51.74 80.73,51.86 80.73,52.09 80.85,52.21 93.11,52.21 102.02,61.13 102.74,61.13 102.86,61.24
  BOTTOM w0.076: v1(110.67,65.99) 111.07,65.6 111.54,65.6 111.74,65.81 113.31,65.81 113.6,66.1 114.03,66.1 114.14,66.04 114.28,66.04 114.51,66.11 114.65,66.11 114.86,66.03 115.12,66.03 UC1.AY29
  BOTTOM w0.112: JDIMM1.229 78.09,50.99 77.69,50.59 76,50.59 v1(75.55,51.04)
DDR_A_D51: length 52.9
  IN1 w0.076: 102.86,59.85 104.06,61.05 104.06,62.09 105.79,63.82 107.86,63.82 v1(108.44,64.39)
  IN1 w0.119: 102.86,59.85 102.17,59.85 93.52,51.21 89.77,51.21 89.29,50.73 78.87,50.73 78.43,50.29 72.62,50.29 72.5,50.41 v1(72.5,51.04)
  BOTTOM w0.076: v1(108.44,64.39) 108.44,64.6 v2(108.69,64.85) 108.95,65.11 111.76,65.11 111.96,65.31 113.53,65.31 113.63,65.4 114.57,65.4 114.81,65.64 115.57,65.64 UC1.AW29
  BOTTOM w0.112: JDIMM1.228 72.39,51.24 72.5,51.13 v1(72.5,51.04)
DDR_A_D52: length 51.2
  IN1 w0.076: 102.86,63.44 104.52,65.11 104.52,66.12 104.75,66.35 107.07,66.35 v1(107.42,65.99)
  IN1 w0.119: 102.86,63.44 101.59,63.44 93.75,55.6 91.44,55.6 91.32,55.48 91.32,55.04 91.2,54.92 90.97,54.92 90.85,55.04 90.85,55.48 90.73,55.6 90.48,55.6 90.36,55.48 90.36,54.31 90.24,54.19 90,54.19 89.88,54.31 89.88,55.48 89.76,55.6 89.53,55.6 89.41,55.48 89.41,54.31 89.29,54.19 79.69,54.19 79.01,54.87 78.76,54.87 78.64,54.75 78.64,54.31 78.52,54.19 78.29,54.19 78.17,54.31 78.17,54.75 78.05,54.87 77.38,54.87 77.26,54.75 v1(77.26,54.2)
  BOTTOM w0.076: v1(107.42,65.99) 107.98,66.56 v2(108.35,66.56) 108.57,66.77 112.46,66.77 112.77,67.09 113.85,67.09 UC1.BB31
  BOTTOM w0.112: JDIMM1.215 77.55,54.49 v1(77.26,54.2)
DDR_A_D53: length 52.2
  IN1 w0.076: 102.85,62.76 105.53,65.45 106.22,65.45 v1(106.77,65.99)
  IN1 w0.119: v1(74.22,54.2) 73.89,53.87 73.89,53.37 74.01,53.25 74.7,53.25 74.82,53.37 74.82,53.69 74.94,53.81 75.18,53.81 75.3,53.69 75.3,53.37 75.42,53.25 77.38,53.25 77.65,53.52 92.62,53.52 101.86,62.76 102.85,62.76
  BOTTOM w0.076: UC1.BA31 114.42,67.16 114.28,67.3 114.27,67.3 114.27,67.31 114.02,67.43 113.76,67.43 113.59,67.25 112.71,67.25 112.39,66.94 107.72,66.94 v1(106.77,65.99)
  BOTTOM w0.112: v1(74.22,54.2) 73.18,55.24 JDIMM1.212
DDR_A_D54: length 52.1
  IN1 w0.076: v1(107.07,64.39) 106.66,63.98 105.72,63.98 103.9,62.16 103.9,61.27 102.86,60.24
  IN1 w0.119: v1(74.03,51.04) 74.03,50.74 74.15,50.62 78.29,50.62 78.73,51.07 88.2,51.07 88.32,51.19 88.32,51.42 88.44,51.54 88.68,51.54 88.8,51.42 88.8,51.19 88.92,51.07 89.15,51.07 89.27,51.19 89.27,51.42 89.39,51.54 93.39,51.54 102.08,60.24 102.86,60.24
  BOTTOM w0.076: v1(107.07,64.39) 107.95,65.27 111.69,65.27 111.89,65.48 113.44,65.48 113.54,65.57 114.07,65.57 114.34,65.83 UC1.BA29
  BOTTOM w0.112: v1(74.03,51.04) 72.83,52.24 JDIMM1.224
DDR_A_D55: length 50.8
  IN1 w0.076: 102.86,60.62 103.64,61.4 103.64,62.23 105.72,64.31 v1(105.72,64.36)
  IN1 w0.119: 102.86,60.62 101.99,60.62 93.25,51.88 88,51.88 87.88,51.76 87.88,51.52 87.76,51.4 87.52,51.4 87.4,51.52 87.4,51.76 87.28,51.88 87.04,51.88 86.92,51.76 86.92,51.52 86.8,51.4 86.56,51.4 86.44,51.52 86.44,51.76 86.33,51.88 86.09,51.88 85.97,51.76 85.97,51.52 85.85,51.4 85.61,51.4 85.49,51.52 85.49,51.76 85.37,51.88 85.13,51.88 85.01,51.76 85.01,51.52 84.89,51.4 84.65,51.4 84.53,51.52 84.53,51.76 84.42,51.88 84.18,51.88 84.06,51.76 84.06,51.52 83.94,51.4 83.7,51.4 83.58,51.52 83.58,51.76 83.46,51.88 83.21,51.88 83.09,51.76 83.09,51.52 82.98,51.4 82.74,51.4 82.62,51.52 82.62,51.76 82.5,51.88 82.26,51.88 82.14,51.76 82.14,51.52 82.02,51.4 81.78,51.4 81.66,51.52 81.66,51.76 81.54,51.88 81.3,51.88 81.18,51.76 81.18,51.52 81.07,51.4 78.6,51.4 78.23,51.04 v1(77.08,51.04)
  BOTTOM w0.076: UC1.BB29 113.57,65.83 113.38,65.64 111.83,65.64 111.62,65.44 106.79,65.44 v1(105.72,64.36)
  BOTTOM w0.112: JDIMM1.225 78.03,51.99 v1(77.08,51.04)
DDR_A_D56: length 56.2
  IN1 w0.076: v1(110.39,64.39) 110.39,63.82 109.98,63.41 105.91,63.41 104.97,62.46 104.97,62.38
  IN1 w0.119: v1(77.26,48.86) 77.34,48.78 77.95,48.78 78.06,48.89 78.46,48.89 78.57,48.78 78.87,48.78 78.99,48.9 78.99,49.63 79.23,49.87 79.48,49.87 79.6,49.75 79.6,48.96 79.72,48.84 79.95,48.84 80.07,48.96 80.07,49.75 80.19,49.87 80.5,49.87 80.62,49.75 80.62,49.14 80.74,49.02 80.98,49.02 81.1,49.14 81.1,49.75 81.22,49.87 91.43,49.87 91.55,49.99 91.55,50.23 91.67,50.35 91.91,50.35 92.03,50.23 92.03,49.93 92.15,49.81 92.39,49.81 92.51,49.93 92.51,50.23 92.63,50.35 92.87,50.35 92.99,50.23 92.99,49.99 93.11,49.87 93.41,49.87 102.53,58.99 103.61,58.99 104.43,59.81 104.43,61.84 104.97,62.38
  BOTTOM w0.076: v1(110.39,64.39) 110.2,64.39 110.02,64.58 v2(110.02,64.78) 110.02,64.87 110.09,64.94 110.5,64.94 110.58,64.87 110.58,64.74 110.65,64.66 110.8,64.66 110.88,64.74 110.88,64.87 110.96,64.94 111.83,64.94 112.03,65.14 113.6,65.14 113.69,65.24 114.12,65.24 114.27,65.08 114.4,65.08 114.52,65.21 114.69,65.21 114.87,65.03 114.87,64.7 114.94,64.62 115.13,64.62 UC1.AY27
  BOTTOM w0.112: v1(77.26,48.86) 77.09,49.03 77.09,49.28 77.2,49.39 78.02,49.39 78.42,48.99 JDIMM1.237
DDR_A_D57: length 56.9
  IN1 w0.076: 103.76,59.85 104.23,60.32 104.23,61.95 105.87,63.6 109.01,63.6 109.09,63.68 v1(109.09,64.39)
  IN1 w0.119: 103.76,59.85 103.23,59.33 102.39,59.33 93.74,50.68 90.95,50.68 90.83,50.56 90.83,50.33 90.71,50.21 90.47,50.21 90.35,50.33 90.35,50.56 90.23,50.68 89.99,50.68 89.51,50.21 79.09,50.21 78.65,49.76 78.16,49.76 78.04,49.64 78.04,49.31 77.92,49.19 77.68,49.19 77.56,49.31 77.56,49.64 77.44,49.76 76.94,49.76 76.82,49.64 76.82,49.37 76.7,49.25 76.46,49.25 76.34,49.37 76.34,49.64 76.22,49.76 75.12,49.76 75,49.64 75,49.36 75.15,49.21 75.62,49.21 75.74,49.09 v1(75.74,48.86)
  BOTTOM w0.076: UC1.AW27 115.87,64.61 115.65,64.4 115.1,64.4 115.06,64.43 113.75,64.43 113.55,64.63 112.81,64.63 112.7,64.52 112.7,64.2 112.48,63.99 112.02,63.99 111.89,63.86 v2(111.27,63.86) 109.62,63.86 v1(109.09,64.39)
  BOTTOM w0.112: JDIMM1.233 76.87,49.99 v1(75.74,48.86)
DDR_A_D58: length 56.3
  IN1 w0.076: v1(108.44,62.36) 107.56,63.24 105.98,63.24 105.32,62.58 105.32,62.47 104.68,61.83 104.68,61.8
  IN1 w0.119: 104.68,61.8 104.64,61.76 104.64,60.69 104.76,60.57 105.52,60.57 105.63,60.45 105.63,60.22 105.52,60.1 104.76,60.1 104.64,59.98 104.64,59.74 104.76,59.62 105,59.62 105.12,59.5 105.12,59.26 105,59.14 104.76,59.14 104.64,59.02 104.64,58.96 104.27,58.59 102.6,58.59 93.48,49.47 81.91,49.47 80.98,48.54 80.12,48.54 80.01,48.44 74.63,48.44 v1(74.22,48.86)
  BOTTOM w0.076: UC1.AY25 114.97,63.48 114.7,63.21 114.4,63.21 114.09,63.06 113.56,63.06 113.55,63.07 112.55,63.07 112.32,62.85 112.32,62.85 112.12,62.64 v2(111.83,62.64) 111.36,62.64 110.73,62.02 108.79,62.02 v1(108.44,62.36)
  BOTTOM w0.112: v1(74.22,48.86) 73.79,48.43 72.54,48.43 71.73,49.24 JDIMM1.236
DDR_A_D59: length 56.5
  IN1 w0.076: v1(107.79,62.36) 107.43,62.72 105.7,62.72 105.48,62.51 105.48,61.5 105.84,61.14
  IN1 w0.119: v1(72.69,48.86) 72.43,48.6 72.43,48.17 72.55,48.05 80.11,48.05 80.27,48.21 81.12,48.21 82.05,49.14 93.62,49.14 102.69,58.21 104.36,58.21 105.84,59.69 105.84,61.14
  BOTTOM w0.076: UC1.AW25 115.69,63.48 115.4,63.19 114.92,63.19 114.64,62.91 114.64,62.68 114.54,62.58 114.17,62.58 114.13,62.62 113.22,62.62 112.96,62.36 111.31,62.36 110.8,61.85 108.54,61.85 108.5,61.9 v2(108.26,61.9) 108.25,61.9 v1(107.79,62.36)
  BOTTOM w0.112: JDIMM1.232 72.03,50.24 72.69,49.58 v1(72.69,48.86)
DDR_A_D60: length 53.9
  IN1 w0.114: 105.03,56.43 105.28,56.43 105.39,56.54 105.39,57.14 105.51,57.25 105.74,57.25 105.85,57.14 105.85,56.54 105.96,56.43 106.28,56.43 106.4,56.54 106.4,58.87 109.67,62.14 109.67,62.55 110.11,62.99 112.23,62.99 112.34,63.1 v1(112.34,64.39)
  IN1 w0.119: 105.03,56.43 103.18,56.43 94.29,47.53 82.72,47.53 80.94,45.76 75.86,45.76 75.74,45.88 v1(75.74,46.27)
  BOTTOM w0.076: UC1.BB27 112.75,64.8 v1(112.34,64.39)
  BOTTOM w0.112: v1(75.74,46.27) 76.46,46.99 JDIMM1.245
DDR_A_D61: length 55.1
  IN1 w0.114: 106.19,58.95 106.67,59.43 106.67,59.92 106.79,60.03 107.27,60.03 107.39,60.14 107.39,60.37 107.27,60.49 106.79,60.49 106.67,60.6 106.67,60.83 106.79,60.94 108.19,60.94 108.3,61.06 108.3,61.29 108.19,61.4 106.79,61.4 106.67,61.52 106.67,61.87 106.79,61.99 109.23,61.99 109.46,62.22 109.46,62.63 111.04,64.21 v1(111.04,64.39)
  IN1 w0.119: 106.19,58.95 106.19,58.23 104.78,56.81 103.09,56.81 94.15,47.87 82.58,47.87 80.81,46.1 80.08,46.1 79.96,46.22 79.96,46.47 79.84,46.59 79.6,46.59 79.48,46.47 79.48,46.22 79.37,46.1 79.13,46.1 79.01,46.22 79.01,46.47 78.89,46.59 78.65,46.59 78.53,46.47 78.53,46.22 78.41,46.1 77.43,46.1 v1(77.26,46.27)
  BOTTOM w0.076: v1(111.04,64.39) 111.4,64.76 111.89,64.76 112.11,64.98 113.67,64.98 113.76,65.07 114.05,65.07 114.32,64.8 UC1.BA27
  BOTTOM w0.112: v1(77.26,46.27) 77.54,45.99 79.15,45.99 JDIMM1.249
DDR_A_D62: length 55.1
  IN1 w0.114: 105.22,54.76 106.8,56.35 106.8,58.59 v1(110.61,62.39)
  IN1 w0.119: v1(72.69,46.27) 72.69,45.18 72.81,45.06 73.21,45.06 73.33,45.18 73.33,45.47 73.45,45.59 73.68,45.59 73.8,45.47 73.8,45.18 73.92,45.06 81.41,45.06 83.21,46.86 94.57,46.86 95.89,48.19 96.71,48.19 98.46,49.94 98.46,50.61 102.61,54.76 105.22,54.76
  BOTTOM w0.076: UC1.BA25 114.42,63.48 114.27,63.33 114.05,63.22 113.63,63.22 113.61,63.24 112.48,63.24 112.25,63.01 112.21,62.96 111.18,62.96 v1(110.61,62.39)
  BOTTOM w0.112: JDIMM1.246 71.92,46.74 72.39,46.27 v1(72.69,46.27)
DDR_A_D63: length 53.8
  IN1 w0.114: 105.24,55.1 106.6,56.46 106.6,58.78 110.04,62.22 v1(110.04,62.39)
  IN1 w0.119: 105.24,55.1 102.32,55.1 94.52,47.3 94.43,47.2 83.08,47.2 81.27,45.39 75.48,45.39 75.36,45.51 75.36,45.66 75.24,45.78 75,45.78 74.88,45.66 74.88,45.51 74.76,45.39 74.34,45.39 74.22,45.51 v1(74.22,46.27)
  BOTTOM w0.076: v1(110.04,62.39) 110.04,62.65 v2(110.28,62.89) 110.57,63.18 112.18,63.18 112.41,63.41 113.65,63.41 113.73,63.48 UC1.BB25
  BOTTOM w0.112: v1(74.22,46.27) 73.46,45.51 72.24,45.51 72.01,45.74 JDIMM1.250
DDR_A_DQS0: length 67.7
  IN1 w0.076: v1(120.05,96.65) 120.05,96.76 119.94,96.88 119.56,96.88 119.32,97.11 119.32,98.32 119.32,99.46 119.28,99.5 119.28,99.6
  IN1 w0.114: 76.06,107.23 v1(76.19,107.23) ; 75.84,107.43 75.84,107.4
  IN1 w0.124: 75.84,107.43 75.7,107.57 75.7,107.74 75.94,107.98 77.07,107.98 77.52,107.53 78.9,107.53 79.03,107.41 79.03,107.23 79.28,106.98 79.84,106.98 80.09,107.23 80.09,107.41 80.21,107.53 81.07,107.53 81.94,106.67 82.73,106.67 83.13,106.26 83.48,106.26 83.7,106.49 83.88,106.49 84.15,106.22 84.15,106.04 83.93,105.82 83.93,105.46 84.65,104.74 115.45,104.74 117.45,102.74 117.45,102.18 117.9,101.72 118.42,101.72 119.28,100.87 119.28,99.6 ; 76.06,107.23 75.99,107.23 75.84,107.39 75.84,107.4
  BOTTOM w0.076: UC1.AM69 120.18,89.31 120.49,89.64 120.49,90.1 120.53,90.19 120.53,90.4 120.47,90.52 120.47,90.78 120.55,90.86 120.55,91.64 120.01,92.18 120.01,92.68 119.53,93.17 119.53,96.71 119.69,96.87 119.91,96.87 120.05,96.73 v1(120.05,96.65)
  BOTTOM w0.109: JDIMM1.13 78.46,106.99 78.29,107.16 77.72,107.16 76.97,107.9 76.03,107.9 75.82,107.69 75.82,107.41 76,107.23 v1(76.19,107.23)
DDR_A_DQS1: length 58.2
  IN1 w0.076: 113.09,94.98 113.11,94.98 113.15,95.02 114.9,95.02 115.81,94.11 115.81,93.94 115.72,93.85 v1(115.3,93.85)
  IN1 w0.124: 113.09,94.98 113.07,95 111.94,95 111.54,95.4 110.96,95.4 106.38,99.97 100.85,99.97 100.72,99.85 100.72,99.51 100.47,99.26 99.91,99.26 99.66,99.51 99.66,99.85 99.54,99.97 83.94,99.97 81.68,102.23 80.95,102.23 80.67,102.51 74.48,102.51 74.33,102.36 74.33,102.18 74.49,102.02 v1(74.6,102.02)
  BOTTOM w0.076: UC1.AT70 117.72,89.44 117.72,89.41 117.66,89.35 117.58,89.35 117.52,89.41 117.46,89.54 117.46,89.75 117.49,89.83 117.49,90.11 117.44,90.24 117.44,90.35 117.49,90.48 117.49,90.75 117.49,90.97 117.32,91.14 117.32,91.72 116.79,92.26 116.79,93.4 116.23,93.96 115.75,93.96 115.63,93.85 v1(115.3,93.85)
  BOTTOM w0.109: v1(74.6,102.02) 74.31,101.73 74.31,101.58 74.08,101.35 72.73,101.35 72.19,101.89 71.9,101.89 71.74,101.74 JDIMM1.34
DDR_A_DQS2: length 52.8
  IN1 w0.076: v1(110.46,91.67) 110.38,91.67 110.05,91.33 110.05,91.17 109.87,91 109.47,91 109.29,91.18 108.94,91.18 108.18,91.94 108.18,92.36 108.05,92.49 108.05,92.49
  IN1 w0.124: v1(76.18,96.75) 75.88,97.04 75.88,97.27 76.01,97.4 76.66,97.4 76.86,97.2 78.79,97.2 79.22,97.64 79.81,97.64 80.31,97.14 80.91,97.14 82.63,95.41 99.9,95.41 100.57,94.75 105.94,94.75 108.05,92.76 108.05,92.49
  BOTTOM w0.076: UC1.AY64 115.33,86.3 115,86.63 114.75,86.63 114.67,86.6 114.46,86.6 114.35,86.65 114.14,86.65 114.02,86.6 113.78,86.6 113.59,86.78 112.92,86.78 111.99,87.71 111.99,88.91 111.71,89.2 111.71,90.2 111.06,90.85 110.68,90.85 110.22,91.31 110.22,91.56 110.33,91.67 v1(110.46,91.67)
  BOTTOM w0.109: JDIMM1.55 78.38,96.49 78.24,96.63 77.83,96.63 77.09,97.37 76.07,97.37 75.84,97.14 75.84,96.86 75.95,96.75 v1(76.18,96.75)
DDR_A_DQS3: length 51.3
  IN1 w0.076: v1(110.11,86.16) 109.96,86.16 109.73,86.39 109.73,86.58 108.81,87.5 107.11,87.5 106.68,87.93 106.68,88.64 106.03,89.29 106.03,89.3 105.98,89.35 105.97,89.35 105.92,89.4 105.87,89.4 105.85,89.42
  IN1 w0.114: 105.85,89.42 105.85,89.43 104.78,90.5 104.78,90.62 104.76,90.65 ; 104.72,90.68 104.72,90.69 104.72,90.69 104.73,90.69 104.72,90.7
  IN1 w0.124: 104.72,90.68 104.76,90.65 ; v1(74.57,91.28) 74.24,90.95 74.24,90.72 74.42,90.54 75.33,90.54 75.91,91.12 104.3,91.12 104.72,90.7
  BOTTOM w0.076: UC1.BA60 114.94,83.8 114.94,83.68 114.87,83.6 114.36,83.6 114.34,83.58 114.32,83.57 114.31,83.56 114.17,83.56 114.06,83.62 114.05,83.62 113.69,83.62 113.53,83.46 112.82,83.46 110.57,85.71 109.68,85.71 109.64,85.75 109.64,85.83 109.97,86.16 110.08,86.16 110.08,86.16 v1(110.11,86.16)
  BOTTOM w0.109: v1(74.57,91.28) 74.28,90.98 74.28,90.73 74.07,90.52 72.89,90.52 72.06,91.35 71.82,91.35 71.71,91.24 JDIMM1.76
DDR_A_DQS4: length 50.9
  IN1 w0.076: 102.86,70.18 102.95,70.18 103,70.13 103.11,70.13 103.76,70.78 109.09,70.78 109.21,70.89 109.21,71.16 108.87,71.49 v1(108.72,71.49)
  IN1 w0.124: 102.86,70.18 98.63,70.18 92.09,63.65 79.52,63.65 78.9,63.02 78.46,63.02 78.11,63.37 77.52,63.37 77.18,63.02 75.72,63.02 75.63,63.12 75.63,63.47 75.75,63.59 v1(75.98,63.59)
  BOTTOM w0.076: v1(108.72,71.49) 108.92,71.49 109.04,71.62 109.04,71.95 109.21,72.12 111.54,72.12 111.79,71.87 112.9,71.87 113.03,72 113.49,72 113.61,71.87 114.02,71.87 114.14,71.93 114.35,71.93 114.46,71.87 114.67,71.87 114.75,71.91 115.03,71.91 115.14,71.87 115.28,71.78 UC1.AY38
  BOTTOM w0.102: 75.74,63.65 75.69,63.7 75.69,64.01 75.86,64.17 77.08,64.17 77.6,63.65 78.23,63.65
  BOTTOM w0.109: v1(75.98,63.59) 75.8,63.59 75.74,63.65 ; JDIMM1.179 78.4,63.49 78.23,63.65
DDR_A_DQS5: length 52.4
  IN1 w0.076: v1(108.36,67.87) 108.47,67.87 108.57,67.97 108.57,68.17 108.45,68.29 104.63,68.29 104.56,68.29 102.97,66.69 102.97,66.68
  IN1 w0.114: 73.96,58.34 v1(73.84,58.34)
  IN1 w0.124: 73.96,58.34 74.17,58.14 74.17,57.74 74.54,57.38 80.45,57.38 81.07,57.99 92.75,57.99 100.75,65.99 102.53,65.99 102.97,66.42 102.97,66.68
  BOTTOM w0.076: v1(108.36,67.87) 108.48,67.99 108.48,68.4 108.84,68.76 112.74,68.76 112.88,68.89 114.06,68.89 114.17,68.84 114.19,68.84 114.3,68.84 114.43,68.89 114.7,68.89 114.78,68.86 115,68.86 115.06,68.88 115.15,68.93 115.16,68.98 115.16,69.06 115.1,69.12 UC1.BA34
  BOTTOM w0.109: v1(73.84,58.34) 73.87,58.34 74.1,58.57 74.1,58.7 73.95,58.84 72.75,58.84 72.75,58.84 72.66,58.84 72.19,58.37 71.81,58.37 71.68,58.24 JDIMM1.200
DDR_A_DQS6: length 52.5
  IN1 w0.076: v1(108.72,65.99) 109.21,65.51 109.21,65.32 109.08,65.19 105.54,65.19 102.88,62.53 102.88,62.51 102.83,62.46 102.83,62.46 102.74,62.37
  IN1 w0.124: 102.74,62.37 102.34,61.98 101.82,61.98 92.8,52.96 78.62,52.96 77.86,52.2 75.87,52.2 75.75,52.32 75.75,52.63 75.87,52.75 v1(76.12,52.75)
  BOTTOM w0.076: UC1.AY30 115.34,66.8 115.06,66.93 114.75,66.93 114.67,66.89 114.46,66.89 114.35,66.95 114.14,66.95 114.02,66.89 113.41,66.89 113.38,66.92 112.84,66.92 112.53,66.61 109.24,66.61 109.06,66.43 109.06,66.16 108.89,65.99 v1(108.72,65.99)
  BOTTOM w0.109: JDIMM1.221 78.49,52.99 78.34,53.14 77.83,53.14 77.64,53.33 75.81,53.33 75.74,53.26 75.74,52.91 75.89,52.75 v1(76.12,52.75)
DDR_A_DQS7: length 56.3
  IN1 w0.076: 104.64,57.76 104.65,57.77 104.72,57.77 105.67,58.71 105.67,58.92 106.32,59.58 106.32,61.98 105.94,62.36 v1(105.84,62.36)
  IN1 w0.124: 104.64,57.76 104.52,57.64 102.87,57.64 93.84,48.61 82.27,48.61 80.99,47.33 78.07,47.33 77.69,46.94 74.56,46.94 74.38,47.13 74.38,47.3 v1(74.6,47.52)
  BOTTOM w0.076: v1(105.84,62.36) 105.91,62.36 105.99,62.44 105.99,62.98 106.51,63.51 108.25,63.51 108.3,63.56 108.8,63.56 108.85,63.51 112.05,63.51 112.28,63.74 113.48,63.74 113.66,63.91 114.05,63.91 114.19,63.86 114.3,63.86 114.43,63.91 114.7,63.91 114.78,63.87 115,63.87 115.06,63.9 115.15,63.95 115.16,64 115.16,64.08 115.1,64.14 UC1.BA26
  BOTTOM w0.109: v1(74.6,47.52) 74.44,47.52 74.25,47.34 74.25,47.08 74.03,46.86 72.84,46.86 72.59,47.11 72.52,47.31 71.93,47.89 71.8,47.89 71.65,47.74 JDIMM1.242
DDR_A_DQS#0: length 67.7
  IN1 w0.076: 119.53,99.6 119.53,99.5 119.48,99.46 119.48,97.18 119.62,97.04 119.87,97.04 v1(120.05,97.23)
  IN1 w0.114: 75.49,107.29 v1(75.43,107.23)
  IN1 w0.124: 119.53,99.6 119.49,99.64 119.49,100.24 119.49,100.24 119.49,100.96 118.51,101.94 117.99,101.94 117.66,102.27 117.66,102.82 115.54,104.95 84.74,104.95 84.14,105.55 84.14,105.73 84.36,105.95 84.36,106.31 83.97,106.7 83.61,106.7 83.39,106.48 83.21,106.48 82.81,106.88 82.02,106.88 81.16,107.75 80.12,107.75 79.87,107.5 79.87,107.32 79.75,107.2 79.37,107.2 79.24,107.32 79.24,107.5 78.99,107.75 77.61,107.75 77.16,108.2 75.85,108.2 75.49,107.83 75.49,107.29
  BOTTOM w0.076: v1(120.05,97.23) 119.86,97.04 119.62,97.04 119.36,96.78 119.36,93.1 119.84,92.61 119.84,92.11 120.39,91.57 120.39,90.93 120.31,90.84 120.31,90.48 120.36,90.35 120.36,90.24 120.31,90.11 120.31,89.69 120.19,89.57 120.13,89.57 120.08,89.63 UC1.AM70
  BOTTOM w0.109: JDIMM1.11 78.44,107.49 78.31,107.36 77.8,107.36 77.06,108.1 75.9,108.1 75.58,107.79 75.58,107.39 v1(75.43,107.23)
DDR_A_DQS#1: length 58.1
  IN1 w0.076: 113.08,95.22 113.09,95.23 113.11,95.23 113.15,95.19 114.96,95.19 115.97,94.18 115.97,93.87 115.72,93.62 v1(115.72,93.43)
  IN1 w0.124: v1(73.84,102.02) 73.98,102.02 74.12,102.16 74.12,102.45 74.4,102.73 80.76,102.73 81.03,102.45 81.77,102.45 84.03,100.19 99.63,100.19 99.88,99.94 99.88,99.59 100,99.47 100.38,99.47 100.51,99.59 100.51,99.94 100.76,100.19 106.47,100.19 111.04,95.61 111.63,95.61 112.03,95.22 113.08,95.22
  BOTTOM w0.076: v1(115.72,93.43) 115.72,93.7 115.81,93.8 116.16,93.8 116.63,93.33 116.63,92.19 117.16,91.66 117.16,91.07 117.33,90.9 117.33,90.52 117.27,90.4 117.27,90.19 117.33,90.08 117.33,89.87 117.29,89.79 117.29,89.5 117.38,89.31 117.51,89.18 117.51,89.18 117.54,89.15 117.56,89.15 UC1.AT69
  BOTTOM w0.109: JDIMM1.32 71.72,102.24 71.87,102.09 72.27,102.09 72.81,101.55 73.96,101.55 74.07,101.67 74.07,101.78 v1(73.84,102.02)
DDR_A_DQS#2: length 52.7
  IN1 w0.076: v1(109.88,91.67) 109.88,91.24 109.8,91.16 109.54,91.16 109.36,91.35 109.01,91.35 108.34,92.01 108.34,92.49
  IN1 w0.124: 108.34,92.49 108.26,92.57 108.26,92.85 106.02,94.96 100.66,94.96 99.99,95.63 82.72,95.63 81,97.35 80.4,97.35 79.9,97.85 79.13,97.85 78.7,97.42 76.95,97.42 76.75,97.62 75.92,97.62 75.67,97.36 75.67,97 v1(75.41,96.75)
  BOTTOM w0.076: v1(109.88,91.67) 110.05,91.49 110.05,91.24 110.61,90.68 110.99,90.68 111.52,90.16 111.52,89.15 111.83,88.84 111.83,87.64 112.85,86.62 113.53,86.62 113.71,86.43 113.94,86.43 114.06,86.43 114.17,86.49 114.19,86.49 114.3,86.49 114.43,86.43 114.7,86.43 114.78,86.47 114.93,86.47 115.07,86.33 115.07,86.27 115,86.2 UC1.BA64
  BOTTOM w0.109: JDIMM1.53 78.36,96.99 78.2,96.83 77.92,96.83 77.17,97.57 75.99,97.57 75.6,97.19 75.6,96.94 v1(75.41,96.75)
DDR_A_DQS#3: length 51.3
  IN1 w0.076: 105.85,89.21 105.88,89.21 106.52,88.57 106.52,87.86 107.04,87.33 108.74,87.33 109.56,86.51 109.56,86.26 v1(109.46,86.16)
  IN1 w0.114: 105.85,89.21 105.78,89.21 104.58,90.41 104.58,90.54 104.57,90.55
  IN1 w0.124: 104.57,90.55 104.21,90.9 76,90.9 75.42,90.33 74.33,90.33 74.02,90.64 74.02,91.07 v1(73.81,91.28)
  BOTTOM w0.076: v1(109.46,86.16) 109.46,85.7 109.61,85.55 110.5,85.55 112.75,83.29 113.6,83.29 113.76,83.45 114.02,83.45 114.02,83.45 114.14,83.4 114.26,83.4 114.3,83.38 114.33,83.4 114.38,83.4 114.41,83.43 114.43,83.44 114.94,83.44 115.25,83.75 UC1.AY60
  BOTTOM w0.109: v1(73.81,91.28) 74.08,91.02 74.08,90.81 73.99,90.72 72.97,90.72 72.14,91.55 71.87,91.55 71.68,91.74 JDIMM1.74
DDR_A_DQS#4: length 51
  IN1 w0.076: 102.86,69.97 103.18,69.97 103.83,70.62 109.16,70.62 109.37,70.83 v1(109.37,71.49)
  IN1 w0.124: 102.86,69.97 98.71,69.97 92.18,63.44 79.61,63.44 78.99,62.81 78.37,62.81 78.02,63.16 77.61,63.16 77.26,62.81 75.63,62.81 75.42,63.03 75.42,63.39 v1(75.22,63.59)
  BOTTOM w0.076: UC1.BA38 115.07,71.39 115.18,71.39 115.25,71.43 115.25,71.51 115.25,71.51 115.25,71.58 115.22,71.61 115.15,71.67 115.06,71.72 115,71.74 114.78,71.74 114.7,71.71 114.43,71.71 114.3,71.76 114.19,71.76 114.05,71.71 113.54,71.71 113.42,71.83 113.09,71.83 112.96,71.7 111.72,71.7 111.47,71.95 109.28,71.95 109.2,71.88 109.2,71.66 v1(109.37,71.49)
  BOTTOM w0.102: JDIMM1.177 78.29,63.99 78.15,63.85 77.68,63.85 77.16,64.36 75.78,64.36 75.5,64.09 75.5,63.88 75.28,63.65
  BOTTOM w0.109: 75.28,63.65 v1(75.22,63.59)
DDR_A_DQS#5: length 52.5
  IN1 w0.076: 102.75,66.71 102.75,66.77 102.88,66.89 102.93,66.89 104.49,68.45 104.63,68.45 104.63,68.45 104.7,68.45 104.7,68.45 108.52,68.45 108.74,68.24 108.74,67.99 108.85,67.87 v1(109.01,67.87)
  IN1 w0.114: v1(74.6,58.34) 74.42,58.17
  IN1 w0.124: 74.42,58.17 74.42,57.82 74.65,57.59 80.36,57.59 80.98,58.21 92.67,58.21 100.66,66.2 102.44,66.2 102.75,66.51 102.75,66.71
  BOTTOM w0.076: v1(109.01,67.87) 108.94,67.87 108.64,68.17 108.64,68.33 108.91,68.6 112.81,68.6 112.94,68.73 114.02,68.73 114.14,68.67 114.35,68.67 114.46,68.73 114.67,68.73 114.75,68.69 115.03,68.69 115.14,68.73 115.28,68.82 115.33,68.94 115.41,69.02 UC1.AY34
  BOTTOM w0.109: JDIMM1.198 71.72,58.74 71.89,58.57 72.11,58.57 72.58,59.04 74.03,59.04 74.3,58.78 74.3,58.58 74.53,58.34 v1(74.6,58.34)
DDR_A_DQS#6: length 52.4
  IN1 w0.076: v1(109.37,65.99) 109.37,65.25 109.15,65.03 105.61,65.03 103.04,62.45 103.04,62.44 102.93,62.33 102.93,62.3 102.9,62.26 102.9,62.23 102.89,62.22
  IN1 w0.124: v1(75.36,52.75) 75.5,52.61 75.5,52.23 75.75,51.98 77.95,51.98 78.71,52.74 92.89,52.74 101.91,61.76 102.43,61.76 102.89,62.22
  BOTTOM w0.076: UC1.BA30 115.07,66.45 115.11,66.45 115.18,66.53 115.18,66.66 115,66.76 114.78,66.76 114.7,66.73 114.43,66.73 114.3,66.78 114.17,66.78 114.06,66.73 113.34,66.73 113.31,66.76 112.91,66.76 112.6,66.45 109.31,66.45 109.22,66.36 109.22,66.15 v1(109.37,65.99)
  BOTTOM w0.109: JDIMM1.219 78.42,53.49 78.27,53.34 77.91,53.34 77.72,53.53 75.73,53.53 75.54,53.34 75.54,52.94 v1(75.36,52.75)
DDR_A_DQS#7: length 56.2
  IN1 w0.076: 104.82,57.58 104.82,57.58 104.83,57.59 104.83,57.64 105.83,58.65 105.83,58.85 106.49,59.51 v1(106.49,62.36)
  IN1 w0.124: v1(73.84,47.52) 74.16,47.2 74.16,47.05 74.17,47.04 74.17,47.03 74.47,46.73 77.78,46.73 78.16,47.11 81.08,47.11 82.36,48.4 93.93,48.4 102.96,57.43 104.67,57.43 104.82,57.58
  BOTTOM w0.076: v1(106.49,62.36) 106.4,62.36 106.16,62.61 106.16,62.92 106.58,63.34 v4(108.57,63.34) 112.12,63.34 112.35,63.57 113.55,63.57 113.73,63.75 114.02,63.75 114.14,63.69 114.35,63.69 114.46,63.75 114.67,63.75 114.75,63.71 115.03,63.71 115.14,63.75 115.28,63.84 115.33,63.96 115.33,64.02 115.35,64.04 UC1.AY26
  BOTTOM w0.109: JDIMM1.240 71.65,48.24 71.8,48.09 72.02,48.09 72.69,47.42 72.76,47.22 72.92,47.06 73.94,47.06 74.05,47.17 74.05,47.38 73.91,47.52 v1(73.84,47.52)
DDR_A_MA0: length 52.8
  IN1 w0.076: 103.5,77.69 103.65,77.69 103.94,77.41 111.54,77.41 111.58,77.36 112.39,77.36 112.43,77.41 115.04,77.41 v1(115.41,77.78)
  IN1 w0.188: 103.5,77.69 94.05,77.69 89.29,72.94 80.18,72.94 79.52,73.6 77.68,73.6 77.41,73.33 75.52,73.33 75.45,73.39 73.66,73.39 73.63,73.37 72.22,73.37 71.8,73.79 71.8,74.05 71.99,74.24 72.73,74.24 72.86,74.12 73.21,74.12 73.44,73.88 v1(73.44,73.82)
  BOTTOM w0.076: v1(115.41,77.78) 115.22,77.97 UC1.AY50
  BOTTOM w0.183: v1(73.44,73.82) 73.64,73.82 73.77,73.95 73.77,74.2 73.65,74.32 72.61,74.32 72.53,74.24 JDIMM1.144
DDR_A_MA1: length 51.9
  IN1 w0.076: 104.67,80.21 104.67,79.88 105.28,79.27 109.18,79.27 109.41,79.5 109.59,79.5 109.81,79.27 110.04,79.27 110.12,79.35 v1(110.12,79.58)
  IN1 w0.183: 103.83,81.04 104.67,80.21 ; v1(76.54,76.57) 76.54,76.84 76.72,77.02 77.37,77.02
  IN1 w0.188: 103.83,81.04 91.09,81.04 87.51,77.46 86.97,77.46 86.78,77.27 86.78,76.88 86.64,76.74 86.02,76.74 85.83,76.92 85.83,77.27 85.65,77.46 85.27,77.46 85.08,77.27 85.08,76.92 84.89,76.74 84.4,76.74 84.21,76.92 84.21,77.27 84.02,77.46 83.64,77.46 83.46,77.27 83.46,76.92 83.27,76.74 82.89,76.74 82.7,76.92 82.7,77.27 82.52,77.46 82.14,77.46 81.95,77.27 81.95,76.92 81.77,76.74 81.45,76.74 80.9,77.29 80.14,77.29 79.59,76.74 79.21,76.74 78.97,76.97 78.51,76.97 78.28,76.74 77.79,76.74 77.55,76.97 77.41,76.97 77.37,77.02
  BOTTOM w0.076: v1(110.12,79.58) v2(109.27,79.58) 109.1,79.58 108.98,79.45 108.98,78.94 109.35,78.57 111.98,78.57 112.34,78.21 113.71,78.21 113.73,78.23 UC1.BB50
  BOTTOM w0.183: JDIMM1.133 79.15,76.99 78.01,76.99 77.76,77.24 76.29,77.24 76.16,77.11 76.16,76.94 v1(76.54,76.57)
DDR_A_MA2: length 54.3
  IN1 w0.076: 104.39,79.93 105.21,79.11 111.03,79.11 111.11,79.18 v1(111.11,79.48)
  IN1 w0.183: 103.75,80.58 104.39,79.93
  IN1 w0.188: 103.75,80.58 91.28,80.58 86.98,76.27 81.26,76.27 80.71,76.82 80.33,76.82 79.78,76.27 77.75,76.27 77.63,76.14 77.48,76.14 77.45,76.11 75.15,76.11 74.74,76.52 74.74,77.32 74.55,77.51 72.2,77.51 72.01,77.32 72.01,76.11 72.2,75.92 72.85,75.92 v1(73.49,76.57)
  BOTTOM w0.076: v1(111.11,79.48) 111.52,79.06 v2(111.79,79.06) 111.99,79.06 112.52,78.54 113.58,78.54 113.71,78.66 114.06,78.66 114.17,78.61 114.29,78.61 114.41,78.65 114.73,78.65 114.79,78.61 114.99,78.61 115.09,78.65 115.34,78.65 UC1.AY51
  BOTTOM w0.183: JDIMM1.132 72.82,77.24 v1(73.49,76.57)
