# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AUD_SPK_L+:
  vias: v2(26.53,9.08)
AUD_SPK_L+_C: length 0.9
  TOP w0.127: v1(14.42,4.74) v3(14.42,5.62)
  vias: v1(14.42,4.11) v1(25.97,5.25) v1(25.97,4.66)
AUD_SPK_L-_C:
  vias: v1(13.46,4.74) v1(13.46,4.11) v1(14.8,2.55) v1(14.8,1.94) v1(26.67,5.25) v1(26.67,4.66) v3(13.78,2.65)
AUD_SPK_R+: length 3.2
  TOP w0.127: v1(27.41,3.57) v2(28.23,3.57)
  IN3 w1.016: 27.52,5.8 27.52,6.21 26.65,7.07 26.65,7.86
  vias: v1(27.41,4.2) v1(27.94,9.31) v1(28.36,8.88)
AUD_SPK_R+_C: length 0.7
  TOP w0.127: 23.4,4.68 23.76,4.68 v2(24.01,4.94)
  vias: v1(19.69,4.42) v1(20.07,4.87)
AUD_SPK_R-: length 5.8
  TOP w0.127: v1(27.34,1.84) 27.87,1.84 v2(28.13,1.58)
  IN3 w1.016: 29.19,2.09 29.19,4.74 29.26,4.81 29.26,6.95
  vias: v1(26.7,1.84) v1(27.43,9) v1(27.88,8.55)
AUD_SPK_R-_C: length 1.2
  TOP w0.127: RA14.2 v3(26.04,1.58)
  vias: v1(19.24,2.33) v1(19.88,2.33)
AUD_VREF: length 3.2
  TOP w0.203: CA23.1 21.98,14.51 22.21,14.28 22.59,14.28 22.62,14.25 UA1.28
AUX_EN_WOWL: length 100.9
  TOP w0.089: UE1.34 50.1,69.81 v1(49.84,69.55) ; v1(47.57,112.4) 46.66,113.32 46.66,114.19 45.73,115.12 45.12,115.12 44.2,116.04 44.2,116.42 43.39,117.23 v2(43.39,118.16) v1(43.39,119.25)
  TOP w0.254: UW1.4 68.68,139.69 68.35,140.03 RW11.2 67.69,140.03 67.15,139.49 67.15,137.73 67.05,137.63 v1(67.05,137.42)
  IN1 w0.089: v1(49.84,69.55) 51.55,71.26 51.55,82.81 54.11,85.38 54.11,110.8 53.34,111.58 49.08,111.58 48.26,112.4 v1(47.57,112.4)
  BOTTOM w0.102: v1(67.05,137.42) 66.13,137.42 65.36,136.66 60.61,136.66 58.61,134.65 54.82,134.65 52.16,132 52.16,127.91 51.92,127.67 51.92,127.67 51.44,127.2 50.34,127.2 47.74,124.6 44.51,124.6 43.57,123.65 43.57,119.43 v1(43.39,119.25)
AUX_ON: length 43.8
  TOP w0.089: v2(14.63,88.15) 15.43,88.15 RL6.2 16.63,88.56 UL2.4 16.89,87.71 v1(16.62,87.43)
  TOP w0.102: UE1.3 v1(38.15,69.17)
  IN3 w0.102: v1(16.62,87.43) 16.62,86 17.48,85.14 19.33,85.14 19.87,84.59 19.87,79.67 21.11,78.44 25.76,78.44 25.95,78.63 25.95,78.8 27.35,80.2 29.76,80.2 31.65,78.31 32.61,78.31 34.31,76.6 36.48,76.6 38.95,74.13 38.95,69.97 v1(38.15,69.17)
BAT1_LED#: length 44.6
  TOP w0.102: v1(47.18,95.5) 46.84,95.85 Q17.1 ; v1(32.39,85.36) 31.94,85.82 30.39,85.82 RE18.1 29.51,87.71 v2(29.61,87.82) ; v1(37.6,78.33) 36.76,78.33 36.64,78.21 UE1.106
  IN1 w0.102: v1(47.18,95.5) 43.48,95.5 42.43,94.45 42.43,93.8 41.72,93.09 32.81,93.09 30.67,90.96 30.67,88.5 31.5,87.67 31.5,86.26 v1(32.39,85.36)
  IN3 w0.102: v1(32.39,85.36) 31.85,84.82 31.85,83.88 33.96,81.77 37.74,81.77 38.12,81.39 38.12,78.85 v1(37.6,78.33)
BAT2_LED#: length 44.8
  TOP w0.089: RE21.1 34.44,65.58 v1(35.26,65.58)
  TOP w0.102: UE1.1 37.35,66.55 v1(37.22,66.42) ; v1(45.65,97.15) Q17.4 44.18,97.15 v2(43.82,97.51)
  IN3 w0.102: v1(45.65,97.15) 46.23,96.58 46.23,92.71 45.32,91.81 44.87,91.81 43.47,90.41 43.47,87.94 42.6,87.07 41.16,87.07 39.02,84.93 39.02,83.78 39.25,83.55 39.25,77.78 40.86,76.17 40.86,73.88 39.94,72.96 39.94,68.68 37.68,66.42 v1(37.22,66.42) 36.38,65.58 v1(35.26,65.58)
BATGONE_CHG: length 4.7
  TOP w0.089: PCB34.1 v2(206.74,44.39)
  TOP w0.254: PCB34.1 PRB24.1 206.62,46.38 PRB25.1 207.27,47.73 v1(207.38,47.73)
  BOTTOM w0.203: v1(207.38,47.73) 206.94,47.29 PUB01.25
BATT_WHITE_LED_R#: length 10.9
  TOP w0.089: Q22.1 47.36,102.4 46.93,101.97 46.93,100.74 46.15,99.96 46.15,97.61 Q17.3
  TOP w0.102: Q17.3 47.5,97.15 47.86,97.5 Q19.2
BEEP: length 101.9
  TOP w0.089: DA3.2 v1(38.77,11.73) v2(39.59,11.73)
  TOP w0.102: UE1.45 50.42,74.21 50.22,74.41 49.17,74.41 v1(48.97,74.61)
  IN1 w0.102: v1(37.09,52.54) 37.42,52.87 44.47,52.87 45.82,54.21 50.02,54.21 v1(50.59,53.64)
  IN2 w0.102: v1(31.44,29.46) 32.11,30.13 32.11,31.15 31.32,31.94 31.32,35.01 32.8,36.49 32.8,37.01 31.68,38.13 31.68,43.68 32.11,44.12 34.57,44.12 35.38,44.93 35.38,48.91 36.28,49.81 36.28,51.21 37.09,52.03 v1(37.09,52.54)
  BOTTOM w0.089: v1(31.44,29.46) 31.44,28.72 31.73,28.44 34.56,28.44 36.32,30.2 40.72,30.2 41.28,29.64 41.28,23.95 41.13,23.8 39.62,23.8 39.2,23.38 39.2,22.26 39.9,21.56 39.9,12.86 v1(38.77,11.73)
  BOTTOM w0.102: v1(48.97,74.61) 48.97,74.31 50.52,72.76 50.52,66.12 49.86,65.46 49.86,59.6 50.88,58.58 50.88,53.93 v1(50.59,53.64)
BGATE_CHG: length 82.3
  TOP w0.089: v1(146.45,34.95) 146.43,34.96 145.86,34.96 v2(145.75,34.86)
  IN2 w0.381: 207.78,37.4 207.59,37.21 198.87,37.21 198.74,37.35
  IN2 w0.508: 207.78,37.4 208.63,38.24 v1(208.63,42.1) ; 198.74,37.35 198.49,37.6 196.05,37.6 195.55,38.1 193.9,38.1 193.38,37.57 192.85,37.57 192.45,37.97 186.65,37.97 186.43,38.18 184.86,38.18 183.79,37.12 181.2,37.12 180.36,36.28 178.62,36.28 176.56,34.21 174.15,34.21 173.86,34.5 167.36,34.5 166.65,35.2 165.41,35.2 164.36,34.16 163.24,34.16 162.86,33.78 158.87,33.78 157.94,32.85 155.34,32.85 154.87,33.32 152.58,33.32 151.06,34.84 146.55,34.84 v1(146.45,34.95)
  BOTTOM w0.381: v1(146.45,34.95) 146.43,34.96 145.43,34.96 144.93,34.46 144.93,33.3 146.56,31.67 PCB33.1 147.05,31.22 147.62,31.22 148,30.85 PQB03.4
  BOTTOM w0.508: 206.8,43.98 206.8,43.32 207.56,42.55 208.17,42.55 v1(208.63,42.1)
BKLT_CTRL: length 21.7
  TOP w0.102: RP2.7 173,72.44 173,73.38 173.96,74.34 174.94,74.34 D3.1 177.73,71.55 R9.1 177.41,71.15 177.11,71.15 v1(176.81,71.46) ; v1(176.06,65.97) 176.51,65.51 v2(176.72,65.51) 177.41,65.51 RP1.8
  BOTTOM w0.089: v1(176.81,71.46) 177.61,70.66 177.61,69.79 176.06,68.25 v1(176.06,65.97)
BKLT_IN_EC: length 157
  TOP w0.089: RC6.2 128.56,56.17 128.7,56.31 v1(129.17,56.31) ; v1(125.68,38.05) 125.27,37.64 v2(125.27,36.56)
  TOP w0.102: v1(44.99,76.89) 47.54,76.89 48.95,78.3 UE1.67
  IN2 w0.089: v1(44.99,76.89) 45.42,76.89 46.21,76.11 46.21,74.62 48.56,72.27 48.56,69.52 48.57,69.51 48.57,69.05 49.59,68.03 49.97,68.03 50.75,67.25 50.75,64.4 50.17,63.83 50.17,58.7 49.77,58.29 49.77,57.72 50.22,57.27 50.22,52.33 50.04,52.15 50.04,47.9 51.26,46.68 51.26,42.51 54.4,39.37 57.57,39.37 62.17,34.77 68.18,34.77 68.84,35.43 69.54,35.43 69.97,35 71.67,35 72.28,34.39 75.63,34.39 76.08,34.85 81.69,34.85 82.74,35.9 83.5,36.66 84.41,36.66 85.05,37.3 87.16,37.3 87.39,37.54 90.7,37.54 91.87,36.37 95.11,36.37 95.8,37.06 96.7,37.06 96.96,37.32 98.33,37.32 98.48,37.16 99.44,37.16 101.54,35.06 106.15,35.06 106.9,35.8 109.65,35.8 110.28,36.43 114.46,36.43 114.93,36.9 120.76,36.9 121.79,37.94 122.37,37.94 122.8,38.37 124.03,38.37 124.67,38.37 124.99,38.05 v1(125.68,38.05)
  IN3 w0.089: v1(125.68,38.05) 125.68,38.05 125.68,39.22 125.98,39.52 125.98,39.87 126.93,40.83 128.43,40.83 128.65,41.04 128.65,41.34 129.6,42.3 129.6,42.63 129.75,42.77 129.75,47.56 130.32,48.13 130.32,49.54 130.32,49.55 130.32,50.9 130.18,51.04 130.18,51.72 130.57,52.11 130.57,52.35 129.61,53.31 129.61,53.6 129.38,53.83 129.38,54.46 129.12,54.72 128.99,54.72 128.63,55.08 128.63,55.93 129.01,56.31 v1(129.17,56.31)
  BOTTOM w0.102: UC1.R12 128.88,56.31 v1(129.17,56.31)
BLON_OUT_C: length 60.3
  TOP w0.089: RP2.1 176.45,68.28 v1(176.45,67.97) 176.07,67.59 176.07,66.87 v2(176.17,66.77) 176.89,66.05 177.23,66.05 RP1.7
  IN1 w0.102: v1(176.45,67.97) 176.45,68.27 176.88,68.7 177.49,68.7 179.55,66.63 180.12,66.63 183.6,63.15 190.34,63.15 191.39,62.1 191.39,61.46 192.21,60.65 193.75,60.65 196.73,57.66 202.88,57.66 203.33,57.2 208.63,57.2 209.01,57.58 212.12,57.58 212.14,57.56 214.12,57.56 214.52,57.16 214.52,51.12 214.35,50.95 214.35,47.85 v1(214.03,47.53)
  BOTTOM w0.102: v1(214.03,47.53) 213.69,47.19 213.22,47.19 212.98,46.95 JEDP1.28
BLUETOOTH_EN: length 193.7
  TOP w0.089: RW14.1 RC226.2 40.95,98.53 DW2.1 40.46,98.22 37.78,98.22 v1(37.65,98.09)
  IN1 w0.089: v1(51.26,51.4) 51.26,52.44 49.72,53.98 45.86,53.98 44.55,52.68 40.97,52.68 40.34,52.05 40.34,44.98 41.1,44.22 v1(41.7,44.22)
  IN2 w0.102: v1(51.26,51.4) 50.98,51.12 50.98,48.3 52.2,47.08 52.2,43.16 55.03,40.32 55.36,40.32 57.94,40.32 61.19,37.07 70.21,37.07 70.65,36.63 73.43,36.63 73.88,37.08 79.94,37.08 82.78,39.92 96.15,39.92 98.74,42.52 105.11,42.52 105.33,42.3 107.99,42.3 111.3,45.61 113.44,45.61 113.85,46.03 117.7,46.03 117.96,46.29 118.71,46.29 119.31,45.69 121.18,45.69 121.36,45.87 123.96,45.87 125.25,47.16 v1(125.6,47.16)
  IN3 w0.089: v1(34.51,41.73) 34.53,41.75 38.67,41.75 41.15,44.22 v1(41.7,44.22)
  BOTTOM w0.076: UC1.AB2 125.08,50.4 124.82,50.14 124.82,49.82
  BOTTOM w0.089: v1(37.65,98.09) 36.81,97.25 36.81,91.99 35.91,91.09 35.91,89.29 35.23,88.61 35.23,88.04 33.73,86.54 32.73,86.54 31.41,85.22 31.41,83.67 32.69,82.39 32.69,78.66 32.21,78.17 32.21,66.2 31.5,65.49 31.5,63.76 33.15,62.11 33.15,60.38 33.63,59.9 33.63,57.39 34.96,56.06 34.96,51.74 36.1,50.59 36.1,45.75 35.27,44.92 35.27,42.49 v1(34.51,41.73)
  BOTTOM w0.102: 125.31,47.54 125.08,47.77 125.08,49.57 124.82,49.82 ; v1(125.6,47.16) 125.6,46.58 RC42.2
  BOTTOM w0.112: 125.31,47.54 125.6,47.25 v1(125.6,47.16)
BOARD_ID: length 24.8
  TOP w0.089: v2(35.02,89.06) 35.15,89.06 v1(35.53,89.44) ; v1(31.7,89.57) 31.45,89.82 RE1.2 ; UE1.111 37.21,76.21 v1(37.58,76.58)
  TOP w0.102: v1(35.53,89.44) 34.88,90.09 CE2.1 34.88,91.09 RE6.2
  IN1 w0.102: v1(31.7,89.57) 32.36,90.23 34.73,90.23 v1(35.53,89.44)
  IN2 w0.102: v1(35.53,89.44) 35.34,89.25 35.34,88.55 34.91,88.11 34.91,85.82 37.94,82.79 37.94,79.56 37.77,79.38 37.44,79.38 37.16,79.11 37.16,76.99 v1(37.58,76.58)
BOARD_ID1: length 8.6
  BOTTOM w0.102: 124.69,49.38 124.34,49.73 124.34,50.25 UC1.AC1
  BOTTOM w0.112: 124.69,49.38 124.69,48.01 124.42,47.73 124.42,47.32 124.72,47.01 124.72,46.3 v2(124.53,46.1) 124.36,45.93 124.36,45.17 124.97,44.56 124.97,44.31 125.57,43.71 RC57.2 RC58.1
BOARD_ID2: length 6.4
  BOTTOM w0.076: 125.8,48.82 125.8,49.23 125.46,49.57 125.46,50.91 UC1.AB3
  BOTTOM w0.102: 125.8,48.82 125.57,48.59 125.57,47.93 125.83,47.67 126,47.67 v2(126.09,47.58)
  BOTTOM w0.112: RC56.1 126.26,46.47 RC55.2 126.03,46.69 126.03,47.3 126.09,47.36 v2(126.09,47.58)
BOOT1_CHG: length 1.3
  TOP w0.089: v2(200.48,45.5) 200.88,45.91 v1(201.63,45.91)
BOOT2_CHG: length 3.6
  BOTTOM w0.203: PCB30.1 203.82,41.73 204.4,41.73 204.64,41.97 v2(204.64,42.27) 204.64,42.77 204.73,42.86 204.73,43.4 204.77,43.43 PUB01.4
BOT_MUX_N: length 3.1
  BOTTOM w0.112: UT3.9 28.62,127.56 28.38,127.32 28.36,127.32 27.93,126.89 27.93,126.87 27.69,126.63 LT4.3 27.52,125.73 RT58.1
BOT_MUX_N_R: length 35.7
  TOP w0.112: JUSBC1.B7 6.58,121.57 v1(6.61,121.55)
  IN3 w0.135: v1(6.61,121.55) 6.61,121.55 6.95,121.2 7.46,121.2 7.7,120.96 8.85,120.96 12.14,117.67 12.14,116.52 13.07,115.59 14.08,115.59 14.99,116.5 27.17,116.5 v1(27.32,116.65)
  BOTTOM w0.112: v1(27.32,116.65) 27.5,116.47 28.21,116.47 28.33,116.58 28.33,118.27 27.31,119.28 27.31,120.55 27.75,120.99 27.75,121.24 27.38,121.61 EU4002.8 EU4002.2 27.38,123.48 27.52,123.62 27.52,123.63 27.61,123.72 27.62,123.72 27.82,123.92 27.82,124.17 27.69,124.3 LT4.4 27.52,124.81 RT58.2
BOT_MUX_P: length 3.2
  BOTTOM w0.112: RT57.1 28.32,125.76 LT4.2 28.19,126.16 27.91,126.44 27.91,126.53 v4(28.3,126.93) 28.84,127.47 28.84,127.67 29.02,127.85 UT3.8
BOT_MUX_P_R: length 35.8
  TOP w0.112: JUSBC1.B6 5.75,121.07 6.48,121.07 v1(6.59,120.96)
  IN3 w0.135: v1(27.32,116.07) 27.14,116.26 15.09,116.26 14.18,115.35 12.97,115.35 11.9,116.42 11.9,117.57 8.75,120.72 7.6,120.72 7.36,120.96 v1(6.59,120.96)
  BOTTOM w0.112: v1(27.32,116.07) 27.5,116.25 28.31,116.25 28.55,116.49 28.55,118.36 27.53,119.38 27.53,120.45 27.97,120.9 27.97,121.18 28.38,121.58 28.38,121.82 EU4002.7 EU4002.4 28.38,123.54 28.04,123.88 28.04,124.2 28.19,124.35 LT4.1 28.19,124.68 RT57.2
BP_0: length 6.2
  BOTTOM w0.089: RV82.1 122.28,118.85 v2(122.28,117.2)
  BOTTOM w0.102: RV82.1 122.96,120.49 122.96,122.21 UV1.U1
BP_1: length 5.2
  BOTTOM w0.102: RV81.1 121.61,119.99 121.92,119.99 v2(122.39,120.45) 122.66,120.73 122.66,122.46 123.34,123.14 UV1.U3
BREATH_LED#: length 81.3
  TOP w0.089: v1(47.69,82.21) 47.75,82.27 47.75,82.33
  TOP w0.102: UE1.70 47.75,82.33 ; v1(53.34,33.13) 54.26,33.13 54.52,33.38 Q21.3 53.86,34.83 R53.2
  IN1 w0.102: v1(47.69,82.21) 47.55,82.06 46.94,82.06 46.15,81.28 43.39,81.28 42.85,81.82 36.72,81.82 34.11,79.21 34.11,77.38 35.54,75.95 35.54,71.47 33.18,69.1 33.18,66.41 34.74,64.84 35.14,64.84 36.65,63.32 v1(37.14,63.32)
  IN2 w0.102: v1(37.14,63.32) 38.18,63.32 39.13,62.37 40.36,62.37 41.14,61.59 42.12,61.59 44.1,59.62 44.1,57.28 43.17,56.36 43.17,45.73 42.72,45.27 42.72,43.69 44.43,41.98 44.43,40.71 51.55,33.58 52.89,33.58 v1(53.34,33.13)
  BOTTOM w0.089: v2(52.69,33.31) 52.87,33.13 v1(53.34,33.13)
BST2_VGA: length 3.8
  TOP w0.089: v2(74.94,135.77) 76.54,135.77 77.12,135.19 PRV01.1
BST_1.2V_R: length 4.5
  TOP w0.089: v2(42.58,30.67) 41.58,30.67 PRM02.2
  TOP w0.508: PRM02.2 41.25,27.9 PCM12.1
BST_3V: length 2.1
  BOTTOM w0.089: PR301.1 20.98,39.71 21.81,38.87 22.3,38.87 v2(22.44,38.74)
BST_5V: length 1
  TOP w0.089: v1(24.01,99.39) v3(25.01,99.39)
BST_+1.35VGPU: length 2.9
  TOP w0.089: v2(145.27,109.81) 145.53,109.56 v1(145.53,109.12)
  TOP w0.508: PRW06.1 145.53,108.85 v1(145.53,109.12)
  BOTTOM w0.254: PUW01.1 v1(145.53,109.12)
BST_+1.35VGPU_R: length 1.3
  TOP w0.089: v2(146.5,109.36) 146.2,109.06 PRW06.2
BST_+1VALW: length 2
  TOP w0.089: v1(163.1,49.59) 163.05,49.59 162.52,49.06 v2(162.52,48.83)
  TOP w0.254: PRH06.1 163.47,49.96 v1(163.1,49.59)
BST_+1VALW_R: length 1.5
  TOP w0.089: PRH06.2 162.07,51.61 v3(161.86,51.82)
BST_VCCSA: length 0.7
  TOP w0.089: v1(165.79,60.26) v2(166.51,60.26)
BST_VCCSA_R: length 1.5
  TOP w0.089: PCA07.1 164.96,59.7 v2(165.26,59.39)
BST_VCORE1: length 3.1
  TOP w0.089: PRI01.1 164.47,69.74 164.49,69.72 164.49,69.47 v2(164.04,69.02)
  TOP w0.508: v1(164.02,70.92) 164.47,70.46 PRI01.1
  BOTTOM w0.254: v1(164.02,70.92) PUI01.5
BST_VCORE1_R: length 2.7
  TOP w0.089: PCI09.1 v2(167.16,71.63)
  TOP w0.508: PRI01.2 165.75,71.62 PCI09.1
BST_VCORE2: length 2.7
  TOP w0.254: v1(167.6,85.71) 166.96,85.71 v2(166.94,85.68) 166.79,85.53 PRI21.1
  BOTTOM w0.254: PUI02.5 167.41,85.52 v1(167.6,85.71)
BST_VCORE2_R: length 3.3
  TOP w0.089: PCI29.1 169.53,83.12 v3(169.93,82.71)
  TOP w0.508: PRI21.2 PCI29.1
CAP_LED: length 41.6
  TOP w0.089: R25.2 50.8,46.3 50.8,47.11 50.81,47.13 51.45,47.76 v3(51.45,48.1) 51.45,49.04 v1(51.37,49.12)
  BOTTOM w0.089: JKB1.27 80.55,35.2 80.1,35.65 76.53,35.65 74.8,37.38 72.24,37.38 70.63,39 68.65,39 68.14,39.5 61.81,39.5 61.62,39.68 58.17,39.68 54.68,43.18 54.68,45.69 51.37,49 v1(51.37,49.12)
CAP_LED#: length 44.7
  TOP w0.089: Q6.3 48.35,48.96 v1(48.35,48.05) ; R24.2 50.31,48.52 v2(50.31,49.39)
  TOP w0.102: Q6.3 49.15,49.08 49.86,48.37 R24.2 ; UE1.93 38.55,81.39 v1(40,79.94)
  IN2 w0.102: v1(48.35,48.05) 47.63,48.77 47.63,53.04 48.18,53.58 48.18,61.19 48.99,62.01 48.99,63.66 48.93,63.72 48.93,66.64 46.45,69.11 46.45,73.12 40.52,79.05 40.52,79.42 v1(40,79.94)
CAP_LED_Q: length 3.4
  TOP w0.089: v2(50.17,43.67) R25.1
  TOP w0.102: R25.1 49.87,44.76 49.22,44.11 Q7.1
CAP_LED_R#: length 4.4
  TOP w0.089: Q6.1 45.72,48.11 45.04,47.43 v2(45.04,46.6) 45.04,46.05 Q7.2
CBN: length 1.5
  TOP w0.203: CA24.1 22.33,11.45 UA1.35
CBP: length 3.3
  TOP w0.203: v1(23.91,10.22) 23.93,10.2 UA1.37
  TOP w0.305: CA24.2 v1(22.22,10.63)
  BOTTOM w0.305: v1(22.22,10.63) 22.83,10.01 23.7,10.01 v1(23.91,10.22)
CCG4_CC1_P1: length 48.1
  TOP w0.254: CT11.1 39.96,121.55 v1(40.24,121.55) ; v1(8.34,121.88) 8.29,121.83 7.35,121.83 JUSBC1.A5
  IN1 w0.254: v1(23.29,130.7) 24.21,129.77 24.21,128.98 24.57,128.62 27.07,128.62 28.05,127.64 30.21,127.64 33.49,124.36 33.49,122.43 33.82,122.11 38.86,122.11 39.42,121.55 v1(40.24,121.55)
  IN3 w0.254: v1(8.29,125.38) 7.93,125.02 7.93,124.98 7.43,124.48 7.43,122.27 7.89,121.8 8.26,121.8 v1(8.34,121.88)
  BOTTOM w0.203: v1(23.29,130.7) 23.2,130.61 23.2,130.59 22.97,130.36 EU4001.9 EU4001.1 19.62,130.36 19.5,130.25 16.12,130.25 15.32,129.45 14.74,129.45 14.39,129.8 12.12,129.8 11.52,129.2 11.52,127.53 v2(9.38,125.38) v1(8.29,125.38)
  BOTTOM w0.254: UT1.9 v1(40.24,121.55)
CCG4_CC2_P1: length 55.2
  TOP w0.254: v1(6.57,120.37) 6.41,120.37 6.2,120.57 JUSBC1.B5 ; v1(30.35,128.1) 29.83,128.1 28.2,126.47 v2(28.2,125.66) 28.2,124.42 28.56,124.06 v1(29.09,124.06) ; v1(40.25,122.6) 39.8,122.6 CT10.1
  IN1 w0.254: v1(30.35,128.1) 34.24,124.21 38.31,124.21 39.93,122.6 v1(40.25,122.6)
  IN3 w0.254: v1(23.73,115.68) 17.86,115.68 16.62,114.44 13.06,114.44 10.7,116.8 10.04,116.8 8.09,118.75 8.09,118.91 6.63,120.37 v1(6.57,120.37)
  BOTTOM w0.203: v1(23.73,115.68) 24.24,115.17 28.15,115.17 29.09,116.11 29.09,118.63 28.73,118.98 28.73,121.79 28.88,121.93 EU4002.6 EU4002.5 28.88,123.85 v1(29.09,124.06)
  BOTTOM w0.254: UT1.7 40.2,122.55 v1(40.25,122.6)
CCG4_I2C_INT#: length 87.9
  TOP w0.102: UE1.32 49.75,66.92 v1(50.07,66.6) 50.2,66.47 v2(50.69,66.47) 51.3,66.47 51.98,67.14 53.27,67.14 RE71.1
  IN1 w0.089: v1(50.07,66.6) 49.18,67.49 49.18,72.88 49.44,73.13 50.28,73.13 50.63,73.48 50.63,80.53 49.92,81.24 49.59,81.24 49.02,81.81 49.02,82.32 47.94,83.4 37.27,83.4 36.08,84.59 34.72,84.59 34.31,84.99 34.31,85.18 31.97,87.52 31.97,88.71 v1(31.12,89.57)
  IN1 w0.102: v1(30.94,117.09) 31.92,118.07 35.98,118.07 36.64,118.73 36.64,119.42 v1(36.64,119.42)
  BOTTOM w0.102: v1(36.64,119.42) UT1.15 ; v1(30.94,117.09) 31.42,117.09 33.23,115.27 33.23,111.38 34.25,110.36 36.06,110.36 37.68,108.75 37.68,105.62 37.12,105.06 37.12,102.66 35.93,101.47 35.93,100.17 35.12,99.36 35.12,93.67 33.68,92.22 32.67,92.22 31.12,90.67 v1(31.12,89.57)
CCG4_ID1: length 4.6
  BOTTOM w0.089: UT1.25 32.95,123.05 31.83,121.92 RT4.1 30.29,121.92 RT3.2 v2(30.29,120.81)
CCG4_ID2: length 6.8
  TOP w0.089: RT65.1 RT64.2 32.85,124.37 32.53,124.05 v1(32.53,124.04) 32.53,124.04 32.94,123.64 32.94,123.21 32.09,122.36 v2(31.62,122.36)
  BOTTOM w0.102: UT1.27 32.53,124.05 v1(32.53,124.04)
CCG4_SWD_CLK: length 8.1
  IN1 w0.089: v1(40.24,125.05) 39.76,125.05 39.58,124.86 39.58,124.16 39.82,123.92 40.43,123.92 40.63,123.73 40.63,122.31 40.9,122.03 v1(42.53,122.03)
  BOTTOM w0.089: v1(42.53,122.03) 42.83,122.33 JCCG4.4
  BOTTOM w0.102: UT1.2 v1(40.24,125.05)
CCG4_SWD_IO: length 5.3
  TOP w0.089: v2(42.34,124.09) v1(42.34,124.82)
  IN1 w0.089: v1(40.22,125.67) 41.31,125.67 42.15,124.82 v1(42.34,124.82)
  BOTTOM w0.089: v1(42.34,124.82) 42.68,124.82 42.83,124.98 JCCG4.5
  BOTTOM w0.102: UT1.1 40.1,125.55 v1(40.22,125.67)
CCG4_XRES: length 9.9
  TOP w0.089: v1(40.24,120.82) 40.13,120.71 37.26,120.71 RT5.2 36.98,120.99 36.98,121.51 CT9.1 37.04,122.08 v2(36.33,122.08)
  IN1 w0.089: v1(40.24,120.82) 40.86,121.45 v1(42.53,121.45)
  BOTTOM w0.089: JCCG4.3 42.83,121.14 v1(42.53,121.45)
  BOTTOM w0.102: v1(40.24,120.82) 40.02,121.05 UT1.10
CFG0: length 8.7
  TOP w0.112: TPC10.1 140.53,90.09 v1(140.45,90.17)
  BOTTOM w0.076: UC1.E68 134.87,88.02 135.16,87.86 135.58,87.86 135.82,87.77 136.03,87.77 136.07,87.79 136.8,87.79 137.05,88.03 137.37,88.03 139.11,89.77 139.18,89.77
  BOTTOM w0.112: 139.18,89.77 140.15,89.77 140.45,89.48 RC131.2 140.83,89.59 140.83,89.79 v1(140.45,90.17)
CFG1: length 9.3
  BOTTOM w0.076: 138.3,91.6 137.17,90.47 137.17,89.64 136.69,89.15 136.45,89.15 135.9,88.6 UC1.B67
  BOTTOM w0.112: 138.3,91.6 138.77,92.07 TPC11.1 139.44,94.64 139.75,94.33 RC132.2
CFG2: length 6.4
  BOTTOM w0.076: UC1.D65 135.11,87.17 135.48,87.17 135.79,87.28 137.4,87.28 137.51,87.39 137.51,87.95 138.83,89.26 139.18,89.26
  BOTTOM w0.112: TPC12.1 139.55,89.26 139.18,89.26
CFG3: length 29.6
  TOP w0.089: RC175.1 124.27,96.61
  TOP w0.112: 124.27,96.61 124.27,97.61 124.82,98.16 131.16,98.16 133.5,95.82 136.77,95.82 141.24,91.35 v1(141.27,91.35) 141.29,91.33 TPC13.1
  BOTTOM w0.076: 139.18,90.53 138.11,89.46 138.11,89.13 137.27,88.29 137.03,88.29 136.7,87.95 136.03,87.95 135.98,87.94 135.85,87.94 135.68,88 135.57,88.04 135.57,88.06 135.3,88.18 UC1.D67
  BOTTOM w0.112: v1(141.27,91.35) 140.88,90.97 RC133.2 140.59,90.97 140.15,90.53 139.18,90.53 139.18,90.53
CFG4: length 3.4
  TOP w0.089: 134.74,91.86 TPC14.1 134.6,92 RC136.2
  TOP w0.102: v1(134.74,91.13) 134.74,91.86
  BOTTOM w0.076: UC1.E70 134.24,90.25 134.44,90.45 134.44,90.8 134.74,91.1 v1(134.74,91.13)
CFG5: length 6.8
  BOTTOM w0.076: UC1.C68 135.04,88.93 135.58,89.47 135.58,90.18 135.76,90.36 135.76,91.08
  BOTTOM w0.102: 136.92,92.24 135.76,91.08
  BOTTOM w0.112: TPC15.1 137.13,92.45 136.92,92.24
CFG6: length 4.7
  BOTTOM w0.076: UC1.D68 134.77,90.1 135.13,90.47 135.13,90.97
  BOTTOM w0.102: 136.24,92.24 136.24,92.08 135.13,90.97
  BOTTOM w0.112: TPC16.1 136.24,92.24
CFG7: length 6.2
  BOTTOM w0.076: UC1.C67 135.8,88.79 136.2,89.19 136.2,89.57 136.48,89.85 136.73,89.85 136.92,90.04 136.92,90.99 137.91,91.98
  BOTTOM w0.112: TPC17.1 137.96,92.03 137.91,91.98
CFG8: length 3.8
  BOTTOM w0.076: UC1.F71 133.68,90.24 133.68,90.5 133.64,90.54 133.64,91.65 133.87,91.87
  BOTTOM w0.102: 133.99,91.99 133.87,91.87
  BOTTOM w0.112: TPC20.1 134.39,92.39 133.99,91.99
CFG9: length 4.4
  BOTTOM w0.076: 132.7,91.93 132.7,91.7 ; 132.92,91.32 132.92,90.98 132.72,90.78 132.72,90.51 132.78,90.39 132.78,90.26 132.71,90.03 132.71,89.89 132.79,89.68 132.79,89.42 UC1.G69
  BOTTOM w0.089: 132.92,91.32 132.92,91.47 132.7,91.7
  BOTTOM w0.112: 132.7,91.93 132.7,92.63 132.59,92.74 TPC21.1
CFG10: length 6
  BOTTOM w0.076: UC1.F70 133.88,89.85 133.88,90.47 133.88,90.47 133.88,90.64 133.82,90.69 133.82,91.44
  BOTTOM w0.102: 134.11,91.74 133.82,91.44
  BOTTOM w0.112: TPC22.1 135.28,92.53 134.48,91.74 134.11,91.74
CFG11: length 7.5
  BOTTOM w0.076: 133.87,92.24 133.87,92.19 133.47,91.79 133.47,90.46 133.32,90.31 133.32,89.83 133.18,89.69 133.18,89.5 133.32,89.36 133.32,89.17 132.89,88.74 UC1.G68
  BOTTOM w0.112: TPC23.1 134.23,94.55 133.77,94.08 133.77,93.07 133.99,92.84 133.99,92.36 133.87,92.24
CFG12: length 3.3
  BOTTOM w0.076: TPC24.1 131.57,92.25 131.93,91.89 131.93,90.93 132.1,90.76 132.1,90.48 132.04,90.35 132.04,90.24 132.1,90.11 132.1,89.88 UC1.H70
CFG13: length 4
  BOTTOM w0.076: 133.08,92.03 133.08,91.61 133.14,91.55 133.14,90.83 132.99,90.69 UC1.G71
  BOTTOM w0.112: 133.08,92.03 133.08,94.25 TPC25.1
CFG14: length 6.1
  BOTTOM w0.076: UC1.H69 132.33,89.2 132.6,89.47 132.6,89.73 132.54,89.89 132.54,90.03 132.6,90.25 132.6,90.37 132.57,90.45 132.56,90.48 132.56,90.89 132.68,91.01 132.68,91.43 132.37,91.75
  BOTTOM w0.112: TPC26.1 132.01,94.61 132.01,92.47 132.37,92.11 132.37,91.75
CFG15: length 2.9
  BOTTOM w0.076: 133.34,91.98 133.31,91.95 133.31,91.77 133.31,90.53 132.99,90.21 UC1.G70
  BOTTOM w0.112: 133.34,91.98 133.48,92.12 TPC27.1
CFG16: length 10.9
  IN3 w0.135: v1(129.04,93.36) 129.45,92.94 129.45,90.66 v1(133.97,86.15)
  BOTTOM w0.076: UC1.E63 133.89,86.06 v1(133.97,86.15)
  BOTTOM w0.112: TPC19.1 129.04,93.4 v1(129.04,93.36)
CFG17: length 9.8
  IN3 w0.135: v1(129.04,92.21) 129.04,90.69 131.95,87.78 131.95,87.05 132.35,86.65 132.83,86.65 v1(133.34,86.15)
  BOTTOM w0.076: UC1.F63 133.24,86.05 v1(133.34,86.15) ; 128.58,92.21 v1(129.04,92.21)
  BOTTOM w0.112: TPC18.1 128.58,92.21
CFG18: length 9.8
  IN3 w0.135: v1(129.87,93.32) 130.31,92.87 130.31,91.83 130.18,91.71 130.18,90.69 131.93,88.94 133.16,88.94 v1(133.89,88.21)
  BOTTOM w0.076: v1(133.89,88.21) UC1.E66
  BOTTOM w0.112: TPC29.1 129.87,94.53 v1(129.87,93.32)
CFG19: length 7.1
  IN3 w0.135: v1(129.87,92.21) 129.87,90.63 131.81,88.69 132.76,88.69 v1(133.24,88.21)
  BOTTOM w0.076: 129.87,92.22 v1(129.87,92.21) ; v1(133.24,88.21) UC1.F66
  BOTTOM w0.102: 129.87,92.24 129.87,92.22
  BOTTOM w0.112: TPC28.1 129.87,92.35 129.87,92.24
CFG_0: length 2.7
  TOP w0.102: UT5.59 43.99,108.97 44.67,109.66 44.67,110.02 RT74.1
CFG_1: length 8.8
  TOP w0.102: v1(47.19,107.37) 47.19,108.75 v2(47.28,108.84) 48.07,109.63 RT76.1 ; UT5.58 44.52,108.57 v1(44.58,108.51) 44.74,108.66 44.74,108.94 RT75.1
  IN1 w0.089: v1(44.58,108.51) 45.72,107.37 v1(47.19,107.37)
CFG_RCOMP: length 2.1
  TOP w0.089: v2(133.94,82.71) 134.12,82.89 v1(134.12,83.36)
  TOP w0.254: v1(134.12,83.36) 133.5,83.98 RC134.1
  BOTTOM w0.254: UC1.E60 133.82,83.66 v1(134.12,83.36)
CHG_AMBER_LED_R#: length 8.8
  TOP w0.089: Q18.2 51.64,93.5 v2(52.26,94.12)
  TOP w0.102: Q17.6 45.72,95.85 48.07,93.5 Q18.2
CLK_ITPXDP_N: length 1.3
  TOP w0.089: TP8.1 133.4,74.73 v1(133.4,75.08)
  BOTTOM w0.076: v1(133.4,75.08) 133.45,75.04 133.45,74.71 133.34,74.6 UC1.F43
CLK_ITPXDP_P: length 1.3
  TOP w0.089: v1(133.58,74.14) 133.58,73.45 133.59,73.44 TP9.1
  BOTTOM w0.076: v1(133.58,74.14) 133.58,74.19 133.82,74.43 UC1.E43
CLK_LAN_REQ2#_R: length 6.4
  TOP w0.089: RL13.2 29.8,80.46 30.26,80.01 30.26,78.71 v2(30.06,78.51)
  TOP w0.102: UL1.12 27.26,82.06 28.38,80.95 29.26,80.95 RL13.2
CLK_PCIE_LAN_N2: length 175.2
  TOP w0.112: UL1.16 26.71,83.66 26.79,83.58 27.06,83.58 27.69,84.21 28.11,84.21 v1(28.24,84.35)
  IN1 w0.076: 132.19,82.19 132.19,82.19 132.21,82.16 132.21,82.12 132.22,82.1 132.27,82 132.27,80.08 132.11,79.93 132.11,78.41 131.94,78.24 131.94,74.14 132.48,73.6 133.26,73.6 133.48,73.38 133.48,73.13 133.46,73.11 133.46,72.95 133.49,72.92 133.49,72.89 133.5,72.88
  IN1 w0.119: 133.5,72.88 134.54,71.83 138.16,71.83 138.17,71.82 138.57,71.82 139.74,73 140.07,73 v1(140.34,72.74) ; v1(54.69,114.33) 54.84,114.18 54.84,113.85 55.09,113.61 56.17,113.61 56.46,113.9 57.3,113.9 57.49,114.09 59.06,114.09 60.28,112.88 75.78,112.88 77.17,111.49 78.5,111.49 79.19,110.8 82.36,110.8 83.27,109.89 96.6,109.89 97.26,109.23 99.72,109.23 100.16,109.67 103.85,109.67 104.35,109.16 117.24,109.16 123.07,103.34 125.43,103.34 126.72,102.05 126.72,100.19 128.32,98.58 128.32,95.67 130.72,93.27 130.72,92.25 130.73,92.24 130.73,91.62 131.43,90.92 131.43,85.07 132.19,84.31 132.19,82.19
  IN3 w0.135: v1(54.69,114.33) 54.86,114.17 54.86,113.76 53.44,112.34 51.97,112.34 49.29,109.66 46.38,109.66 44.8,108.09 44.4,108.09 43.23,106.92 43.23,106.51 41.53,104.81 36.47,104.81 35.31,103.65 35.31,102.2 36.47,101.04 36.47,96.03 29.79,89.35 29.79,88.3 28.95,87.47 28.95,84.36 28.76,84.17 28.42,84.17 v1(28.24,84.35)
  BOTTOM w0.076: 138.17,73.23 138.1,73.23 137.76,73.57 137.16,73.57 137.13,73.61 135.42,73.61 135.13,73.9 UC1.D41
  BOTTOM w0.112: 138.17,73.23 138.98,73.23 139.17,73.03 140.05,73.03 v1(140.34,72.74)
CLK_PCIE_LAN_P2: length 175.1
  TOP w0.102: UL1.15 26.68,83.26
  TOP w0.112: v1(28.24,83.76) 28.01,83.99 27.78,83.99 27.15,83.36 26.78,83.36 26.68,83.26
  IN1 w0.076: 133.64,73.03 133.64,73.45 133.33,73.77 132.55,73.77 132.11,74.21 132.11,78.17 132.28,78.35 132.28,79.86 132.43,80.01 132.43,82.03 132.39,82.12 132.39,82.19
  IN1 w0.119: 132.39,82.19 132.39,84.4 131.64,85.15 131.64,91.01 130.94,91.71 130.94,93.36 128.54,95.76 128.54,98.67 126.94,100.28 126.94,102.14 125.52,103.55 123.16,103.55 117.33,109.38 104.44,109.38 103.94,109.88 100.07,109.88 99.63,109.45 97.35,109.45 96.69,110.1 83.36,110.1 82.45,111.02 79.28,111.02 78.59,111.71 77.26,111.71 75.87,113.09 60.37,113.09 59.15,114.31 57.4,114.31 57.21,114.12 56.37,114.12 56.08,113.83 55.18,113.83 55.06,113.94 55.06,114.11 v1(55.28,114.33) ; v1(140.34,73.32) 140.25,73.24 139.67,73.24 138.48,72.04 134.63,72.04 133.64,73.03
  IN3 w0.135: v1(55.28,114.33) 55.12,114.17 55.12,114.15 55.1,114.14 55.1,113.66 53.54,112.1 52.07,112.1 49.39,109.42 46.48,109.42 44.9,107.84 44.5,107.84 43.47,106.82 43.47,106.41 41.63,104.57 36.57,104.57 35.55,103.55 35.55,102.3 36.71,101.14 36.71,95.93 30.03,89.25 30.03,88.2 29.19,87.37 29.19,84.26 28.86,83.93 28.41,83.93 v1(28.24,83.76)
  BOTTOM w0.076: 138.17,73.45 138.12,73.45 137.82,73.74 137.63,73.74 137.61,73.76 137.24,73.76 137.2,73.79 136.13,73.79 135.73,74.2 135.46,74.2 135.39,74.13 135.39,73.97 135.46,73.9 UC1.C41
  BOTTOM w0.112: v1(140.34,73.32) 140.26,73.25 139.27,73.25 139.07,73.45 138.17,73.45
CLK_PCIE_LAN_REQ#: length 138.6
  TOP w0.112: RL13.1 29.51,79.32 29.51,78.1 30.08,77.53 v1(30.49,77.53) ; RC73.2 106.88,45.97 107.32,46.41 v2(108.94,46.41) 109,46.41 109.51,46.92 v1(109.51,47.24)
  IN1 w0.119: v1(30.49,77.53) 33.21,77.53 35.05,75.69 35.05,71.67 32.57,69.19 32.57,66.32 33.42,65.47 34.61,64.28 34.9,64.28 37.03,62.15 37.69,62.15 37.86,61.98 40.48,61.98 41.05,61.41 46.03,61.41 48.56,58.89 v1(49.09,58.89)
  IN3 w0.135: v1(117.29,54.96) 117.29,54.3 116.5,53.51 115.25,53.51 114.51,52.77 112.99,52.77 110.07,49.85 110.07,49.43 110.07,49.43 110.07,49.01 109.51,48.45 v1(109.51,47.24) 109.51,46.88 108.73,46.1 108.73,45.36 105.97,42.61 105.97,41.29 105.97,40.88 103.84,38.74 103.38,38.74 103.2,38.56 103.2,38.27 102.69,37.77 102.47,37.77 102.46,37.77 101.69,37.77 101.22,37.3 99.11,37.3 98.4,38.01 94.7,38.01 94.19,37.5 91.62,37.5 90.9,38.22 88.91,38.22 87.9,37.21 85.79,37.21 85.37,36.79 82.8,36.79 82.1,36.08 75.12,36.08 74.44,36.76 71.17,36.76 70.12,37.81 61.54,37.81 59.81,39.54 59.39,39.54 57.24,41.68 56.33,41.68 52.9,45.11 52.9,48.06 52.61,48.35 52.61,50.89 51.49,52.02 51.49,53.43 49.69,55.23 49.69,57.12 49.09,57.72 v1(49.09,58.89)
  BOTTOM w0.076: UC1.AT8 117.29,54.87 v1(117.29,54.96)
CLK_PCIE_NVME_N4: length 182.3
  IN1 w0.119: v1(26.55,35.41) 26.39,35.25 26.39,35.04 26.51,34.92 26.7,34.92 27.66,33.97 30.14,33.97 30.6,33.5 33.09,33.5 34.13,32.46 39.38,32.46 40.68,31.16 45.88,31.16 48.95,34.22 56.19,34.22 62.83,27.58 66.92,27.58 67.44,27.06 69.34,27.06 71.22,25.18 99.63,25.18 100.59,26.13 113.38,26.13 114.66,27.41 120.35,27.41 120.82,27.88 130.81,27.88 132.12,29.2 136.42,29.2 139.46,32.23 142.53,32.23 144.94,34.64 144.94,37.16 145.52,37.74 146.88,37.74 150.14,41 150.14,42.75 149.81,43.07 149.81,46.97 147.91,48.87 146.95,48.87 145.76,50.07 145.76,50.49 145.36,50.89 145.36,52.17 144.72,52.8 144.72,55.42 144.18,55.96 144.18,62.22 143.91,62.49 143.91,67.68 143.45,68.14 143.45,68.75 143.09,69.11 142.2,69.11 141.07,70.25 141.07,71.26 140.82,71.51 140.45,71.51 v1(140.21,71.27)
  BOTTOM w0.076: UC1.B40 135.79,73.23 135.79,73.08 135.86,73.01 136,73.01 136.14,73.15 136.34,73.15 136.47,73.01 137.22,73.01 138,72.23 138,72.2 138.01,72.19
  BOTTOM w0.112: v1(26.55,35.41) 26.37,35.23 26.37,35.02 26.27,34.92 26.27,34.71 26.38,34.61 JSSD1.53 ; v1(140.21,71.27) 140.21,71.42 140.1,71.53 138.65,71.53 138.15,72.03 138.15,72.05 138.01,72.19
CLK_PCIE_NVME_P4: length 182.2
  IN1 w0.119: v1(140.21,72.04) 140.51,71.73 140.91,71.73 141.29,71.35 141.29,70.34 142.29,69.33 143.18,69.33 143.67,68.84 143.67,68.23 144.13,67.78 144.13,62.58 144.4,62.31 144.4,56.05 144.94,55.51 144.94,52.9 145.58,52.26 145.58,50.98 145.97,50.58 145.97,50.16 147.04,49.09 148,49.09 150.03,47.07 150.03,43.16 150.35,42.84 150.35,40.9 146.97,37.52 145.61,37.52 145.16,37.07 145.16,34.55 142.62,32.01 139.55,32.01 136.51,28.98 132.22,28.98 130.9,27.67 120.91,27.67 120.44,27.2 114.75,27.2 113.47,25.91 100.68,25.91 99.72,24.96 71.13,24.96 69.25,26.84 67.35,26.84 66.83,27.36 62.74,27.36 60.91,29.19 56.1,34 49.04,34 45.98,30.94 40.58,30.94 39.29,32.24 34.04,32.24 33,33.28 30.51,33.28 30.05,33.75 27.56,33.75 26.61,34.7 26.42,34.7 26.17,34.95 26.17,35.21 26.14,35.24 26.14,35.24 v1(25.97,35.41)
  BOTTOM w0.076: UC1.A40 136.55,73.27 136.62,73.19 137.3,73.19 138.13,72.36 138.16,72.36 138.17,72.35
  BOTTOM w0.112: v1(140.21,72.04) 139.93,71.76 138.76,71.76 v4(138.54,71.98) 138.17,72.35 ; v1(25.97,35.41) 26.15,35.23 26.15,35.11 26.05,35.01 26.05,34.81 25.87,34.64 JSSD1.55
CLK_PCIE_NVME_REQ#: length 126.3
  TOP w0.112: v1(30.4,30.91) 30.4,33.67 29.63,34.45 v2(29.63,34.6) 29.63,35.77 31.96,38.11 34.15,38.11 34.92,38.88 37.26,38.88 37.89,39.52 42.01,39.52 43.77,41.28 43.77,43.89 v1(44.24,44.37)
  IN1 w0.119: v1(107.61,43.54) 107.01,42.94 107.01,42.94 106.72,42.65 103.47,42.65 102.38,41.56 102.38,40.94 101.95,40.51 101.2,40.51 100.95,40.27 97.75,40.27 97.27,39.79 92.37,39.79 91.84,40.32 85.83,40.32 85.32,39.81 81.52,39.81 81.3,39.59 80.58,39.59 80.22,39.23 76.43,39.23 75.87,39.78 73.41,39.78 72.89,40.31 72.32,40.31 69.96,42.67 67.31,42.67 66.05,43.92 66.05,44.2 65.22,45.03 59.51,45.03 57.69,46.85 55.74,46.85 53.36,44.47 44.74,44.47 44.64,44.37 v1(44.24,44.37)
  BOTTOM w0.076: UC1.AU8 116.75,54.48 116.29,54.03 113.61,54.03 113.53,53.95 111.65,53.95 110.71,53.01 110.32,53.01 110.15,52.83 110.15,52.54 109.87,52.26 108.33,52.26 107.46,51.39 107.46,51.31
  BOTTOM w0.112: RC188.2 105.41,40.15 107.63,42.38 107.63,43.52 v1(107.61,43.54) 107.63,43.56 107.63,44.36 106.91,45.08 106.85,45.08 106.56,45.37 106.56,46.29 107.53,47.25 107.53,48.09 107.74,48.3 107.74,48.86 107.46,49.13 107.46,51.31 ; v1(30.4,30.91) 30.04,30.54 29.92,30.54 29.91,30.54 29.59,30.54 29.59,30.54 28.76,30.54 26.63,28.4 JSSD1.52
CLK_PCIE_PEG_REQ#: length 94.3
  TOP w0.089: 116.97,55.48 v1(117.34,55.85)
  TOP w0.102: 116.97,55.48 116.33,55.48 116.1,55.71 115.14,55.71 114.41,54.99 114.41,53.98 113.95,53.53 110.17,53.53 110.07,53.62 106.66,53.62
  TOP w0.112: RC71.2 106.01,53.33 106.36,53.33 106.66,53.62
  IN1 w0.076: 125.36,92.24 125,91.88 125,91.13 122.89,89.02 122.19,89.02 121.22,88.05 121.22,85.39 120.79,84.95 120.79,75.12 120.33,74.66 118.62,74.66 117.79,73.83 117.79,73 117.48,72.69 116.4,72.69 114.24,70.53 114.24,57.19 114.87,56.56 116.44,56.56 117.14,55.85 v1(117.34,55.85)
  IN1 w0.119: 125.36,92.24 125.64,92.51 125.64,94.24 125.09,94.78 125.09,101.79 v1(125.15,101.84)
  IN3 w0.135: v1(131.23,108.14) 131.23,109.69 130.79,110.12 130.79,111.24 129.19,112.83 129.19,114 128.88,114.31 v1(126.2,114.31)
  BOTTOM w0.076: UC1.AR10 118.19,55.4 117.74,55.85 v1(117.34,55.85)
  BOTTOM w0.112: v1(125.15,101.84) v2(130.37,107.06) 131.23,107.92 v1(131.23,108.14) ; v1(126.2,114.32) 126.2,115.16 124.42,116.94 124.42,118 RV153.1
CLK_PCIE_WLAN_N1: length 128.3
  IN1 w0.119: v1(147.65,81.82) 147.53,81.95 147.22,81.95 146.89,82.27 146.89,83.92 146.19,84.62 146.19,86.91 145.41,87.7 145.41,91.43 144.1,92.74 142,92.74 141.43,93.31 140.75,93.31 138.13,95.93 136.77,95.93 133.37,99.33 133.37,101.67 133.28,101.75 133.28,102.06 124.62,110.73 124.62,110.93 124.62,111.26 121.71,114.17 109.9,114.17 109.44,114.63 95.46,114.63 94.99,114.16 85.92,114.16 85.17,114.91 83.86,114.91 82.74,116.03 81.94,116.03 81.14,116.83 80.03,116.83 78.89,117.96 75.55,117.96 75.38,118.13 v1(75.38,118.68)
  BOTTOM w0.094: 138.17,73.98 138.16,73.98 138.15,73.99 136.31,73.99 136.07,74.23 136.07,74.29 UC1.B42
  BOTTOM w0.112: 138.17,73.98 138.46,73.98 139.96,75.48 140.65,75.48 141.83,76.66 141.83,77.84 144.1,80.11 144.47,80.11 146.18,81.82 v4(146.63,81.82) v1(147.65,81.82) ; v1(75.38,118.68) 75.38,121.83 74.57,122.64 74.57,127.11 75.07,127.62 75.07,131.5 76.18,132.6 78.29,132.6 78.33,132.65 JWLAN1.49
CLK_PCIE_WLAN_P1: length 128.3
  IN1 w0.119: v1(75.96,118.68) 75.96,118.65 75.62,118.3 75.62,118.21 75.64,118.18 78.98,118.18 80.12,117.04 81.23,117.04 82.03,116.25 82.83,116.25 83.95,115.13 85.26,115.13 86.01,114.38 94.9,114.38 95.37,114.85 109.53,114.85 109.99,114.38 121.8,114.38 124.84,111.35 124.84,110.82 133.5,102.15 133.5,101.84 133.59,101.76 133.59,99.43 136.87,96.15 138.22,96.15 140.84,93.53 141.52,93.53 142.09,92.96 144.19,92.96 145.63,91.52 145.63,87.79 146.41,87 146.41,84.71 147.11,84.01 147.11,82.36 147.28,82.2 147.45,82.2 v1(147.65,82.4)
  BOTTOM w0.094: UC1.A42 136.32,74.47 136.27,74.42 136.27,74.29 136.39,74.18 136.74,74.18 136.86,74.29 137.02,74.29 137.14,74.18 138.08,74.18 138.11,74.21 138.17,74.21
  BOTTOM w0.112: JWLAN1.47 78.36,132.15 78.12,132.38 76.27,132.38 75.29,131.4 75.29,127.53 74.79,127.02 74.79,122.74 75.6,121.92 75.6,119.04 75.96,118.68 v1(75.96,118.68) ; 138.17,74.21 138.37,74.21 139.86,75.7 140.56,75.7 141.61,76.75 141.61,77.93 144.01,80.33 144.38,80.33 146.11,82.05 147.05,82.05 147.15,82.15 147.15,82.34 147.26,82.46 147.6,82.46 v1(147.65,82.4)
CLK_PCIE_WLAN_REQ#: length 19.8
  TOP w0.112: v1(109.02,47.67) 109.02,47.08 108.78,46.85 107.84,46.85 107.72,46.96 v2(107.32,46.96) 107.05,46.96 106.83,46.74 RC72.2
  BOTTOM w0.076: UC1.AT7 117.4,53.85 116.6,53.85 116.47,53.72 116.47,53.06 116.31,52.9 115.8,52.9 115.76,52.94 115.18,52.94 115.12,52.88 114.5,52.88 114.48,52.86 113.6,52.86 113.51,52.76
  BOTTOM w0.102: 111.75,51.67 112.84,52.76 113.51,52.76
  BOTTOM w0.112: v1(109.02,47.67) 109.02,48.05 108.78,48.28 108.41,48.28 108.15,48.54 108.15,49.04 107.91,49.28 107.91,51 108.43,51.52 109.66,51.52 110.05,51.13 RW9.1 110.37,50.94 110.6,51.16 111.24,51.16 111.75,51.67
CLK_PCIE_WLAN_REQ#_R: length 171.7
  IN1 w0.119: v1(108.52,50.94) 107.64,51.81 106.51,51.81 105.6,52.73 103.71,52.73 103.54,52.55 102.8,52.55 100.93,50.69 100.93,47.79 98.88,45.73 96.27,45.73 96.1,45.56 95.75,45.22 95.14,44.6 83.35,44.6 82.34,43.59 72.2,43.59 70.17,45.63 69.49,45.63 68.51,46.61 67.02,46.61 65.52,48.11 59.52,48.11 58.42,49.22 58.42,56.86 57.07,58.21 56.24,58.21 54.26,60.19 54.26,61.34 55.79,62.87 55.79,65.89 53.64,68.05 53.64,70.04 54.13,70.54 54.13,76.05 52.96,77.22 52.34,77.22 52.18,77.38 52.18,82.74 54.62,85.19 54.62,108.88 58.08,112.35 v1(58.08,112.95)
  BOTTOM w0.076: v1(108.52,50.94) RW9.2
  BOTTOM w0.112: v1(58.08,112.95) 58.32,113.19 59.64,113.19 59.68,113.16 60.08,113.16 60.12,113.19 72.18,113.19 74.57,115.58 74.57,117.28 74.13,117.72 74.13,118.06 74.61,118.54 74.61,121.63 72.93,123.3 72.93,126.38 74.56,128.02 74.56,128.03 74.58,128.05 74.58,132.42 75.81,133.65 JWLAN1.53
CLK_PEG_VGA: length 112.3
  IN3 w0.135: v1(113.15,145.02) 113.17,145 113.17,143.84 113.73,143.29 113.73,140.34 113.01,139.63 113.01,138.02 112.03,137.04 111.44,137.04 111.05,136.65 111.05,134.72 111.41,134.35 111.41,132.56 112.05,131.92 112.05,124.27 113.84,122.47 116.87,122.47 117.39,122.99 118.22,122.99 119.4,121.82 122.58,121.82 122.93,122.17 123.81,122.17 125.27,123.63 127.79,123.63 130.12,121.29 130.72,121.29 133.23,118.79 133.53,118.48 135.33,118.48 135.95,117.86 135.95,116.39 137.96,114.39 137.96,112.06 139.09,110.93 140.36,110.93 140.66,110.63 145.45,105.84 145.45,96.35 147.21,94.59 147.21,92.46 149.63,90.04 149.63,87.97 148.22,86.56 148.22,84.27 147.79,83.84 v1(147.56,83.84)
  BOTTOM w0.076: 138.01,74.84 138.01,74.84 138.01,74.81 137.97,74.77 137.97,74.74 137.85,74.63 137.09,74.63 136.83,74.89 136.69,74.89 136.53,74.89 136.3,74.89 136.26,74.84 136.18,74.84 136.14,74.89 135.68,74.89 135.62,74.86 135.61,74.85 135.3,74.76 135.25,74.76 135.23,74.77 135.18,74.76 UC1.D42
  BOTTOM w0.102: UV1.AK30 113.3,143.84 113.3,144.25 113.29,144.25 113.29,144.69 113.29,144.69 113.29,144.76 113.29,144.76 113.29,144.78
  BOTTOM w0.112: 138.01,74.84 139.54,76.37 140.21,76.37 140.84,77 140.84,78.11 143.71,80.98 144.1,80.98 146.92,83.8 147.52,83.8 v1(147.56,83.84) ; v1(113.15,145.02) 113.29,144.88 113.29,144.78
CLK_PEG_VGA#: length 112.3
  IN3 w0.135: v1(147.56,83.07) 147.91,83.07 148.04,83.21 148.04,83.74 148.46,84.17 148.46,86.46 149.87,87.87 149.87,90.14 147.45,92.56 147.45,94.69 145.69,96.45 145.69,105.94 140.9,110.73 140.9,110.73 140.46,111.17 139.19,111.17 138.2,112.16 138.2,114.49 136.19,116.49 136.19,117.96 135.43,118.72 133.63,118.72 133.33,119.03 130.82,121.53 130.22,121.53 127.89,123.87 125.17,123.87 123.71,122.41 122.83,122.41 122.48,122.06 119.5,122.06 118.32,123.24 117.29,123.24 116.77,122.72 113.94,122.72 112.29,124.37 112.29,132.02 111.65,132.66 111.65,134.45 111.29,134.82 111.29,136.55 111.54,136.8 112.13,136.8 113.25,137.92 113.25,139.53 113.97,140.24 113.97,143.39 113.41,143.94 113.41,144.69 113.74,145.02 v1(113.74,145.02)
  BOTTOM w0.076: 138.17,74.69 137.95,74.47 136.95,74.47 136.7,74.72 136.4,74.72 136.31,74.64 136.13,74.64 136.05,74.72 135.72,74.72 135.7,74.7 135.32,74.6 135.25,74.52 UC1.C42
  BOTTOM w0.102: 113.51,144.78 113.5,144.78 113.5,144.34 113.64,144.2 UV1.AK32
  BOTTOM w0.112: v1(147.56,83.07) 147.56,83.25 147.23,83.58 147.01,83.58 144.19,80.75 143.8,80.75 141.07,78.02 141.07,76.91 140.3,76.15 139.63,76.15 138.17,74.69 ; v1(113.74,145.02) 113.51,144.79 113.51,144.78
CLK_SMB: length 3.5
  TOP w0.112: v2(160.56,42.15) 161.58,42.15 PR42.1 161.68,41.7 v1(161.34,41.36)
  BOTTOM w0.112: v1(161.34,41.36) 161.01,41.03 PBATT1.7
CLK_TP_SIO: length 158.9
  TOP w0.112: R32.2 C27.1 115.69,25.2 v2(115.67,25.18) 115.06,25.18 114.93,25.31 v1(114.93,25.75) ; v1(44.75,82.09) 44.62,82.09 44.51,82.2 44.51,82.56 44.55,82.6 UE1.78
  IN1 w0.119: v1(44.75,82.09) 44.36,82.49 36,82.49 35.72,82.76 v1(35.72,82.98)
  BOTTOM w0.112: JTP1.1 125.05,29.8 124.73,29.48 124.73,28.12 123.57,26.96 118.41,26.96 116.77,25.32 115.36,25.32 v1(114.93,25.75) 114.91,25.77 114.91,25.82 114.78,25.94 113.98,25.94 113.39,25.36 99.87,25.36 99.28,24.76 76.8,24.76 70.61,30.96 66.14,30.96 65.22,31.87 57.19,31.87 55.43,33.64 54.94,33.64 53.77,34.81 47.52,34.81 42.76,39.57 42.76,41.27 41.52,42.52 39.82,42.52 36.77,45.56 36.77,49.74 37.22,50.2 37.22,51.08 36.44,51.86 36.44,55.78 34.48,57.74 34.48,60.43 34.01,60.9 34.01,62.45 32.35,64.11 32.35,65.13 33.05,65.83 33.05,69.64 34.91,71.49 34.91,78.92 34.5,79.32 34.5,82.81 34.89,83.2 35.25,83.2 35.47,82.98 v1(35.72,82.98)
CMP_VIN0: length 28.7
  TOP w0.089: v2(36.34,88.92) 36.76,88.5 37.33,88.5 37.83,88 RE52.1 38.31,88.41 38.55,88.41 38.81,88.67 RE37.1 39.34,88.81 v1(39.57,89.05)
  TOP w0.102: v1(44.62,69.13) 44.62,68.88 44.95,68.55 UE1.20
  IN2 w0.102: v1(44.62,69.13) 45.02,69.53 45.02,71.81 44.31,72.51 44.31,74.51 39.62,79.2 39.62,83.02 39.04,83.6 39.04,87.2 38.72,87.51 38.72,88.2 v1(39.57,89.05)
CMP_VOUT0: length 23.2
  TOP w0.102: RE52.2 37.9,87.09 RE49.2 v1(39.42,87.09) ; v1(41.73,84.7) 41.74,84.7 41.75,84.68 UE1.85
  IN1 w0.089: v1(41.73,84.7) 41.36,85.07 41.36,85.15 v1(39.42,87.09)
  IN3 w0.102: v1(28.56,83.14) 29.05,83.14 29.73,83.82 29.73,87.19 30.13,87.6 31.76,87.6 32.98,86.38 36.62,86.38 37.33,87.09 v1(39.42,87.09)
  BOTTOM w0.102: PR507.1 27.43,83.05 v2(28.05,83.05) 28.47,83.05 v1(28.56,83.14)
COMP_1A_CPU: length 3.6
  BOTTOM w0.203: PCZ30.1 172.61,60.35 v2(172.86,60.11) 173.63,59.33 PUZ01.26
  BOTTOM w0.254: PCZ31.1 172.61,62.08 PCZ30.1
COMP_1B_CPU: length 4.7
  TOP w0.089: v2(181.71,57.72) 181.43,57.72 PCZ03.1
  TOP w0.254: PCZ03.1 PCZ01.1 180.1,55.51 v1(179.76,55.51)
  BOTTOM w0.203: PUZ01.43 179.58,55.7 v1(179.76,55.51)
COMP_2PH_CPU: length 5.7
  TOP w0.089: v2(177.9,48.36) 177.68,48.57 177.34,48.57 177.05,48.87 177.05,49.72 PCZ16.2
  TOP w0.254: v1(177.01,51.65) 177.01,51.57 PCZ15.2 177.52,51.06 PCZ16.2
  BOTTOM w0.203: v1(177.01,51.65) 177.01,51.84 176.43,52.42 PUZ01.4
COMP_CHG: length 2.5
  BOTTOM w0.203: PUB01.28 207.29,46.09 207.36,46.02 208.06,46.02 208.19,46.15 PCB39.1
  BOTTOM w0.254: PRB30.1 208.2,46.16 PCB39.1
CPU_DP1_CTRL_CLK: length 182.9
  IN1 w0.114: 134.88,52.73 134.88,54.21 134.51,54.57 132.59,54.57 132.47,54.68 132.47,56 131.77,56.7 131.77,57.03 131.52,57.29 131.11,57.29 130.88,57.51 v1(130.88,57.65)
  IN1 w0.119: v1(27.56,85.66) 27.76,85.47 27.76,84.92 27.55,84.72 27.55,82.88 28.32,82.12 28.32,78.49 27.77,77.94 27.77,76.26 26.29,74.79 26.29,62.69 29.15,59.83 31.48,59.83 32.51,58.81 32.51,57.34 31.12,55.96 31.12,54.53 32.76,52.89 33.93,52.89 35.96,50.86 35.96,47.08 40.32,42.71 41.35,42.71 42.67,41.39 44.38,41.39 45.53,42.54 54.1,42.54 54.3,42.74 56.11,42.74 56.41,42.45 57.53,42.45 57.53,42.45 60.04,42.45 60.05,42.45 60.09,42.45 63.1,39.44 69.74,39.44 71.82,37.36 75.07,37.36 76.13,36.3 81.43,36.3 81.59,36.46 85.97,36.46 87.57,38.06 89.99,38.06 91.46,36.59 91.55,36.59 92.32,35.82 96.84,35.82 97.98,34.68 100.9,34.68 101.17,34.95 106.01,34.95 107.77,36.71 116.74,36.71 117.5,35.96 121.21,35.96 121.8,36.56 123.05,36.56 123.75,35.87 124.64,35.87 124.85,36.07 128.2,36.07 131.34,39.21 131.34,39.59 131.6,39.85 131.6,40.12 v1(131.77,40.29) 131.59,40.48 131.59,42.06 131.73,42.21 131.73,45.86 132.45,46.58 132.45,50.99 133.1,51.65 133.1,52 133.28,52.17 134.33,52.17 134.88,52.72 134.88,52.73
  BOTTOM w0.076: v1(130.88,57.65) 130.89,57.65 130.57,57.32 UC1.L13
  BOTTOM w0.112: RC1.1 131.62,39.81 131.62,40.14 v1(131.77,40.29) ; QI2.1 26.42,88.04 26.81,88.43 26.97,88.43 27.15,88.25 27.15,87.8 28.01,86.93 28.01,86.45 27.74,86.18 27.74,85.83 v1(27.56,85.66)
CPU_DP1_CTRL_DATA: length 182
  IN1 w0.114: v1(131.05,56.76) 131.05,56.97 131.16,57.08 131.43,57.08 131.57,56.95 131.57,56.62 132.27,55.91 132.27,54.6 132.5,54.37 134.43,54.37 134.67,54.12 134.67,52.82 134.45,52.59
  IN1 w0.119: v1(28.15,85.66) 28,85.52 28,84.82 27.8,84.62 27.8,82.99 28.56,82.22 28.56,78.38 28.02,77.84 28.02,76.16 26.54,74.68 26.54,62.79 29.25,60.08 31.59,60.08 32.75,58.91 32.75,57.24 31.37,55.86 31.37,54.63 32.86,53.14 34.03,53.14 36.2,50.96 36.2,47.18 40.42,42.96 41.45,42.96 42.77,41.64 44.28,41.64 45.43,42.79 54,42.79 54.2,42.99 56.22,42.99 56.51,42.7 57.48,42.7 57.48,42.7 60.07,42.7 60.07,42.7 60.19,42.7 63.2,39.68 69.85,39.68 71.92,37.61 75.18,37.61 76.23,36.55 81.33,36.55 81.48,36.71 85.87,36.71 87.47,38.31 90.09,38.31 91.56,36.84 91.65,36.84 92.42,36.07 96.94,36.07 98.09,34.93 100.8,34.93 101.07,35.2 105.91,35.2 107.67,36.96 116.85,36.96 117.6,36.21 121.1,36.21 121.7,36.81 123.16,36.81 123.85,36.11 124.54,36.11 124.75,36.32 128.09,36.32 131.09,39.32 131.09,39.69 131.36,39.95 131.36,40.12 v1(131.19,40.29) 131.34,40.45 131.34,42.16 131.49,42.31 131.49,45.96 132.2,46.68 132.2,48.64 132.24,48.68 132.24,51.08 132.9,51.73 132.9,52.08 133.19,52.38 134.24,52.38 134.45,52.59
  BOTTOM w0.076: v1(131.05,56.76) 130.71,56.76 UC1.L12
  BOTTOM w0.112: v1(131.19,40.29) 131.38,40.09 131.38,39.81 RC2.1 ; v1(28.15,85.66) 27.97,85.83 27.97,86.08 28.25,86.36 28.25,87.03 27.39,87.89 27.39,88.35 27.16,88.58 27.16,88.85 27.65,89.34 QI2.4
CPU_DP1_HPD: length 203.4
  TOP w0.089: v1(30.02,114.15) 29.86,114.31 RI15.2 28.67,114.31 QI3.3 27.08,114.72 26.58,115.22 v2(25.33,115.22)
  IN2 w0.089: v1(30.02,114.15) 29.81,114.15 29.59,113.93 29.59,113.46 30.3,112.75 30.3,110.58 30.82,110.06 39.28,110.06 40.3,109.04 40.3,104.25 40.52,104.03 40.52,99.42 39.63,98.53 39.63,93.89 40.57,92.95 41.01,92.95 41.45,92.51 41.45,89.73 44.04,87.14 44.04,84.4 44.24,84.2 44.24,82.71 43.48,81.94 43.48,80.87 44.24,80.11 44.24,78.53 44.61,78.16 44.61,75.87 47.27,73.22 47.27,70.45 48.39,69.33 48.39,68.97 49.52,67.84 49.87,67.84 50.55,67.17 50.55,64.46 49.99,63.9 49.99,58.77 49.59,58.37 49.59,57.64 50.03,57.19 50.03,52.4 49.86,52.23 49.86,47.83 51.08,46.6 51.08,42.43 54.33,39.19 57.49,39.19 62.1,34.58 68.24,34.58 68.91,35.25 69.46,35.25 69.92,34.79 71.63,34.79 72.21,34.21 75.7,34.21 76.16,34.66 81.76,34.66 83.57,36.47 84.49,36.47 85.13,37.12 87.23,37.12 87.47,37.35 90.63,37.35 91.79,36.18 95.18,36.18 95.88,36.88 96.78,36.88 97.03,37.13 98.26,37.13 98.41,36.98 99.36,36.98 101.47,34.87 106.23,34.87 106.97,35.62 109.73,35.62 110.35,36.24 114.54,36.24 115.01,36.72 120.83,36.72 121.87,37.75 122.44,37.75 122.87,38.19 123.95,38.19 124.6,38.19 124.95,37.83 124.95,37.41 125.31,37.05 128.36,37.05 128.78,37.47 129.73,37.47 130.78,38.53 131.1,38.53 132.25,39.68 132.25,40.65 v1(132.14,40.76)
  IN3 w0.135: v1(132.14,40.76) 132.58,41.2 132.58,41.93 133.33,42.69 133.33,45.52 134.08,46.26 134.11,46.26 134.34,46.5 134.34,46.52 134.35,46.53 134.35,50.07 133.11,51.31 133.11,51.47 132.4,52.18 v1(132.42,52.18)
  BOTTOM w0.076: 131.81,52.36 131.8,52.37 131.16,52.37 131.07,52.41 130.88,52.6 130.88,54.31 130.57,54.62 UC1.L9
  BOTTOM w0.102: 131.81,52.36 132.21,52.36 132.4,52.18 v1(132.42,52.18)
CPU_DP2_AUXN: length 142.5
  TOP w0.112: RT103.1 30.22,111.7 30.22,111.31 30.53,111 30.88,111 30.96,110.91 v1(30.96,110.81) 31.2,110.81 31.36,110.65 31.36,110.31 31.71,109.96 31.71,109.71 CT68.2
  IN1 w0.076: v1(134.14,77.86) 134.06,77.93 133.98,77.92 133.86,77.77 133.88,77.49 134.02,77.36 134.26,77.36 134.88,77.99 135.56,77.99 ; 134.37,92.08 134.38,92.07 134.4,92.07
  IN1 w0.119: v1(30.96,110.81) 31.33,110.81 31.41,110.73 31.9,110.73 32.37,111.19 33.9,111.19 34.05,111.35 35.71,111.35 36.75,110.3 43.97,110.3 47.17,113.5 52.53,113.5 53.84,114.81 59.36,114.81 60.57,113.6 76.08,113.6 77.38,112.29 78.81,112.29 79.58,111.52 82.66,111.52 83.27,110.9 83.83,110.9 84.05,110.67 84.12,110.6 95.94,110.6 96.36,111.03 104.52,111.03 105.01,110.53 107.72,110.53 108.06,110.87 115.58,110.87 115.93,110.53 117.81,110.53 120.73,107.61 122.13,107.61 124.76,104.99 125.87,104.99 128.4,102.45 128.4,100.42 129.73,99.1 129.73,96.98 131.12,95.58 131.12,95.33 133.91,92.54 134.37,92.08 ; 134.4,92.07 137.72,88.75 137.72,86.25 138.6,85.37 138.6,81.03 135.56,77.99
  BOTTOM w0.076: v1(134.14,77.86) 133.82,77.55 UC1.E48
CPU_DP2_AUXN_C: length 2.7
  TOP w0.112: UT5.25 33.91,107.77 33.85,107.84 33.61,107.84 v4(33.15,108.3) 32.56,108.88 CT68.1
CPU_DP2_AUXP: length 142.5
  TOP w0.112: RT102.1 30.44,111.69 30.44,111.4 30.62,111.22 v1(31.38,111.22) 31.38,110.94 31.58,110.74 31.58,110.4 31.79,110.2 CT67.2
  IN1 w0.076: v1(133.5,77.8) 133.69,77.64 133.72,77.42 133.72,77.41 133.96,77.2 134.33,77.2 134.95,77.82 135.46,77.82 135.48,77.8 135.63,77.8 135.67,77.83 135.7,77.83 135.7,77.84 ; 134.52,92.24 134.54,92.23
  IN1 w0.119: 135.7,77.84 138.81,80.94 138.81,85.45 137.93,86.34 137.93,88.86 137.9,88.86 134.54,92.23 ; 134.52,92.24 131.34,95.42 131.34,95.68 129.94,97.07 129.94,99.19 128.62,100.52 128.62,102.54 125.96,105.2 124.85,105.2 122.23,107.83 120.82,107.83 117.9,110.74 116.02,110.74 115.67,111.09 107.97,111.09 107.63,110.75 105.11,110.75 104.61,111.25 96.27,111.25 95.85,110.82 84.21,110.82 83.92,111.12 83.36,111.12 82.75,111.74 79.67,111.74 78.9,112.51 77.48,112.51 76.17,113.81 60.66,113.81 59.45,115.03 53.75,115.03 52.44,113.72 47.08,113.72 43.88,110.52 36.84,110.52 35.8,111.56 33.96,111.56 33.81,111.41 32.28,111.41 31.81,110.95 31.64,110.95 v1(31.38,111.22)
  BOTTOM w0.076: UC1.F48 133.5,77.67 v1(133.5,77.8)
CPU_DP2_AUXP_C: length 2.6
  TOP w0.112: CT67.1 32.81,108.96 33.09,108.67 33.11,108.67 33.54,108.24 33.54,108.22 33.7,108.06 33.83,108.06 33.94,108.17 UT5.24
CPU_DP2_CTRL_DATA: length 38.4
  TOP w0.089: RC212.1 v2(140.56,34.98) 140.18,35.36 136.27,35.36 136.03,35.59 133.05,35.59 131.23,37.41 129.98,37.41 129.18,38.21 129.18,39.31 128.6,39.89 127.83,39.89 127.72,40 125.92,40 v1(125.57,39.66)
  IN3 w0.076: v1(128.96,54.3) 128.96,54 129.43,53.53 129.43,52.6 129.15,52.32 129.15,48.69 129.15,48.68
  IN3 w0.089: 129.15,48.68 128.91,48.45 128.91,45.51 129.14,45.29 129.14,42.23 128.51,41.61 127.94,41.61 127.4,41.07 126.5,41.07 125.57,40.14 v1(125.57,39.66)
  BOTTOM w0.076: UC1.N8 129.39,54.26 129,54.26 v1(128.96,54.3)
CPU_DP2_HPD: length 204.4
  TOP w0.089: v1(130.07,52.31) 130.07,52.76 129.68,53.14 RC5.2
  TOP w0.102: UT5.3 41.94,111.12 v1(41.82,111.24)
  IN1 w0.089: v1(130.07,52.31) 129.89,52.13 129.89,48.52 129.75,48.39 129.75,46.98 128.77,45.99 128.77,42.65 128.18,42.06 v1(128.18,41.23) ; v1(32.84,111.97) 33.35,112.49 40.85,112.49 41.82,111.52 v1(41.82,111.24)
  IN2 w0.089: v1(128.18,41.23) 125.17,41.23 123.84,39.9 122.67,39.9 122.14,39.38 121.36,39.38 120.64,40.09 119.46,40.09 119.35,39.98 118.88,39.98 118.71,39.81 117.69,39.81 115.37,37.49 115.01,37.49 114.31,36.79 107.63,36.79 106.08,35.24 101.62,35.24 99.51,37.35 98.56,37.35 98.41,37.5 96.88,37.5 96.63,37.24 95.73,37.24 95.03,36.55 91.95,36.55 90.78,37.72 87.32,37.72 87.08,37.48 84.98,37.48 84.34,36.84 83.42,36.84 81.61,35.03 76.01,35.03 75.76,34.78 75.55,34.57 72.36,34.57 71.75,35.18 70.05,35.18 69.62,35.61 68.76,35.61 68.1,34.95 62.24,34.95 57.65,39.55 54.58,39.55 51.45,42.69 51.45,46.75 50.22,47.98 50.22,52.08 50.97,52.82 50.97,55.85 50.51,56.3 50.51,57.33 49.95,57.89 49.95,58.22 50.36,58.62 50.36,63.73 50.93,64.3 50.93,67.32 50.04,68.21 49.67,68.21 48.75,69.13 48.75,72.36 46.45,74.66 46.45,76.15 45.53,77.07 45.53,83.18 44.22,84.49 44.22,87.23 41.65,89.81 41.65,92.62 41.12,93.15 40.66,93.15 39.84,93.98 39.84,98.47 42.68,101.31 42.68,110.66 42.1,111.24 v1(41.82,111.24)
  BOTTOM w0.076: v1(130.07,52.31) 130.07,52.66 130.57,53.16 UC1.L7
  BOTTOM w0.089: v1(32.84,111.97) 33.04,112.17 33.04,115.13 31.71,116.47 v2(30.54,116.47) 30.05,116.47 28.24,114.66 23.21,114.66 RT114.2
