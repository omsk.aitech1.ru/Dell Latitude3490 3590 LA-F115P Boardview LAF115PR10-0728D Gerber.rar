# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VS_CAM: length 2.2
  TOP w0.127: C15.1 210.65,44.06 v2(210.65,43.35)
  vias: v1(213.41,46.65) v1(214.02,46.66)
+3VS_SSD: length 7.7
  TOP w0.089: v1(29.93,25.2) 30.31,25.59 v3(30.31,25.99)
  BOTTOM w0.508: 23.69,30.42 23.41,30.7 23.41,32.63 24.74,33.96 RS2.2
  vias: v1(23.83,26.67) v1(23.83,26.08) v1(24.46,26.67) v1(24.46,26.08) v1(29.35,25.2) v3(27.01,29.07) v3(28.1,24.93)
+5V_AVDD: length 18.1
  TOP w0.127: v2(32.13,22.18) 31.77,21.83 31.77,20.47 31.47,20.16 CA49.1
  TOP w0.203: 22.94,15.05 UA1.26
  TOP w0.381: 22.94,15.05 22.18,15.81 CA10.1
  TOP w0.508: CA10.1 21.85,15.81 21.33,16.32 21.33,16.45 20.85,16.94 CA11.1 v1(20.53,17.66)
  IN2 w0.508: v1(30.22,19.88) 30.22,19.88 27.59,17.25 20.95,17.25 v1(20.53,17.66)
+5V_CONN_P1: length 26.3
  TOP w0.508: v1(41.04,122.55) 41.04,120.63 38.52,118.11 37.18,118.11 v2(35.76,116.69) 35.46,116.39 34.63,116.39 v1(33.78,117.24)
  BOTTOM w0.254: CT78.1 40.93,121.6 40.48,122.05 UT1.8
  BOTTOM w0.356: CT78.1 41.21,122.39 v1(41.04,122.55)
  BOTTOM w0.508: CT3.1 33.13,117.89 v1(33.78,117.24) ; CT2.1 39.53,131.23 39.53,129.74 40.38,128.89 UT6.3 41.74,126.99 41.74,124.19 41.04,123.49 v1(41.04,122.55)
+5V_HDD:
  vias: v1(184.79,36.6) v1(185.38,36.6) v3(182.3,36.66) v3(184.06,36.2) v3(186.01,36.28)
+5V_HDMI:
  vias: v1(14.7,100.96) v1(14.7,100.33) v1(14.7,99.69) v2(16.09,98.61)
+5V_KB_BL: length 52.3
  IN2 w0.508: v1(50.3,40.6) 53.35,37.55 56.89,37.55 61.49,32.95 68.36,32.95 68.95,32.36 71.27,32.36 71.65,31.98 73.8,31.98 74.2,32.39 79.33,32.39 80.19,31.52 81.21,31.52 82.38,32.69 83.15,32.69 84.74,34.28 86.83,34.28 87.39,33.73 94.49,33.73 v1(94.59,33.82)
  BOTTOM w0.381: C51.1 95.05,35.44 JKBBL1.1 95.05,34.28 v1(94.59,33.82)
  vias: v3(49.67,40.37)
+5V_PVDD: length 6.7
  TOP w0.127: v1(30.84,2.12) 31.33,2.12 v2(31.71,1.74)
  IN2 w1.016: 30.54,4.83 30.54,5.65 29.45,6.74 27.36,6.74 26.48,7.63
  vias: v1(26.02,9.15) v1(26.02,8.57) v1(30.26,2.12) v1(30.26,1.48) v1(30.84,1.48)
+5VALW: length 383.9
  TOP w0.127: v1(23.11,38.93) v3(22.13,38.93) ; v1(156.4,93.7) 155.41,93.7 v3(155.14,93.98)
  TOP w0.178: PUV01.26 77.34,129.9 77.67,129.57 78.09,129.57 78.48,129.96 78.48,130.13 78.71,130.36 78.71,130.42
  TOP w0.203: UZ3.4 v1(37.09,58.03) ; v1(76.17,133.24) 75.98,133.04 PUV01.31
  TOP w0.254: UU2.4 34.03,46.37 v1(34.58,45.82) ; CZ40.1 80.62,111.77 80.62,112.43 80.75,112.57 UZ7.4
  TOP w0.305: CZ5.1 156.89,30.58 v1(156.89,30.64) 156.89,30.73 156.6,31.02 UZ2.3
  TOP w0.381: PRG02.1 157.13,94.51 PCG11.1 156.67,93.98 v1(156.4,93.7)
  TOP w0.508: PCI11.1 160.57,68.3 v1(160.57,68.3) ; Q20.3 51.77,34.35 52.52,33.6 52.52,32.84 52,32.32 v1(51.95,32.32) ; PCA08.1 166.56,58.31 v1(167.11,58.31) ; PRZ39.1 v1(172.79,46.73) ; v1(79.93,112.9) 79.93,111.77 80.12,111.58 CZ40.1 ; v1(164.79,89.02) 164.79,88.3 PCI31.1 165.45,88.12 165.91,87.66 167.2,87.66 v1(167.45,87.91) ; PRI02.1 v1(160.18,69.11) ; v1(145.77,111.69) 145.22,111.69 144.82,111.29 PRW11.1 ; Q19.3 51.06,99.43 51.56,98.92 51.56,96.04 v1(51.45,95.93) 50.95,95.43 Q18.3 ; 78.71,130.42 79.35,131.06 PRV13.1 79.66,131 PCV12.1 80.74,131.42 81.12,131.8 82.6,131.8 83.54,130.86 v1(83.54,129.73)
  TOP w0.762: v1(176.12,45.95) 176.51,45.56 176.51,44.31 176.15,43.95 176.15,42.24 177.26,41.13 179.22,41.13 179.37,40.98 180.5,40.98
  TOP w2.032: 198.18,37.51 198.18,38.02 193.94,42.26 193.94,45.3 191.97,47.26 191.97,55.25 190.85,56.37 187.38,56.37 186.19,57.56 186.19,59.1
  IN1 w0.508: v1(34.65,24.62) 34.13,24.62 31.38,27.36 v1(31.38,27.81) ; v1(76.17,133.24) 77.12,132.29 79.07,132.29 79.54,131.82 82.65,131.82 83.54,130.93 v1(83.54,129.73) ; v1(48.83,95.93) v1(51.45,95.93)
  IN1 w0.762: v1(176.12,45.95) 175.11,44.93 173.32,44.93 172.79,45.47 v1(172.79,46.73) 172.72,46.8 172.72,49.3 172.03,49.98 172.03,51.34 171.39,51.98 170.09,51.98 ; 169.27,52.29 169.27,52.75 167.11,54.92 v1(167.11,58.31) 166.24,58.31 165.93,58.62 165.93,59.08 164.09,60.92 160.45,60.92 159.52,61.84 159.52,66.8 159.53,66.81
  IN1 w1.524: 24.62,40.2 25.4,40.98 26.92,40.98 30.54,44.6
  IN2 w0.508: v1(197.56,32.63) 197.56,33.28 195.96,34.88 193.31,34.88 191.78,33.35 188.52,33.35 188.09,33.77 182.42,33.77 182.23,33.97 179.65,33.97 177.41,31.73 177.22,31.73 176.79,31.3 176.79,30.84 176.51,30.56 169.48,30.56 168.93,31.11 167.5,31.11 167.46,31.07 164.89,31.07 v1(164.31,30.48) 157.05,30.48 v1(156.89,30.64) ; v1(43.7,59.08) 43.7,57.46 42.78,56.54 42.78,45.89 42.3,45.42 42.3,43.55 44.03,41.82 44.03,40.54 47.94,36.63 47.94,32.14 48.45,31.63 51.27,31.63 v1(51.95,32.32) ; v1(23.11,38.93) 23.11,37 23.92,36.19 27.3,36.19 27.76,35.73 27.76,35.15 28.88,34.03 29.26,34.03 30.02,33.27 30.02,32.52 31.31,31.23 31.31,30.16 30.86,29.71 30.86,28.33 v1(31.38,27.81)
  IN2 w2.032: 109.38,110.78 105.23,110.78 102.37,113.64 91.79,113.64 90.69,114.74 81.17,114.74
  IN3 w0.508: v1(31.38,27.81) 31.38,27.68 32.2,26.86 36.53,26.86 38.06,28.38 38.06,29.51 39.82,31.28 45.86,31.28 46.03,31.44 51.08,31.44 v1(51.95,32.32) ; v1(62.09,119.59) 62.78,120.29 62.78,122.83 65.04,125.08 65.04,125.37 65.94,126.27 69.24,126.27 69.74,125.76 70.66,125.76 71.3,126.41 71.3,131.69 72.12,132.5 75.44,132.5 v1(76.17,133.24) ; v1(48.83,95.93) 48.83,95.64 47.86,94.67 47.86,92.75 47.03,91.92 47.03,86.94 43.7,83.62 43.39,83.62 41.83,82.06 41.83,74.16 43.1,72.89 43.1,68.63 45.16,66.56 45.16,65.25 46.81,63.61 46.81,62.9 46.4,62.49 46.4,61.04 44.43,59.08 v1(43.7,59.08)
  IN3 w2.032: 160.24,94.61 160.24,97.14 159.52,97.86 159.52,99.67 157.36,101.83 157.36,109.92 155.52,111.76
  BOTTOM w0.254: PUI02.2 167.27,87.02 167.61,87.36 167.61,87.75 v1(167.45,87.91) 167.76,88.22 PRI22.1 ; PUG01.15 156.51,93.6 v1(156.4,93.7) ; v1(164.79,89.02) 165.22,88.6 PUI02.15 ; v1(167.11,58.31) 166.99,58.19 PUA01.4 ; v1(160.57,68.3) 160.62,68.36 PUI01.15
  BOTTOM w0.305: PUI01.2 162.52,70.7 v1(162.26,70.96)
  BOTTOM w0.508: PRH11.1 166.02,50.25 166.32,50.25 166.75,50.68 v1(167.9,50.68) ; PRZ57.1 v1(169.32,51.2)
  vias: v1(15.2,48.52) v1(15.2,47.9) v1(15.83,48.52) v1(15.83,47.9) v1(23.1,39.56) v1(23.73,39.57) v1(23.74,38.97) v1(25.9,112.41) v1(25.9,111.78) v1(25.9,111.14) v1(26.48,112.41) v1(26.48,111.78) v1(26.48,111.14) v1(27.07,112.41) v1(27.07,111.78) v1(27.07,111.14) v1(27.7,112.41) v1(27.7,111.78) v1(27.7,111.14) v1(28.34,112.41) v1(28.34,111.78) v1(28.34,111.14) v1(28.97,112.41) v1(28.97,111.78) v1(28.97,111.14) v1(31.29,46.77) v1(31.29,46.16) v1(31.29,45.52) v1(34.76,50.36) v1(34.76,49.73) v1(35.9,60.38) v1(35.9,59.77) v1(35.9,59.16) v1(36.51,60.38) v1(36.51,59.77) v1(36.51,59.16) v1(37.09,60.38) v1(37.12,59.77) v1(37.12,59.16) v1(37.21,127.15) v1(37.75,127.72) v1(37.8,127.14) v1(38.03,128.24) v1(38.35,127.74) v1(38.39,127.15) v1(40.23,124.33) v1(40.86,124.96) v1(40.86,124.33) v1(61.22,119.59) v1(61.64,120.02) v1(68.78,114.38) v1(69.42,114.38) v1(70.05,114.38) v1(129.1,109.85) v1(129.61,109.25) v1(129.69,109.84) v1(130.18,109.39) v1(136.71,114.37) v1(136.9,113.79) v1(137.32,114.37) v1(137.51,113.79) v1(146.4,112.66) v1(146.4,112.07) v1(146.99,112.66) v1(159.55,69.06) v1(159.85,68.46) v1(185.58,61.21) v1(185.59,60.61) v1(186.18,61.2) v1(186.19,60.6) v1(198.19,32.63) v1(198.77,32.63) v1(199.35,32.63) v1(205.46,33.84) v1(205.76,33.33) v1(206.05,33.84) v1(206.38,33.36) v3(197.89,34.43)
+5VALWP: length 33.4
  IN2 w0.254: v1(23.4,93.47) 25.04,93.47 26.09,94.52 26.09,95.25 27.01,96.16 27.01,104.25 27.45,104.69 27.45,106.66 28.09,107.3 v1(28.09,107.51) ; v1(24.95,94.75) 26.63,96.43 26.63,104.43 27.03,104.83 27.03,106.89 27.46,107.31 v1(27.46,107.51)
  BOTTOM w0.254: v1(23.4,93.47) 23.64,93.23 PR509.2 24.21,93.24 PR510.1 ; PU501.14 25.11,94.9 v1(24.95,94.75)
  vias: v1(17.18,105.81) v1(17.18,105.18) v1(17.18,104.54) v1(17.18,103.91) v1(21.51,105.7) v1(21.51,105.06) v1(21.51,104.43) v1(21.51,103.79) v1(22.11,105.39) v1(22.11,104.76) v1(22.11,104.12) v1(22.11,103.49) v1(24.93,108.14) v1(25.26,108.69) v1(25.55,108.14) v1(25.55,107.51) v1(26.19,108.75) v1(26.19,108.14) v1(26.19,107.51) v1(26.82,108.75) v1(26.82,108.14) v1(26.82,107.51) v1(27.46,108.75) v1(27.46,108.14) v1(28.09,108.75) v1(28.09,108.14) v1(28.73,108.75) v1(28.73,108.11) v3(27.54,106.8)
+5VS: length 249.4
  TOP w0.254: v1(216.84,30.67) 217.42,31.25 JVGA.16
  TOP w0.508: QI1.2 24.01,93.81 23.62,94.2 v1(23.62,94.72) ; DI1.1 24.33,110.84 21.17,107.68 16.4,107.68 v1(15.34,106.61) 15.34,103.06 15.69,102.7 FI1.2 ; Q7.3 45.55,42.68 45.55,41.4 45.24,41.09 F3.2 45.24,40.25 43.01,38.02 40.96,38.02 40.45,38.53 v1(40.45,38.73) ; RA4.1 31.82,19.55 32.06,19.79 v1(32.06,20.14) ; C30.1 180.41,66.07 181.02,66.68 v1(181.02,67.23)
  TOP w0.762: 175.08,43.87 175.08,41.59 176.31,40.36 176.31,39.84 ; 174,45 173.21,45 172.74,45.47 171.7,45.47 170.94,46.24 170.94,46.95 170.48,47.4 170.48,49.03 169.88,49.63 v1(169.38,49.63)
  IN1 w0.508: v1(181.02,67.23) 182.57,67.23 183.24,66.56 183.24,65.35 183.68,64.92 184.49,64.92 185.01,64.4 193,64.4 v1(194.24,63.15) ; v1(15.18,87.68) 16.01,88.51 21.55,88.51 22.56,89.53 22.56,93.67 v1(23.62,94.72) ; v1(194.88,61.88) 204.15,61.88 205.59,60.44 211.77,60.44 212.18,60.03 217.44,60.03 221.43,56.04 221.43,47.95 222.32,47.06 222.32,42.94 218.83,39.44 v1(218.83,37.12) 218.83,35.9 220.81,33.92 220.81,31.28 218.77,29.23 v1(218.77,28.91)
  IN2 w0.508: 217.61,28.62 217.61,29.84 216.84,30.61 v1(216.84,30.67) ; 15.97,88.48 22.78,88.48 23.59,87.66 23.59,84.67 23.21,84.29 22.75,84.29 22.42,83.96 22.42,78.7 21.52,77.8 21.52,76.01 23.49,74.05 23.49,63.59 23.07,63.17 v1(23.07,62.1) ; 15.97,88.48 15.97,93.52 14.88,94.61 v1(14.88,98.99) ; 15.97,88.48 v1(15.18,87.68)
  IN3 w0.508: v1(39.48,59.75) 39.48,60.29 39.17,60.6 38.24,60.6 37.87,60.97 33.17,60.97 31.77,59.57 30.58,59.57 29.66,60.49 22.89,60.49 22.47,60.9 22.47,61.5 v1(23.07,62.1)
  IN3 w1.524: 34.74,4.69 37.37,7.32 37.37,13.6 38.34,14.56 38.34,16.25 37.85,16.74 37.85,19.16 36.74,20.28 35.29,20.28 ; 27.57,29.12 28.14,28.55 28.14,28.04 29.41,26.76 30.68,26.76 31.84,25.6 33.55,25.6 33.59,25.56
  BOTTOM w0.508: R12.1 218.37,37.57 v1(218.83,37.12) ; JFAN1.1 181.03,67.54 v1(181.02,67.23) ; v1(15.34,106.61) 15.34,99.45 v1(14.88,98.99)
  BOTTOM w1.524: 26.48,31.45 27.98,31.45 28.28,31.75 29.54,31.75 29.83,32.04 30.93,32.04 31.78,31.2 31.97,31.2 32.63,30.54
  vias: v1(25.67,30.08) v1(25.67,29.5) v1(26.26,30.08) v1(26.26,29.5) v1(32.75,3.61) v1(32.75,3.03) v1(33.33,3.61) v1(33.33,3.03) v1(34.55,30.97) v1(35.09,31.25) v1(35.09,30.67) v1(35.11,30.08) v1(40.34,59.77) v1(40.6,59.16) v1(40.92,59.77) v1(41.19,59.16) v1(41.5,59.77) v1(41.48,58.65) v1(41.81,59.18) v1(42.09,59.77) v1(42.06,58.65) v1(42.39,59.18) v1(42.67,59.77) v1(194.24,62.52) v1(194.24,61.88) v1(194.88,63.15) v1(194.88,62.52) v1(217.95,25.74) v1(217.99,25.09) v3(193.48,63.14)
+5VS_ODD:
  vias: v1(193.19,66.07) v1(193.19,65.43) v1(193.82,66.07) v1(193.82,65.43) v2(198.2,67.17)
+17.4V_BATT+: length 69.5
  TOP w0.102: v1(209.25,42.08) 209.25,42.02 209.63,41.64 v2(210.12,41.64)
  IN2 w0.203: 173.94,33.64 173.53,34.05 166.83,34.05
  IN2 w0.254: v1(151.19,33.21) 151.19,32.9 151.88,32.21 155.02,32.21 155.19,32.38 157.88,32.38 157.97,32.29 162.6,32.29 163.58,33.27 164.89,33.27 165.3,33.68 166.45,33.68 166.83,34.05 ; 173.94,33.64 174.19,33.39 176.78,33.39 178.99,35.6 180.59,35.6 181.63,36.64 183.99,36.64 184.51,37.17 186.61,37.17 186.88,37.44 191.79,37.44 192.57,36.66 193.89,36.66 194.7,37.47 195.3,37.47 195.65,37.12 198.22,37.12 198.54,36.8 207.86,36.8 209.21,38.15 209.21,42.04 v1(209.25,42.08)
  BOTTOM w0.508: v1(209.25,42.08) 209.25,42.44 208.96,42.73 PRB39.1
+17.4V_BATT++: length 4.2
  TOP w0.089: v1(153.04,37.66) 152.36,38.35 v3(152.36,39.39) ; v1(153.04,37.66) 153.37,37.99 v3(153.55,37.99) ; v1(153.04,37.66) 153.04,37.22 152.62,36.8 v3(152.1,36.8)
+19V_ADPIN:
  vias: v1(83.98,142.43) v1(84.51,141.09) v1(84.57,142.43) v1(84.58,141.75) v1(85.1,141.09) v1(85.17,142.41) v1(85.16,141.75) v1(85.68,141.09) v1(85.76,142.43) v1(85.77,141.75) v3(84.68,140.14) v3(86.23,141.35) v3(88.73,141.4)
+19VB: length 274.8
  TOP w2.032: 176.79,25.38 149.59,25.38 148.88,26.09 148.88,28.79 147.14,30.54 146.79,30.54 144.06,33.26 140.08,33.26 139.54,33.79 135.52,33.79 135.28,34.02 132.08,34.02 130.7,35.4 126.17,35.4 125.07,34.3 119.22,34.3 116.72,31.8 116.72,31.34 114.7,29.32 113.71,29.32 111.16,26.77 108.49,26.77 107.11,25.38 101.45,25.38 100.5,24.43 68.82,24.43
  IN1 w1.016: 162.08,111.81 162.08,111.8 152.2,111.8 150.34,113.66 144.57,113.66 142.84,111.93 138.75,111.93 137.99,112.69 137.03,112.69
  IN1 w2.032: 133.82,152.69 164.02,152.69 167.19,149.52 167.19,140.83 167.64,133.71 167.64,117.07
  IN2 w0.508: 204.95,43.89 204.96,43.9 206.28,43.9 206.84,43.34 206.84,42.76 204.76,40.67 204.76,39.84 v1(204.31,39.4)
  IN2 w1.016: 169.08,54.15 169.25,54.15 171.84,51.56 171.84,50.97 172.82,50 177.83,50 181.34,46.49 182.18,46.49 186.33,42.34
  IN2 w2.032: 176.79,25.38 146.29,25.38
  BOTTOM w0.508: v1(17.17,46.55) 17.36,46.55 17.81,47.01 PR302.2 ; v1(204.31,39.4) PRB21.2
  vias: v1(16.37,38.35) v1(16.37,37.77) v1(16.37,37.18) v1(16.37,36.6) v1(16.37,36.01) v1(16.98,38.35) v1(16.98,37.77) v1(16.98,37.18) v1(16.98,36.6) v1(16.98,36.01) v1(32.29,96.79) v1(32.29,96.16) v1(32.29,95.52) v1(32.61,94.92) v1(32.93,96.79) v1(32.93,96.16) v1(32.93,95.52) v1(33.56,96.79) v1(33.56,96.16) v1(33.56,95.52) v1(47.92,24.3) v1(50.46,24.3) v1(51.1,24.3) v1(51.73,24.3) v1(58.49,24.5) v1(58.49,23.92) v1(59.12,24.5) v1(59.12,23.92) v1(59.76,24.5) v1(59.76,23.92) v1(60.39,24.5) v1(60.39,23.92) v1(61.03,24.5) v1(61.03,23.92) v1(61.66,24.5) v1(61.66,23.92) v1(62.3,24.5) v1(62.3,23.92) v1(90.34,141.42) v1(90.34,140.81) v1(90.34,140.2) v1(90.34,139.59) v1(90.34,138.98) v1(90.95,141.42) v1(90.95,140.81) v1(90.95,140.2) v1(90.95,139.59) v1(90.95,138.98) v1(120.26,151.73) v1(120.26,151.15) v1(120.84,151.73) v1(120.84,151.15) v1(121.43,151.73) v1(121.43,151.15) v1(122.01,151.73) v1(122.01,151.15) v1(130.48,153.51) v1(130.48,152.87) v1(131.08,153.48) v1(131.08,152.89) v1(131.66,153.48) v1(131.66,152.89) v1(132.25,153.48) v1(132.25,152.89) v1(134.42,112.6) v1(134.67,113.18) v1(135.05,112.6) v1(165.13,103.82) v1(165.79,104.14) v1(165.79,103.51) v1(166.42,104.14) v1(166.42,103.51) v1(167.06,104.14) v1(167.06,103.51) v1(168.06,55.52) v1(168.44,56) v1(168.41,54.99) v1(169.01,116.18) v1(169.01,115.55) v1(169.01,114.91) v1(169.33,116.71) v1(169.65,116.18) v1(169.65,115.55) v1(169.65,114.91) v1(173.3,77.41) v1(173.59,76.89) v1(173.83,77.75) v1(174.04,76.47) v1(174.15,77.24) v1(174.51,76.06) v1(174.62,76.83) v1(174.93,75.63) v1(175.11,76.41) v1(175.53,75.99) v1(177.97,26.67) v1(177.97,26.04) v1(177.97,25.4) v1(178.6,26.67) v1(178.6,26.04) v1(178.6,25.4) v1(179.24,26.67) v1(179.24,26.04) v1(179.24,25.4) v1(179.87,26.67) v1(179.87,26.04) v1(179.87,25.4) v1(181.42,45.17) v1(186.29,41.43) v1(186.93,41.43) v1(187.56,41.43) v1(188.2,41.43) v1(188.83,41.43) v1(189.53,41.43) v1(190.17,41.43) v1(190.8,41.43) v1(201.23,66.18) v1(201.23,65.59) v1(201.23,65.01) v1(201.23,64.42) v1(201.85,66.18) v1(201.85,65.59) v1(201.85,65.01) v1(201.85,64.42) v1(205.46,54.47) v1(205.45,53.89) v1(206.12,53.65) v1(206.7,53.65) v1(207.34,53.68) v1(207.58,54.88) v1(207.58,54.27) v1(207.93,53.69) v1(208.21,54.88) v1(208.22,54.27) v3(63.56,24.27)
+19VB_1.2V: length 11.1
  TOP w0.254: PRM07.1 32.49,27.47 v1(32.17,27.8)
  IN1 w0.254: v1(32.17,27.8) 33.09,26.87 41.19,26.87 41.82,27.49
  vias: v1(41.89,28.32) v1(42.48,28.32) v1(43.06,28.32) v1(43.43,27.85) v2(44.2,27.01)
+19VB_+1.35VGPU: length 0.8
  TOP w0.089: 138.87,109.18 v2(138.03,109.18)
  vias: v1(139.16,108.61) v1(139.75,108.61)
+19VB_+1VALW:
  vias: v1(163.48,54.57) v1(163.76,54.01) v1(164.07,54.57) v2(164.17,55.3)
+19VB_CPU: length 21.9
  TOP w0.152: v1(170.68,51.18) 170.68,51.23 169.27,52.64 169.27,56.5 168.92,56.85 168.39,56.85 167.95,57.29 167.95,57.93 168.35,58.33 168.35,59.31 166.09,61.57 v1(165.77,61.57)
  BOTTOM w0.508: PRZ35.1 v1(170.68,51.18)
  BOTTOM w1.016: 170.09,67.55 170.09,63.64 167.7,61.25 166.96,61.25
  vias: v1(167.12,82.12) v1(167.12,81.42) v1(167.12,80.78) v1(167.11,79.82) v1(167.11,79.12) v1(167.11,78.54) v1(167.11,77.95) v1(167.44,69.69) v1(167.64,79.52) v1(167.64,78.82) v1(167.64,78.23) v1(167.64,77.65) v1(168.14,69.69) v3(168.82,79.48)
+19VB_VGA:
  vias: v1(81.32,125.59) v1(81.9,125.59) v1(82.1,135.61) v1(82.49,125.59) v1(82.71,135.61) v1(83.07,125.59) v1(83.05,124.04) v1(83.32,135.61) v1(83.66,125.59) v1(83.66,124.04) v1(83.93,135.61) v1(84.21,123.73) v1(84.54,135.61) v1(84.57,124.65) v1(84.72,124.04) v1(85.34,138.29) v1(85.95,138.29) v1(86.56,138.29) v1(87.17,138.29) v1(87.78,138.29) v3(82.58,137.32)
+VBUS_DC_SS: length 208.1
  TOP w0.089: v2(100.52,119.67) 100.2,119.35 v1(99.66,119.35)
  IN2 w0.305: 144.79,106.96 142.27,109.49 136.05,109.49 133.08,112.45 133.08,112.97 131.97,114.08 130.31,114.08 129.78,114.61 126.81,114.61 126.53,114.89 125.81,114.89 125.7,114.78 125.04,114.78 123.88,115.94 121.24,115.94 119.87,117.31 114.74,117.31 114,116.57 109.94,116.57
  IN2 w0.508: 204.76,56.93 203.44,58.25 202.46,58.25 200.11,60.6 187.68,60.6 186.18,62.1 185.66,62.1 184.9,62.86 182.99,62.86 182.98,62.87 181.87,62.87 181.64,62.64 180.12,62.64 179.13,63.64 179.13,64.4 178.01,65.51 177.45,65.51 175.94,67.03 175.94,67.56 175.56,67.94 175.56,68.74 174.99,69.31 174.1,69.31 170.7,72.71 170.7,87.21 169.84,88.06 169.82,88.74 169.82,88.74 169.8,88.96 169.8,88.97 169.43,94.72 169.43,95.11 157.58,106.96 144.79,106.96 ; v1(99.66,119.35) 101.35,117.66 108.85,117.66 109.94,116.57 ; v1(58.38,135.34) 59.09,134.63 59.09,131.9 58.82,131.63 58.82,120.79 61.02,118.59 63.24,118.59 63.75,119.1 63.75,120.18 v1(64.22,120.65)
  IN3 w0.508: v1(99.66,119.35) 92.73,119.35 91.23,120.85 83.02,120.85 81.78,122.1 78.11,122.1 76.76,123.45 75.23,123.45 73.24,121.45 69.43,121.45 69.25,121.63 64.71,121.63 64.22,121.14 v1(64.22,120.65)
  vias: v1(205.46,56.43) v1(205.46,55.79)
+VCC_CORE: length 9.9
  TOP w0.356: PCI159.1 v1(122.39,66.55)
  TOP w0.508: PCI138.1 128.23,66.52 v1(128.22,66.53) PCI140.1 ; PCI139.1 125.84,66.53 v1(125.27,66.53) PCI141.1
  BOTTOM w0.152: UC1.A44 137.05,75.14 v1(137.48,75.57)
  BOTTOM w0.203: UC1.A39 136.78,72.66 v1(136.83,72.62) ; v1(136.8,70.19) UC1.A34
  BOTTOM w0.508: PCI171.1 144.15,67.1 RC150.1
  vias: v1(121.6,70.34) v1(121.7,72.63) v1(121.7,72.04) v1(121.7,68.97) v1(122.21,72.96) v1(122.18,71.56) v1(122.51,72.37) v1(122.84,72.91) v1(123.2,72.37) v1(123.45,72.91) v1(123.48,71.85) v1(123.52,68.11) v1(124.09,74.27) v1(124.69,71.85) v1(124.66,68.11) v1(125.3,74.27) v1(125.83,71.85) v1(125.93,68.11) v1(126.44,74.27) v1(127.1,71.85) v1(127.14,68.11) v1(127.65,74.27) v1(128.31,71.85) v1(128.35,68.11) v1(129.52,71.85) v1(129.55,68.11) v1(130.49,68.99) v1(130.59,72.63) v1(130.71,71.86) v1(130.69,71.15) v1(131.1,68.99) v1(131.22,72.2) v1(131.29,71.42) v1(131.28,70.44) v1(131.39,69.57) v1(132.83,71.41) v1(132.84,69.55) v1(132.85,73.24) v1(132.9,67.7) v1(134.16,73.12) v1(134.38,73.79) v1(136.79,67.71) v1(147.81,79.9) v1(148.39,79.9) v1(149.02,85.63) v1(149.04,85) v1(149.04,84.37) v1(149.04,83.73) v1(149.66,85.63) v1(149.67,85) v1(149.67,84.37) v1(149.67,83.73) v1(151.25,86.27) v1(151.25,85.57) v1(151.25,75.09) v1(151.25,74.46) v1(151.25,73.82) v1(151.25,73.19) v1(151.26,84.94) v1(151.26,84.31) v1(151.26,83.67) v1(151.26,75.73) v1(151.26,72.56) v1(151.83,75.48) v1(151.82,74.78) v1(151.82,74.14) v1(151.82,73.51) v1(151.82,72.87) v1(151.83,72.24) v1(151.88,86.27) v1(151.88,85.57) v1(151.89,84.94) v1(151.89,84.31) v1(151.89,83.67) v1(152.33,71.73) v1(152.33,71.09) v1(152.33,70.46) v1(152.39,74.9) v1(152.39,74.27) v1(152.39,73.63) v1(152.39,73) v1(152.4,72.37) v1(152.47,75.73) v1(152.58,86.27) v1(152.58,85.57) v1(152.59,84.94) v1(152.59,84.31) v1(152.59,83.67) v1(152.59,83.04) v1(152.85,71.42) v1(152.85,70.78) v1(152.85,70.08) v1(152.96,75.22) v1(152.96,74.58) v1(152.96,73.95) v1(152.96,73.31) v1(152.97,72.69) v1(152.96,72.04) v1(153.22,86.27) v1(153.22,85.57) v1(153.23,84.94) v1(153.23,84.31) v1(153.23,83.67) v1(153.22,83.03) v1(153.23,75.8) v1(153.61,75.23) v1(153.6,74.58) v1(153.6,73.95) v1(153.6,73.31) v1(153.61,72.69) v1(153.61,72.05) v1(153.86,75.8) v1(154.23,75.28) v1(154.23,74.65) v1(154.23,74.01) v1(154.24,73.38) v1(154.93,75.28) v1(154.93,74.65) v1(154.93,74.01) v1(154.94,73.38) v1(155.58,74.65) v1(155.58,74.02) v1(155.58,73.38) v3(149.59,71.1)
+VCC_CORE_42:
  vias: v1(121.67,75.75) v1(121.73,75.14) v3(121.04,75.9)
+VCC_CORE_G0: length 1.1
  TOP w0.089: TP32.1 131.25,67.99 v1(131.04,68.2)
  BOTTOM w0.076: UC1.K32 v1(131.04,68.2)
+VCC_CORE_G1: length 1.1
  TOP w0.089: TP33.1 121.55,68.21 v1(121.71,68.36)
  BOTTOM w0.076: v1(121.71,68.36) 121.39,68.36 UC1.AK32
+VCC_GT: length 75.3
  TOP w0.254: 132.9,90.13 132.9,91.48 131.78,92.6 RC155.1
  BOTTOM w0.102: 125.95,84.95 UC1.Y62 ; UC1.Y62 126.28,85.28 ; UC1.Y62 126.28,84.62 ; UC1.Y62 126.61,84.95 ; UC1.AA66 126.16,87.37 ; UC1.AA66 126.11,87.09 ; UC1.AA66 126.11,87.65 ; 128.29,87.74 UC1.R67 ; UC1.R67 128.29,88.3 ; UC1.R67 128.24,88.02 ; UC1.AC71 124.91,90.95 ; UC1.AC71 125.24,90.62 ; UC1.AC71 124.63,90.91 ; UC1.AC71 125.2,90.91 ; 130.11,87.74 UC1.L67 ; UC1.L67 130.11,88.3 ; UC1.L67 130.07,88.02 ; 126.74,85.09 UC1.W63 ; UC1.W63 126.46,85.7 ; UC1.W63 126.41,85.42 ; UC1.R69 128.85,89.61 ; UC1.R69 128.24,89.32 ; UC1.R69 128.29,89.04 ; UC1.R69 128.9,89.32 ; 129.2,89.69 UC1.N70 ; UC1.N70 129.82,89.97 ; UC1.N70 129.15,89.97 ; UC1.N70 129.77,90.26 ; UC1.M62 130.27,84.95 ; UC1.M62 129.94,85.28 ; UC1.M62 129.61,84.95 ; UC1.M62 129.94,84.62 ; 127.66,90.29 UC1.U71 ; UC1.U71 127.66,90.95 ; UC1.U71 127.99,90.62 ; UC1.U71 127.33,90.62 ; 130.11,85.78 UC1.L64 ; UC1.L64 130.11,86.35 ; UC1.L64 130.07,86.07 ; UC1.AA67 126.16,88.02 ; UC1.AA67 126.11,88.3 ; UC1.AA67 126.11,87.74 ; 130.11,86.43 UC1.L65 ; UC1.L65 130.07,86.72 ; UC1.L65 130.11,87 ; 129.2,89.04 UC1.N69 ; UC1.N69 129.48,88.99 ; UC1.N69 129.15,89.32 ; UC1.N69 129.82,89.32 ; UC1.N67 129.77,88.3 ; UC1.N67 129.77,87.74 ; UC1.N67 129.82,88.02 ; 129.15,85.42 UC1.N63 ; UC1.N63 129.82,85.42 ; UC1.N63 129.77,85.7 ; UC1.N63 129.48,85.09 ; 125.54,90.34 UC1.AA71 ; UC1.AA71 126.16,90.62 ; UC1.AA71 125.5,90.62 ; UC1.AA71 125.83,90.95 ; UC1.U68 127.99,88.67 ; UC1.U68 127.37,88.39 ; UC1.U68 127.66,88.34 ; UC1.U68 127.94,88.96 ; 130.07,85.42 UC1.L63 ; UC1.L63 130.11,85.7 ; UC1.L63 130.4,85.09 ; 126.41,89.97 UC1.W70 ; UC1.W70 126.46,89.69 ; UC1.W70 127.03,90.26 ; UC1.W70 126.46,90.26 ; UC1.R70 128.85,90.26 ; UC1.R70 128.9,89.97 ; UC1.R70 128.29,89.69 ; UC1.R70 128.24,89.97 ; UC1.AC64 125.09,86.07 125.25,86.23 ; 125.5,89.32 UC1.AA69 ; UC1.AA69 126.16,89.32 ; UC1.AA69 125.83,88.99 ; UC1.AA69 125.54,89.04 ; UC1.R63 128.9,85.42 ; UC1.R63 128.57,85.09 ; UC1.R63 128.85,85.7 ; UC1.R63 128.24,85.42 ; UC1.AA64 125.54,86.35 ; UC1.AA64 126.16,86.07 ; UC1.AA64 126.11,86.35 ; UC1.AA64 125.83,86.4 ; 131.19,84.95 UC1.L62 ; UC1.L62 130.57,84.67 ; UC1.L62 130.86,84.62 ; UC1.L62 130.53,84.95 ; 126.41,87.37 UC1.W66 ; UC1.W66 126.46,87.09 ; UC1.W66 126.46,87.65 ; UC1.R68 128.85,88.96 ; UC1.R68 128.29,88.96 ; UC1.R68 128.24,88.67 ; UC1.R68 128.29,88.39 ; UC1.AA70 126.11,90.26 ; UC1.AA70 126.16,89.97 ; UC1.AA70 125.5,89.97 ; UC1.AA70 125.54,89.69 ; UC1.R65 128.9,86.72 ; UC1.R65 128.24,86.72 ; UC1.R65 128.29,86.43 ; UC1.R65 128.29,87 ; 128.29,90.34 UC1.R71 ; UC1.R71 128.9,90.62 ; UC1.R71 128.24,90.62 ; UC1.R71 128.57,90.95 ; 127.78,84.95 UC1.T62 ; UC1.T62 128.11,85.28 ; UC1.T62 128.44,84.95 ; UC1.T62 128.11,84.62 ; UC1.L71 130.11,90.91 ; UC1.L71 130.11,90.34 ; UC1.L71 130.07,90.62 ; UC1.W68 126.46,88.96 ; UC1.W68 126.41,88.67 ; UC1.W68 127.03,88.39 ; UC1.W68 126.46,88.39 ; UC1.AC67 125.04,88.02 v1(125.37,87.7) 125.04,87.37 UC1.AC66 ; UC1.AA63 126.11,85.7 ; UC1.AA63 126.16,85.42 ; UC1.AA63 125.5,85.42 ; UC1.AA63 125.83,85.09 ; 126.41,86.72 UC1.W65 ; UC1.W65 126.46,87 ; UC1.W65 126.46,86.43 ; UC1.W65 127.03,86.43 ; 129.82,86.07 UC1.N64 ; UC1.N64 129.48,86.4 ; UC1.N64 129.15,86.07 ; UC1.N64 129.2,85.78 ; 127.99,86.72 UC1.U65 ; UC1.U65 127.37,86.43 ; UC1.U65 127.66,87.05 ; UC1.U65 127.66,86.39 ; 128.24,87.37 UC1.R66 ; UC1.R66 128.29,87.09 ; UC1.R66 128.29,87.65 ; 130.11,89.69 UC1.L70 ; UC1.L70 130.11,90.26 ; UC1.L70 130.07,89.97 ; 129.15,90.62 UC1.N71 ; UC1.N71 129.2,90.34 ; UC1.N71 129.48,90.95 ; UC1.N71 129.82,90.62 ; 126.41,88.02 UC1.W67 ; UC1.W67 127.03,88.3 ; UC1.W67 126.46,88.3 ; UC1.W67 126.46,87.74 ; UC1.W64 126.46,86.35 ; UC1.W64 127.03,86.35 ; UC1.W64 126.46,85.78 ; UC1.W64 126.41,86.07 ; UC1.W71 126.74,90.95 ; UC1.W71 127.07,90.62 ; UC1.W71 126.41,90.62 ; UC1.W71 126.46,90.34 ; UC1.L66 130.11,87.09 ; UC1.L66 130.07,87.37 ; UC1.L66 130.11,87.65 ; 130.07,89.32 UC1.L69 ; UC1.L69 130.11,89.61 ; UC1.L69 130.11,89.04 ; 125.2,86.43 UC1.AC65 125.24,86.72 ; UC1.L68 130.11,88.96 ; UC1.L68 130.07,88.67 ; UC1.L68 130.11,88.39 ; UC1.R64 128.85,86.35 ; UC1.R64 128.29,85.78 ; UC1.R64 128.24,86.07 ; UC1.R64 128.9,86.07 ; UC1.N66 129.77,87.09 ; UC1.N66 129.82,87.37 ; UC1.N66 129.77,87.65 ; UC1.AC69 125.2,89.04 ; UC1.AC69 125.24,89.32 ; UC1.AC69 125.2,89.61 ; 126.41,89.32 UC1.W69 ; UC1.W69 126.46,89.61 ; UC1.W69 126.46,89.04 ; UC1.AC70 125.2,89.69 ; UC1.AC70 125.24,89.97 ; UC1.AC70 125.2,90.26 ; 125.23,88.67 UC1.AC68
  BOTTOM w0.203: UC1.A62 v1(137.03,85.05) ; v1(137.12,82.55) 137.12,82.56 137.1,82.58 UC1.A58 ; v1(137.16,87.63) 137.06,87.53 UC1.A66
  vias: v1(123.28,81.06) v1(123.38,82.72) v1(123.45,79.04) v1(124.21,84.12) v1(124.59,82.72) v1(124.65,79.04) v1(124.84,84.12) v1(125.38,91.01) v1(125.38,90.33) v1(125.37,89.66) v1(125.37,89) v1(125.48,84.12) v1(125.8,82.72) v1(125.77,81.09) v1(125.86,79.04) v1(126.11,84.12) v1(126.3,90.3) v1(126.28,89.65) v1(126.3,88.96) v1(126.3,88.33) v1(126.3,87.69) v1(126.3,87.06) v1(126.33,86.32) v1(126.75,84.12) v1(126.94,82.72) v1(127.14,90.3) v1(127.14,88.38) v1(127.07,79.04) v1(127.17,86.38) v1(127.38,84.12) v1(128.02,84.12) v1(128.21,82.72) v1(128.31,79.04) v1(128.65,84.12) v1(129.05,89.61) v1(129.05,88.97) v1(129.07,87.73) v1(129.05,86.37) v1(129.29,84.12) v1(129.35,82.72) v1(129.73,81.16) v1(130.53,82.71) v1(131.19,81.3) v1(131.22,80.61) v1(149.23,98.21) v1(149.23,97.58) v1(149.23,96.94) v1(149.79,96.36) v1(149.79,95.72) v1(149.86,98.21) v1(149.86,97.58) v1(149.86,96.94) v1(150.37,96.36) v1(150.37,95.72) v1(150.37,95.09) v1(150.5,98.85) v1(150.5,98.21) v1(150.5,97.58) v1(150.5,96.94) v1(151,96.36) v1(151,95.72) v1(151,95.09) v1(151,94.5) v1(151.11,102.88) v1(151.11,102.29) v1(151.14,101.66) v1(151.25,101.01) v1(151.64,96.36) v1(151.64,95.72) v1(151.64,95.09) v1(151.64,94.5) v1(151.83,102.86) v1(151.83,102.28) v1(151.83,101.64) v1(151.83,101.01) v1(152.4,102.02) v1(152.4,101.44) v1(152.4,100.8) v1(153.04,101.44) v1(153.04,100.8) v3(146.29,102.22)
+VCC_GT_42: length 5.1
  TOP w0.089: v1(136.74,80.29) v3(136.03,80.29)
  IN3 w0.508: v1(136.74,80.29) 136.97,80.06 v1(136.97,77.44)
  BOTTOM w0.203: v1(136.97,77.44) 136.4,77.44 UC1.A48 ; v1(136.74,80.29) 136.41,80.29 UC1.A53
  vias: v1(131.21,76.86) v1(131.21,75.97) v1(131.23,75.17)
+VCC_GT_K52: length 2.9
  TOP w0.089: RC157.2 132.01,78.48 v3(132.58,79.05)
  TOP w0.381: v1(130.97,79.04) 130.97,78.88 131.37,78.48 RC157.2
  BOTTOM w0.254: v1(130.97,79.04) 131.07,79.04 131.2,79.17 UC1.K52
+VCC_SA: length 3.3
  TOP w0.508: RC159.1 146.34,57.54 v1(145.97,57.91)
  BOTTOM w0.102: 121.22,64.21 UC1.AK25 ; UC1.AK25 121.51,64.26 ; UC1.AK25 121.55,64.54 ; UC1.AK23 121.51,63.34 ; UC1.AK23 121.55,63.63 ; UC1.AK23 121.22,63.96 ; UC1.AK23 121.51,63.91
  vias: v1(121.73,64.56) v1(121.79,65.19) v1(123.57,64.98) v1(124.84,64.98) v1(126.05,64.98) v1(127.32,64.98) v1(128.53,64.98) v1(132.78,65.91) v1(132.8,64.07) v1(149.8,62.31) v1(149.8,61.68) v1(150.38,62.31) v1(150.38,61.68) v1(150.97,62.31) v1(150.97,61.68) v1(151.55,62.31) v1(151.55,61.68) v1(152.14,62.31) v1(152.14,61.68) v3(150.2,65.08)
+VDD_CT: length 8.3
  TOP w0.508: LV3.2 110.25,136.82 CV61.1 111.26,137.05 111.93,137.05 v2(112.03,136.95) 112.29,136.7 v1(112.68,136.7) ; CV62.1 120.26,136.68 v1(119.86,136.28) ; v1(118.56,137.02) 119.04,137.02 CV63.1
  BOTTOM w0.381: v1(119.86,136.28) 120.14,136.57 120.34,136.76 UV1.AA21 ; v1(119.86,136.28) UV1.AB21 119.12,137.02 v1(118.56,137.02) ; v1(119.86,136.28) UV1.AA20 ; v1(119.86,136.28) 119.38,135.8 UV1.AB20
+VDDR3: length 21.6
  BOTTOM w0.254: 115.77,134.49 116.14,134.49 ; 115.77,134.49 115.5,134.22 112.97,134.22 112.65,133.9 112.11,133.9 112.07,133.94 ; 115.77,134.49 115.77,134.7 115.5,134.98 112.52,134.98 112.24,135.26 111.46,135.26
  BOTTOM w0.381: UV1.AB17 119.46,133.8 v1(119.85,133.41) 119.95,133.41 UV1.AA17 UV1.AA18 UV1.AB18 119.07,134.52 118.27,134.52 v1(118.25,134.51) 116.62,134.51 116.61,134.49 116.14,134.49
  BOTTOM w0.508: 112.07,133.94 111.84,133.94 111.46,134.32 111.46,135.26 v2(110.74,135.26) CV123.1 108.77,136.16 CV66.1 108.68,135.19 LV4.2
GND: length 2957.4
  TOP w0.089: 81.87,35.21 81.87,34.9 81.86,34.89 81.86,34.54 UM1.N2 81.36,34.54 81.36,34.68 81.36,35.06 ; UM1.N5 81.76,32.79 82.01,33.04 82.21,33.04 82.51,32.74
  TOP w0.102: 213.04,52.61 212.95,52.7 212.95,54.01 v1(213.39,54.45) 213.67,54.45 214.14,54.92 215.16,54.92 215.24,55 ; 213.04,52.61 213.04,51.54 v1(213.43,51.15) 213.63,51.34 215.83,51.34 215.86,51.37 ; 213.04,52.61 213.22,52.79 213.83,52.79 v1(213.85,52.81)
  TOP w0.127: v3(22.88,98.97) 23.55,98.97 v1(23.93,98.6) ; DT5.2 12.35,118.84 v1(12.35,118.85) ; v1(80.69,132.8) 80.23,132.34 v3(79.87,132.34)
  TOP w0.178: UT5.19 35.54,110.5 35.12,110.92 v1(34.28,110.92)
  TOP w0.203: v1(42.39,84.75) 42.39,84.72 42.15,84.48 UE1.84 ; v1(88.17,32.01) 88.17,32.06 87.94,32.29 UM1.A6 ; UE1.124 36.87,71.01 v1(37.07,71.21) ; v1(50.15,81.58) 50.37,81.81 UE1.64 ; UM1.P6 80.73,32.29 v1(80.65,32.37) ; v1(38.3,111.46) 38.3,111.2 38.74,110.76 UT5.11 ; UE1.17 43.75,70.35 44.13,70.73 v1(44.61,70.73) ; v1(44.37,105.09) 44.2,105.25 44.2,105.87 43.9,106.17 UT5.52 ; UE1.51 52.19,76.61 52.44,76.35 53.03,76.35 v1(53.14,76.24) ; v1(37.98,31.19) 37.65,30.85 PUM01.1 ; UZ3.11 40.45,58.03 v1(40.6,57.88) ; v1(36.98,80.37) 36.75,80.61 UE1.100 ; PUM01.3 v1(36.85,31.31)
  TOP w0.229: v1(83.83,32.01) 83.61,32.23 UM1.J5 ; UM1.H10 84.11,30.9 v1(83.73,31.28) 83.6,31.28 83.6,31.29 UM1.K8 ; UM1.E10 UM1.E9 v1(86.12,31.3) ; UM1.G5 84.61,32.55 v1(85.12,32.04) 85.38,31.79 UM1.E7 ; UM1.F10 v1(85.11,31.28) ; UM1.C4 86.61,33.28 v1(86.14,32.81)
  TOP w0.254: UV14.A1 161.51,129.76 v1(161.17,130.1) ; UV12.U12 161.51,145.13 161.91,144.73 v1(161.92,144.73) ; UV14.L10 v1(153.11,122.91) UV14.M10 ; v1(154.31,135.76) 154.31,135.76 UV12.H1 UV12.H2 ; UV14.C11 v1(160.31,122.11) UV14.B10 ; v1(152.31,137.52) 151.91,137.93 UV12.E3 ; UV14.N14 v1(152.31,118.91) ; v1(160.06,118.79) 159.91,118.94 UV14.C14 ; UV14.A3 v1(161.11,127.71) 160.31,127.71 UV14.C4 ; UV14.H2 155.97,128.97 155.97,129.65 UV14.H1 155.91,130.2 v1(156.06,130.36) ; UV12.R12 159.91,145.13 160.31,144.73 v1(160.31,144.73) 160.31,144.72 159.91,144.33 UV12.R11 ; UV12.N14 158.31,146.73 v1(157.91,147.13) ; v1(132.33,91.17) 132.28,91.12 PCG113.2 130.66,91.12 v1(130.63,91.14) ; UV14.R14 v1(149.91,119.71) ; v1(160.31,143.93) 160.31,143.93 160.71,143.53 UV12.T10 ; v1(160.31,139.93) 160.71,139.53 UV12.T5 ; v1(148.34,147.1) UV12.A14 ; UV14.R3 v1(149.91,127.71) UV14.R4 ; UV12.E14 151.91,147.24 v1(151.9,147.25) ; DT3.2 v1(10.24,124.77) ; UV12.D10 151.14,143.53 v1(151.49,143.18) ; UV14.C3 v1(159.51,128.51) ; UV14.R11 v1(149.91,121.31) UV14.R12 ; v1(158.32,118.78) 158.31,118.79 UV14.E14 ; UV14.D10 159.08,122.51 v1(158.73,122.85) ; v1(156.31,145.53) 155.91,145.93 UV12.K13 ; v1(161.12,138.33) 161.12,138.32 161.51,137.93 UV12.U3 ; UV12.C13 UV12.C14 150.31,147.09 v1(150.16,147.24) ; UV14.U12 148.62,120.91 v1(148.26,120.54) ; CV11.2 RV13.2 113.76,134.83 113.06,135.53 v1(112.74,135.53) ; UV12.K14 156.28,146.36 v1(156.28,146.35) ; v1(158.33,135.76) 158.31,135.78 UV12.N1 ; UV12.F10 152.71,143.53 v1(153.11,143.13) 153.51,143.52 UV12.G10 ; UV14.U1 v1(148.24,130.17) ; UV14.R1 150.31,130.17 v1(150.2,130.27) ; UV12.C1 150.31,136.22 v1(149.98,135.9) ; UV12.K1 155.91,136.32 v1(156.31,136.72) 156.31,136.72 UV12.K2 ; v1(162.08,120.61) 161.81,120.61 161.51,120.91 UV14.A12 ; UV14.E12 v1(157.91,120.51) ; v1(160.31,146.33) 160.31,146.33 159.91,146.73 UV12.R14 ; UV12.N12 158.31,145.13 157.91,145.53 v1(157.9,145.53) ; v1(79.96,33.18) 80.07,33.29 UM1.P4 ; UV12.G5 153.51,139.53 v1(153.11,139.93) 152.71,139.53 UV12.F5 ; UV14.T10 v1(149.91,122.11) ; v1(161.88,118.94) 161.51,119.31 UV14.A14 ; v1(161.91,135.92) 161.51,136.32 UV12.U1 ; v1(155.51,119.71) UV14.H13 ; v1(151.72,135.76) 151.91,135.94 UV12.E1 ; UV12.M10 157.51,143.52 157.11,143.13 v1(157.1,143.13) 157.1,143.14 156.71,143.53 UV12.L10 ; UV14.H14 v1(155.91,118.74) ; UV14.P10 v1(151.51,122.11) ; UV12.A1 148.71,136.28 v1(149.05,135.93) ; UV12.B10 149.51,143.53 v1(149.91,143.93) 150.31,144.32 UV12.C11 ; UV12.E12 151.91,145.11 151.52,144.73 150.73,144.73 v1(150.67,144.67) 150.31,145.04 UV12.C12 ; UV14.E1 157.9,130.12 v1(157.9,130.22) ; UV14.N12 v1(152.31,120.51) ; UV14.E3 v1(157.91,128.51) ; v1(154.34,130.23) 154.31,130.2 UV14.K1 UV14.K2 ; UV14.M5 v1(153.11,126.11) UV14.L5 ; DT4.2 10.24,122.78 v1(10.61,122.42) ; UV14.T5 v1(149.91,126.11) ; UV12.C3 150.32,137.93 v1(150.72,137.52) ; UU2.14 30.63,48.69 v1(30.55,48.62) ; v1(149.11,144.73) 148.71,145.13 UV12.A12 ; UV12.P10 159.11,143.53 158.71,143.93 v1(158.7,143.93) ; UV12.U14 161.51,146.73 161.11,147.12 v1(161.11,147.13) ; 82.51,32.74 82.66,32.59 v1(82.66,32.11) ; v1(8.37,123.78) 8.12,123.78 8.08,123.82 8,123.82 ; v1(160.18,130.32) 159.91,130.05 UV14.C1 ; PCB44.1 168.05,33.34 168.33,33.05 168.33,32.43 169.09,31.67 PR40.2 ; v1(83.9,112.5) 83.84,112.57 UZ7.5 ; UZ1.5 162.23,34.49 v1(162.44,34.7) ; v1(13.26,117.77) 12.69,117.77 12.38,117.46 DT6.2 ; UV12.A3 148.71,137.93 v1(149.11,138.33) 149.91,138.33 UV12.C4 ; UV12.B5 149.51,139.53 v1(149.91,139.93) ; UV12.R1 159.91,135.87 v1(160.02,135.76) ; UV12.M5 157.51,139.53 157.9,139.14 v1(157.9,139.13) ; UV14.F5 v1(157.11,126.11) UV14.G5 ; JVGA.1 219.31,38.75 v1(219.41,38.64) ; v1(151.91,130.29) 151.91,130.26 151.91,130.25 UV14.N1 ; UV14.G10 v1(157.11,122.91) UV14.F10 ; UV12.L5 156.71,140.09 v1(156.71,140.09) ; UV12.R3 159.91,137.93 v1(160.31,138.33) 159.91,138.73 UV12.R4 ; v1(160.47,126.07) 160.47,126.27 UV14.B5 ; UV12.N3 157.91,138.33 v1(157.9,138.33) ; UV12.H13 154.31,145.93 154.71,146.33 v1(154.71,146.35) 154.69,146.35 154.31,146.73 UV12.H14 ; CV28.2 115.25,136.16 RV12.2 114.78,137.05 115.01,137.27 v1(115.01,138.22) ; UV14.C12 v1(160.31,120.51) UV14.C13 ; UV14.U3 v1(149.11,127.71) ; v1(149.11,118.91) UV14.U14 ; UV14.K14 154.31,119.19 v1(153.97,118.85) ; UV14.K13 v1(153.91,120.51) ; UV14.N3 v1(152.31,127.71)
  TOP w0.279: v1(8.19,117.55) 8.19,117.94 7.81,118.32 JUSBC1.A12 ; 8,123.82 7.35,123.82 JUSBC1.A1
  TOP w0.305: JVGA.10 216.85,34.25 216.71,34.39 v1(216.71,35.37) ; CE37.2 33.62,80.23 33.54,80.31 v1(33.54,80.31) ; RC130.2 124.29,54.26 v1(124.83,54.26) ; CV35.2 113.89,132.06 114.31,132.48 114.74,132.48 115.36,131.86 CV26.2 ; UZ2.5 157.54,34.03 158.2,33.37 CZ6.2 ; v1(216.78,36.48) 216.78,36.91 217.12,37.25 JVGA.4
  TOP w0.356: PQS05.4 60.41,128.07 60.41,127.47 60.04,127.09 PUS02.3 ; v1(17.98,129.81) 17.92,129.88 CT80.2 ; v1(79.61,40.75) 80.15,40.75 80.78,40.11 CM10.2 ; v1(41.13,86.31) 41.16,86.34 CE36.2 ; RC110.2 102.41,43.03 CC71.2 ; v1(206.39,37.74) 206.39,38.41 206.83,38.84 207.9,38.84 C48.2 ; v1(31.51,52.45) CU19.2 CU20.2 ; v1(213.38,45.12) 213.59,45.32 C49.2 215.5,45.32 215.95,45.77
  TOP w0.381: PQ13.1 172.87,33.99 172.43,33.55 PR45.2 ; RC66.2 126.04,51.04 v1(125.64,51.45) ; CA27.2 28.28,6.27 28.28,6.97 CA2.2 28.46,7.15 28.46,7.77 CA47.2 CA43.2 ; PCV34.2 75.52,125.3 76.31,124.51 PCV27.2 76.68,124.39 v1(76.92,124.63) ; v1(133.6,68.63) 133.59,68.64 PCI131.2 ; PCG134.2 124.86,85.27 v1(124.46,85.67) ; UM2.3 83.17,45.46 82.86,45.77 80.93,45.77 80.48,46.22 v1(80.48,46.49) ; CC26.2 106.75,77.33 107.17,77.75 v1(107.17,78.03) ; CV119.2 126.8,129.06 CV175.2 ; CC31.2 106.2,88.71 107.58,88.71 107.95,88.35 v1(107.95,88.07) ; UC4.3 105.16,43.42 106.03,44.28 RC109.2 ; v1(121.71,85.77) 122.16,85.33 122.25,85.33 122.81,84.77 PCG144.2 ; v1(120.02,75.04) 120.43,75.04 PCI135.2 ; v1(128.78,82.72) 128.78,82.34 PCG130.2 ; PQ12.1 172.97,29.25 PR44.1 ; CA49.2 31.39,20.76 ; 31.39,20.76 31.38,20.77 v1(31.38,21.31) ; 31.39,20.76 CA45.2 30.77,20.7 30.32,20.7 RA24.2 ; CV53.2 130.11,127.94 129.37,128.69 v1(129.31,128.69) 129.3,128.69 CV174.2 127.7,128.92 CV175.2 ; v1(50.07,112.97) 50.07,113.44 49.56,113.96 PUS01.4 ; v1(130.63,91.14) 130.59,91.14 129.79,90.35 PCG135.2 ; v1(105.77,73.9) 105.78,73.91 CC36.2 ; RC67.2 122.56,51.82 v1(122.56,53.06) ; CV127.2 121.34,137.84 v1(120.85,137.36) 120.42,137.79 CV62.2 119.36,137.79 CV63.2 ; PCG115.2 122.81,82.27 v1(122.81,82.72) ; CC39.2 108.03,90.76 108.45,90.34 v1(108.45,90.15) ; CA50.2 CA46.2 23.72,9.32 v1(24.04,9.63) ; CC73.2 130.76,53.89 130.55,53.67 v1(130.07,53.67) ; v1(134.18,91.16) 134.1,91.08 RC136.1 ; v1(96.88,149.03) PU2.3 ; UC2.3 v1(105.5,98.66) ; v1(132.85,85.14) 132.69,85.3 RC122.2 131.23,84.85 PCG146.2 ; PCG139.2 PCG145.2 121.5,82.4 v1(121.47,82.37) ; U4.3 43.1,95.01 43.16,94.94 v1(43.56,94.94) ; RV9.2 CV29.2 117.67,134.26 118.25,133.67 v1(118.25,133.51) ; v1(216.32,61.4) 215.92,60.99 C43.2 ; PCG104.2 124.02,82.27 v1(124.02,82.72) ; v1(133.41,65.91) 133.42,65.9 PCA112.2 ; PCG137.2 124.27,89.83 v1(124.46,89.65) ; RV2.1 124.91,128.09 v1(124.91,127.63) 124.66,127.63 CV102.2 124.32,126.87 124.71,126.48 CV101.2 CV105.2 ; UT7.2 39.81,130.31 39.7,130.42 v1(38.88,130.42) ; CV20.2 117.57,131.65 CV21.2 116.88,131.62 v1(116.88,131) ; v1(125.22,82.72) 125.22,82.27 PCG110.2 ; PCG140.2 132.46,80.13 v1(132.84,80.51) 132.84,80.83 PCG136.2 ; CE39.2 CE38.2 54.87,75.86 55.2,75.52 v1(55.2,74.6) ; v1(125.74,130.53) 125.74,130.45 126.24,129.94 CV48.2 CV177.2 127.7,129.6 CV175.2 ; PR43.2 176.04,29.6 176.04,31.01 v1(176.18,31.15) ; v1(126.37,82.72) 126.37,82.34 PCG102.2 ; v1(107.91,81.58) 107.91,81.87 107.63,82.15 106.19,82.15 CC30.2 104.97,81.87 CC35.2 ; PQ12.4 170.51,30.55 170.94,30.12 v1(170.94,28.66) ; UC9.3 144.45,88.8 144.06,88.42 144.06,86.59 144.45,86.21 v1(145.16,86.21) ; C54.2 C53.2 40.48,61.34 40.29,61.53 v1(40.29,61.59) ; RE53.1 37.35,89.82 UE2.3 ; v1(121.4,67.74) 121.47,67.81 121.99,67.81 PCI134.2 ; v1(64.67,122.56) PQS10.4 ; PR38.2 174.7,36.88 174.58,36.75 PQ13.4 ; US2.2 182.49,37.46 182.89,37.07 183.78,37.07 184.26,37.55 184.26,40.66 183.69,41.23 182.69,41.23 CS8.2 ; PCG141.2 133.06,82.95 132.97,83.05 132.97,83.2 v1(132.83,83.35) ; PCG101.2 127.64,82.27 v1(127.64,82.72) ; v1(117.91,75.05) 117.96,75.01 CC34.2 ; CE4.2 32.2,67.76 31.83,67.39 30.96,67.39 30.72,67.15 v1(30.72,67.01) ; CV103.2 121.19,125.44 v1(121.39,125.44) ; v1(129.18,55.14) 128.85,55.14 128.58,54.87 RC6.1 ; v1(132.59,88.2) 131.89,88.2 RC121.2 ; v1(32.43,15.9) 32.3,16.03 CA48.2 CA44.2
  TOP w0.406: Q25.1 51.65,106.54 v1(51.85,106.33) ; v1(59.42,128.57) 59.61,128.38 PQS05.4 ; 165.48,31.85 165.07,32.25 PUB02.3 ; EU3101.3 188.37,34.98 188.55,34.81 v1(188.55,34.57) ; EU2603.3 v1(17.5,30.48)
  TOP w0.432: v1(58.2,133.41) 57.77,132.99 PQS03.4 ; PQ13.4 174.58,35.57 v1(175.11,35.04) ; v1(63.37,122.16) PQS10.1
  TOP w0.457: v1(14.44,42.31) CU12.2 CU11.2 ; v1(77.83,101.97) 77.99,102.14 CD18.2 ; CD14.2 72.35,52.73 v1(72.35,52.74) ; CV76.2 119.51,124.41 v1(119.72,124.63) ; v1(32.52,32.85) 32.91,32.85 PRM11.2 ; v1(176.18,31.15) 176.82,31.79 PQ11.3 ; v1(121.7,57.65) 121.37,57.32 CC66.2 ; EU2601.3 v1(17.79,57.9) ; CD20.2 77.33,81.63 v1(77.32,81.64) ; PR16.2 89.96,151.96 v1(89.94,151.99) 90.45,152.5 PR15.2 ; v1(45.1,123.01) 45.26,123.16 PQS30.1 45.97,123.64 PR66.2 ; v1(53.3,107.96) 52.95,108.31 Q25.4 ; RC213.2 117.95,50.9 v1(117.95,51.45) ; v1(125.56,42.83) 125.82,42.83 126.39,43.39 CC65.2 126.39,44.46 CC64.2 ; CV73.2 120.71,134.43 CV74.2 121.29,134.76 v1(121.75,134.3) 121.75,133.79 CV112.2 ; v1(77.3,76.57) 77.32,76.55 CD23.2 ; v1(54.71,118.2) 54.54,118.36 PD1.1 ; PCV32.2 v1(67.81,125.04) ; PD6.1 v1(167.22,42.55) ; v1(43.84,125.43) PQS30.4 ; v1(24.72,88.68) 24.27,88.68 23.71,88.12 RL4.2 23.67,87.97 CL19.2 CL22.2
  TOP w0.508: v1(18.43,86.66) 18.43,87.28 18.77,87.61 UL2.2 19.55,87.61 CL15.2 ; RT94.1 30.58,104.85 v1(31.01,105.28) ; PRS30.2 62.75,116.98 v1(62.7,117.03) ; v1(98.96,47.37) 98.9,47.31 QC2.3 97.39,47.95 RC164.2 ; RL6.1 v1(15.19,88.67) ; CC100.2 118.95,60.14 v1(118.64,60.45) ; v1(69.62,88.94) 69.68,88.94 69.78,88.84 CD48.2 ; v1(76.5,56.82) 76.5,55.85 76.46,55.81 CD11.2 ; CT17.2 28.7,122.91 28.97,123.18 v1(29.38,123.18) ; CT50.2 17.77,124.74 17.26,125.26 v1(17.26,125.64) ; v1(65.97,124.98) 65.85,124.87 PRS29.2 65.75,124.15 PRS27.1 ; v1(17.75,53.66) 18.6,53.66 CU6.2 CU7.2 ; v1(42.01,114.03) 42.01,113.6 CT75.2 ; v1(83.66,110.51) 82.6,111.58 CZ40.2 ; v1(86.29,112.52) 86.29,113.03 85.94,113.38 CZ33.1 ; v1(34.32,123.3) 34.32,123.01 34.64,122.69 RT65.2 ; v1(31.59,60.47) 31.72,60.6 ED2901.1 ; v1(129.18,55.14) 129.46,55.14 129.92,55.6 CC75.2 ; RC60.2 104.36,40.55 v1(103.85,41.06) ; UW1.2 72.56,138.74 73.07,138.23 CW8.2 74.7,137.92 v1(75.65,136.96) ; v1(15.08,81.11) 15.51,80.68 YL1.2 ; v1(34.48,114.59) 34.01,114.12 CT76.2 ; v1(72.75,69.06) 72.68,69 CD10.1 ; RV369.2 126.03,120.29 126.03,121.02 v1(126.02,121.02) ; CV334.2 v1(159.62,114.81) ; CD46.2 59.31,86.83 v1(56.92,86.83) ; PQ2.3 56.76,114.36 v1(55.88,114.36) ; PCH13.2 159.08,49.01 v1(158.86,49.23) ; JVGA.17 v1(221.25,39.59) ; CV93.2 132.58,124.68 v1(132.64,124.74) ; v1(179.8,63.97) 179.8,64.26 C30.2 ; CD16.2 78.21,73.39 v1(77.25,72.44) ; v1(56.98,53.74) 57.27,53.45 CD43.2 ; v1(118.07,53.08) 118.07,53.41 117.56,53.92 RC201.2 ; R87.1 v1(220.07,25.59) ; CM7.2 76.3,29.62 v1(76.8,29.12) ; v1(178.41,62.68) 178.63,62.68 179.01,62.3 PCZ24.2 ; RV41.1 127.9,118.77 v1(127.07,117.94) ; RV41.1 128.33,119.39 128.62,119.1 RV40.1 130.1,119.1 130.66,119.66 CV84.2 130.66,121.19 CV86.2 130.45,121.41 v1(130.45,122.05) 130.45,122.13 130.01,122.56 CV85.2 ; RV41.1 127.9,119.95 128.18,120.23 RV17.1 ; v1(64.62,81.81) 64.67,81.75 CD52.2 ; v1(69.72,66.34) 69.87,66.34 70.03,66.5 70.75,66.5 RD12.2 ; v1(43.84,125.43) 44.41,125.99 PR62.2 ; v1(119.99,91.39) 120,91.4 120,92.06 119.67,92.39 PCG107.2 ; v1(46.95,42.02) 47.15,42.02 47.6,42.47 C34.2 EC3002.2 ; C57.2 40.75,96.25 v1(40.99,96.01) ; CV227.2 v1(165.76,129.02) ; v1(60.05,70.51) 59.64,70.51 RD22.2 ; v1(129.86,60.37) 129.75,60.26 CC60.2 ; CV92.2 133.98,122.05 v1(134.15,122.23) 134.44,122.23 134.95,121.72 134.95,121 CV91.2 ; v1(64.8,91.28) 65.25,91.74 CD54.2 ; v1(156.01,134.81) RV134.2 RV116.2 ; CD19.2 72.46,78.15 v1(72.75,78.43) ; PCS04.2 49.17,118.02 PRS05.2 v1(50.62,118.02) ; v1(19.89,43.04) 19.99,42.93 PC308.2 ; CZ25.2 CZ12.2 39.09,55.22 v1(38.79,54.92) 39.16,54.55 C1.2 ; PC309.2 23.08,43.42 v1(23.08,43.68) ; v1(54.26,78.09) 54.42,77.93 CE15.2 ; CT72.2 32.04,111.39 31.67,111.77 v1(31.59,111.77) ; DA4.1 v1(20.58,25.59) ; CA25.1 v1(20.47,10.66) ; CV247.2 v1(162.24,150.6) ; R45.2 122.25,44.12 v1(122.13,44.25) ; v1(106.83,44.62) 106.49,44.28 RC109.2 ; CT44.2 v1(12.35,119.68) ; CD51.2 64.64,78.52 v1(64.62,78.54) ; v1(67.76,114.24) CW4.2 CW3.2 ; v1(48.26,63.16) 48.49,63.39 RE48.2 CE23.2 ; CA17.2 v1(32.85,8.9) ; PRV18.2 v1(67.15,127.57) 67.2,127.62 PRV16.2 PCV20.2 ; v1(12.7,131) EU4011.1 ; v1(32.65,119.59) 32.4,119.35 UT4.2 ; v1(36.55,24.62) 36.76,24.41 PCM13.2 ; v1(50.07,112.97) 49.68,112.58 PCS03.2 ; CC37.2 105.93,86.84 106.23,86.53 v1(106.23,86.17) ; v1(34.78,9.58) CA40.2 CA9.2 ; PCM16.2 32.32,30.06 32.08,29.82 v1(32.08,29.54) 32.48,29.13 PCM15.2 ; v1(132.83,83.35) 132.58,83.59 RC134.2 ; RT27.2 RT28.2 16.57,124.85 16.57,125.45 v1(16.19,125.84) ; DA1.1 v1(18.51,4.69) ; v1(69.49,61.62) 69.69,61.62 RD11.2 ; v1(62.05,117.02) 62.05,117.85 PD3.2 ; v1(106.68,69.91) 106.68,69.72 CC32.2 ; v1(150.11,99.28) 149.93,99.28 149.73,99.08 PCG127.2 ; CV176.2 128.43,131.79 128.67,132.03 v1(128.67,132.26) ; C27.2 117.1,25.97 v1(116.29,25.97) 116.14,26.12 116.14,26.47 C26.2 ; v1(210.62,45.84) 210.37,45.59 209.65,45.59 PRB26.2 ; v1(164.88,145.09) 164.9,145.09 CV394.2 ; CD47.2 57.71,105.74 v1(56.84,105.74) ; EC2902.2 v1(221.65,66.95) ; RT82.2 31.85,113.46 v1(32.23,113.84) ; RD17.2 v1(54.77,42.27) ; PCZ33.2 v1(173.47,64.45) ; RV123.2 v1(156.43,150.6) ; v1(127.44,44.92) 126.94,45.42 CC78.2 ; CS30.2 178.85,30.65 v1(178.6,30.91) 178.6,31.47 CS29.2 ; CE14.2 30.93,71.92 v1(30.48,72.37) 30.87,72.75 RE32.2 ; v1(176.75,46.97) 177.01,46.71 PCB31.2 ; CE6.2 54.58,73.41 v1(55.05,73.41) ; 28.54,118.77 28.33,118.98 28.33,119.94 CT53.2 ; 28.54,118.77 QT4.3 ; 28.54,118.77 28.91,118.77 29.27,119.13 v1(29.27,119.5) ; CI9.2 18.26,98.17 17.97,97.87 v1(16.94,97.87) ; CC97.2 CC99.2 97.62,51.51 102.49,51.51 102.99,51 v1(102.99,50.89) 102.49,50.38 CC9.2 ; CE31.2 RE16.2 CE19.2 v1(51.74,87.79) ; CT6.2 31.88,123.66 v1(31.92,123.62) ; Q4.3 57.6,32.31 v1(57.6,30.01) ; v1(73.19,135.28) PRV02.2 PRV04.2 PRV05.2 ; CC57.2 122.46,61.77 v1(122.31,61.62) ; CA6.2 33.84,17.78 33.33,17.27 33.3,17.27 33.05,17.02 33.05,16.9 v1(33.03,16.9) 32.67,16.9 32.54,16.77 CA16.2 ; v1(58.2,133.41) 58.32,133.54 58.8,133.54 PCS21.2 ; v1(160.55,67.43) 160.59,67.39 PCI11.2 ; PC2504.2 72.73,116.77 73.34,116.77 73.63,116.48 v1(73.63,116.12) 73.62,116.11 PC2501.2 ; v1(98.06,30.45) 96.74,30.45 CM4.2 ; v1(103.38,55.55) 103.38,55.02 CC88.2 102.69,54.91 102.68,54.92 ; CC44.2 104.42,103.12 v1(104.78,103.48) ; RT73.2 RT71.2 48.54,105.48 v1(49.14,105.48) ; v1(165.78,120.95) CV390.2 165.13,119.9 CV225.2 ; CE5.2 37.92,64.4 v1(37.68,64.16) ; RC5.1 129.39,52.23 v1(129.51,52.11) ; v1(81.07,91.77) 81.22,91.91 CD17.2 ; PC508.2 23.95,98.58 v1(23.93,98.6) ; CC42.2 145.35,62.07 RC160.2 145.35,60.72 v1(145.13,60.5) ; v1(193.43,31.74) 193.22,31.53 PRB23.2 ; v1(133.8,51.44) 133.21,50.85 132.5,50.85 132.1,50.45 CC59.2 ; RU25.2 35.1,44.15 v1(34.46,43.52) ; RC224.2 46.91,100.03 v1(46.76,99.88) 46.62,99.74 C62.2 ; v1(211.32,55.8) 211.32,56.1 C3.2 211.74,57.41 C2.2 ; PCB37.2 v1(188.98,47.21) ; RC145.2 104.76,37.37 104.61,37.37 v1(104.12,36.89) 104.12,37.14 103.6,37.66 103.59,37.66 103.23,38.02 103.23,38.52 103.65,38.93 RC182.2 ; RE68.2 CE16.2 51.21,63.5 51.51,63.2 v1(51.92,63.2) 52.97,63.2 53.37,63.6 RE541.1 ; RC146.2 125.1,96.57 125.48,96.96 v1(125.48,96.98) ; CE3.2 32.2,70.97 32.7,71.48 v1(33.15,71.48) ; v1(149.37,59.63) 148.99,60.02 PCA101.2 ; RT100.1 34.46,102.35 v1(34.04,102.78) 33.91,102.65 CT71.2 ; v1(30.45,23.73) 30.43,23.76 EC3003.2 ; DE1.2 33.91,85.84 CE17.2 v1(33.83,85.12) ; JVGA.18 v1(222.99,29.45) ; v1(112.81,132.01) 113.04,131.77 CV35.2 ; CA38.1 v1(36.21,14.7) ; CV64.2 118.64,135.28 v1(118.64,135.8) 119.44,135.8 119.59,135.64 119.89,135.64 CV65.2 ; CZ46.1 78.72,113.3 78.72,113.17 78.93,112.96 v1(79,112.96) ; PQB04.3 193.44,34.18 v1(193.55,34.3) ; CE12.2 43.77,63.85 43.69,63.92 CE24.2 43.51,63.95 v1(42.67,63.95) ; CD56.2 64.63,66.9 v1(64.62,66.89) ; v1(53.55,81.21) 53.98,80.79 CE35.1 ; v1(30.44,106.73) RT116.1 ; v1(27.97,105.9) 27.97,104.88 28.34,104.52 RT98.1 ; v1(64.6,76.69) 64.62,76.67 CD50.2 ; v1(19.05,49.3) 19.45,49.7 CU14.2 CU13.2 ; v1(132.2,56.84) 132.2,56.49 132.71,55.98 RC7.2 ; CT74.2 RT75.2 46.79,110.08 v1(47.2,110.08) ; v1(76.88,63.59) 76.98,63.69 CD15.2 ; PRV27.2 78,122.61 v1(78.52,123.13) ; PQ16.3 88.73,147.71 v1(87.79,147.71) ; v1(39.43,132.48) 39.38,132.43 RT62.2 ; CV19.2 110.85,134.61 v1(110.85,134.25) ; DA5.1 v1(18.32,7.08) ; CE13.2 32.98,73.34 v1(32.98,73.2) ; CD58.2 57.75,64.94 v1(56.9,64.94) ; PRV09.2 69.03,132.93 PQS14.3 v1(69.65,134.36) ; RV53.2 RV135.2 v1(164.9,141.85) ; RV120.2 v1(153.71,114.96) ; v1(198.8,51.29) 199.25,51.75 PRB07.2 ; v1(64.48,125.6) 64.33,125.46 PQS07.3 ; RA18.2 v1(11.97,4.48) ; UU3.2 204.42,31.73 204.72,31.43 206.49,31.43 206.89,31.02 211.54,31.02 v1(212.2,31.68) ; RM13.1 76.4,33.18 v1(76.88,33.18) ; CE9.2 CE8.1 53.97,84.95 53.33,85.59 v1(53.33,85.68) ; JWWAN.32 220.11,63.94 219.6,64.44 219.6,64.46 v1(219.26,64.8) ; CE11.2 45.72,63.85 CE34.1 46.74,63.54 46.93,63.35 46.93,63.34 47.11,63.16 v1(47.11,62.32) ; v1(160.63,115) CV333.2 160.64,115.73 CV169.2 ; CD41.2 65.97,46.22 65.97,46.21 ; CT92.2 14.37,124.99 v1(15.24,124.13) ; DA2.1 v1(21.97,3.26) ; CV248.2 v1(163.18,150.6) ; PCM11.2 v1(50.4,27.96) ; v1(31.61,7.22) CA4.2 30.93,7.14 CA3.2 ; RE20.2 36.27,88 v1(35.66,87.38) ; v1(103.2,43.93) 103.14,43.87 103.14,43.75 RC110.2 ; v1(69.87,131.68) 69.57,131.38 PCV10.2 ; RE50.1 34.37,89.64 34.48,89.53 v1(34.67,89.53) ; v1(166.49,53.62) 165.84,53.62 PCH09.2 165.79,52.82 PRH02.2 ; PR44.1 173.03,28.93 172.72,28.62 v1(172.17,28.62) ; C16.2 213.14,42.35 v1(213.41,42.62) ; v1(131.05,51.46) 131.05,50.91 CC74.2 ; PR45.2 172.48,33 v1(172.48,31.69) ; CD53.2 60.04,81.75 v1(60.1,81.81) ; v1(146.01,51.27) CC76.2 ; PCV12.2 PCV11.2 v1(82.9,129.73) ; CW5.2 65.99,116.49 v1(65.99,116.49) ; v1(28.4,5.16) 27.95,5.61 CA27.2 ; v1(47.6,108.14) 47.6,108.43 48.06,108.89 RT67.2 RT69.2 ; v1(51.72,129.34) 52.25,129.87 PQS12.3 ; CE7.1 33.2,78.52 v1(33.54,78.52) ; CV198.2 v1(157.43,150.59) ; v1(163.92,32.78) 163.64,32.5 163.22,32.5 163.19,32.47 CZ22.2 CZ3.2 ; v1(135.94,28.51) 136.25,28.19 Q13.3 ; CE10.2 v1(46.13,65.99) ; CV336.2 v1(157.46,114.81) ; v1(117.32,128.69) 117.47,128.84 117.47,128.88 117.57,128.97 CV33.2 CV34.2 ; CV107.2 122.09,126.53 122.39,126.83 122.53,126.83 v1(122.67,126.96) ; Q24.3 65.3,35.18 C59.2 64.94,35.54 v1(64.94,36.34) ; v1(30.76,58.62) 30.43,58.29 EU2602.1 ; PCI12.2 159.19,67.71 v1(158.81,68.09) ; CV342.2 v1(164.9,139.63) ; v1(60.49,131.76) PCS11.2 PRS14.2 ; v1(145.72,39.51) 145.73,39.51 145.73,40.64 CC96.2 ; v1(32.2,43.52) CU23.2 RU24.2 RU23.2 ; CD49.2 64.64,70.49 v1(64.62,70.51) ; CV82.2 126.64,126.21 v1(126.04,126.21) 126.04,125.69 CV124.2 ; v1(79.03,116.7) 79.41,117.08 79.49,117.08 79.51,117.1 CZ37.2 81.58,117.1 81.89,117.41 CZ32.2 ; v1(33.55,20.18) CA15.1 CA5.1 ; CD25.2 77.33,66.9 v1(77.32,66.89) ; CD44.2 59.58,76.24 v1(60.03,76.69) ; v1(36.27,128.76) 36.22,128.71 CT91.1 35.48,128.01 RT63.2 ; v1(162.75,28.43) 162.75,28.87 CZ1.2 ; v1(32.75,12.89) CA22.1 33.42,13.33 32.98,13.77 CC98.2 ; PC1806.2 167.86,43.58 v1(168.03,43.41) ; CV46.2 114.13,140.47 114.64,139.96 v1(114.64,139.92) ; v1(23.56,5.63) 23.81,5.63 24.32,6.14 CA13.1 ; v1(183.75,34.55) 183.75,34.34 184.11,33.98 184.11,32.63 ; v1(18.93,6.76) 18.66,6.5 CA14.2 ; CU17.2 202.9,38.53 v1(202.79,38.53) ; v1(12.66,4.49) 12.76,4.59 RA17.2 ; v1(59.9,118.65) 60.54,118.65 PD2.2 ; v1(63.02,119.57) 63.41,119.18 PQS11.3 ; CL9.2 v1(12.63,86.44) ; PCB19.2 PCB20.2 199.91,47.54 198.96,46.59 v1(198.6,46.59) ; QI1.3 25.46,91.42 25.13,91.09 v1(25.13,91.02) ; C31.2 204.73,35.9 v1(204.71,35.92) 204.63,35.85 CU16.2 ; v1(21.99,51.61) 22.27,51.61 22.83,52.17 PC312.2 ; CD42.2 65.21,58.46 65.2,58.47 v1(64.99,58.47) ; CD21.2 CD22.2 77.32,78.4 v1(77.32,78.4) ; CZ23.2 35.21,57.92 v1(35.3,57.83) ; RL2.1 19.02,79.76 v1(18.87,79.92) 18.87,80.31 CL11.1 ; CL20.2 28.04,79.54 v1(27.87,79.37) ; v1(45.75,116.32) 45.83,116.25 PCS02.2 PRS06.2 ; CD29.2 67.98,83.94 v1(68.19,83.73) ; RE539.1 40.88,89.2 CE26.2 40.85,89.17 40.85,88.87 40.24,88.26 v1(40.08,88.26) ; v1(210.37,42.8) 210.35,42.82 PCB45.2 PRB33.2 ; RT81.2 45.68,113.97 v1(45.55,114.1) ; v1(112.02,137.79) 111.92,137.89 111.92,138.3 CV61.2 ; v1(22.97,24.98) 23.28,25.29 RA22.2 25.74,25.29 EC2302.2 ; RT99.1 37.97,102.36 v1(37.56,102.76) ; v1(164.94,146.55) 164.96,146.55 CV343.2 ; v1(41.13,86.31) 41.13,86.97 CE20.2 ; C14.2 C15.2 211.5,44 v1(211.5,43.26) ; PC303.2 v1(16.94,43.47) ; v1(38.2,93.91) 38.28,93.83 RE62.2 ; v1(122.23,93.05) 121.8,92.62 121.8,92.57 121.76,92.53 PCG117.2 ; CA29.2 v1(25.02,1.43) ; v1(119.51,119.22) 119.94,119.65 CV125.2 CV80.2 ; v1(88.05,46.15) 88.05,48.36 87.41,48.99 86.06,48.99 EC3001.2 85.84,48.76 Q8.3 ; v1(112.52,138.87) 113.22,138.87 RV16.2 CV15.2 ; v1(101.97,41.14) 102.03,41.08 CC85.2 ; v1(67.9,65.08) 67.9,65.1 68.31,65.5 RD6.2 ; CV179.2 CV39.2 111.5,131.24 CV27.2 111.48,130.59 110.96,130.59 v1(110.76,130.79) ; v1(107.44,52.4) 106.19,51.14 CC8.2 ; CT73.2 v1(43.91,102.12) ; PCV31.2 71.9,120.59 v1(72.28,120.22) ; CV242.2 164.9,135.52 164.88,135.5 v1(164.88,135.38) ; C17.2 207.96,50.94 v1(207.87,51.03) ; CL10.1 19.04,83.6 v1(18.84,83.8) ; EC2901.2 v1(32.98,64.37) 32.98,65.03 CE33.2 ; PCM14.2 33.44,23.41 v1(33.44,23.24) ; JWWAN.31 221.2,46.84 v1(221.2,46.99) ; PC509.2 v1(19.1,103.07) ; v1(105.5,98.66) 105.5,97.64 105.18,97.32 104.03,97.32 103.04,98.31 CC1.2 ; CT45.2 12.03,120.76 v1(12.77,121.49) ; v1(164.96,58.94) 164.96,58.13 PCA08.2 ; CZ9.2 38.25,59.89 v1(38.41,59.72) ; CC49.2 118.34,67.07 v1(118.11,66.84) ; CE28.2 v1(55.06,71.8) ; v1(76.94,74.78) 77.25,75.09 CD24.2 ; RC144.2 v1(124.93,93.18) ; v1(203.66,39.1) 203.66,40.07 PCB35.2 PCB38.2 204.86,40.34 PCB43.2 ; RV29.1 118.26,139.79 118.95,139.79 RV59.1 119.18,140.54 v1(119.01,140.72) ; PRV10.2 71.79,135.49 CW9.2 CW7.2 v1(70.25,135.56) ; CZ6.2 158.56,33.34 v1(159.13,32.77) 159.2,32.77 159.7,33.28 CZ2.2 ; RD16.2 55.41,45.52 56.35,46.45 56.35,47.51 v1(56.52,47.68) ; v1(30.12,60.88) 29.73,60.88 29.4,60.55 SW1.2 ; v1(124.81,61.74) 124.84,61.71 CC83.2 ; v1(77.72,47.52) 78.18,47.98 CD13.2 ; CV341.2 164.9,137.92 v1(164.88,137.92) ; PCH11.2 165.78,50.22 PRH04.2 166.28,49.46 v1(166.48,49.67) ; v1(41.88,33.1) 41.46,33.1 PCM21.2 ; v1(81.07,142.62) PCS16.2 ; v1(23.14,132.62) QT3.3 ; CS8.2 182.85,41.8 v1(183.12,41.8) ; v1(127.34,124.48) 127.34,124.45 CV81.2 ; PCW13.2 v1(148.94,112.67) ; CD26.2 71.84,107.36 71.9,107.29 72.08,107.29 v1(72.18,107.19) ; PU1.2 82.89,143.85 v1(82.37,143.33) ; v1(56.22,115.99) 55.69,115.99 PR6.2 ; v1(86.97,112.54) 87.28,112.23 CZ36.2 ; v1(63.14,114.54) 63.64,114.54 PC2502.2 ; v1(68.18,28.86) 68.08,28.86 R79.1 ; v1(22.87,128.92) 22.47,128.51 RT32.2 ; PCB36.2 v1(187.28,49.36) ; CD55.2 v1(64.95,102.09) ; v1(90.72,147.11) 91.4,147.11 PC21.2 ; CT14.2 32.48,116.74 v1(32.71,116.51) ; CE22.2 v1(45.15,90.48) ; CA28.2 25.26,4.99 CA30.2 24.55,5.23 v1(24.55,5.37) ; PCZ03.2 181.37,56.72 182.15,56.72 PRZ01.2 182.74,56.74 v1(182.81,56.82) ; R2.2 43.15,49.2 45.01,49.2 v1(45.05,49.23) 45,49.23 Q1.3 ; RT13.2 RT12.2 20.39,120.12 19.76,119.5 v1(19.76,118.23) ; RV118.2 v1(165.76,123.62) ; PC2503.2 73.71,109.57 v1(73.71,109.14) ; v1(127.25,25.07) 127.05,25.27 C19.2 127.9,25.74 R40.2 ; CC5.2 102.75,44.6 v1(103.25,44.6) ; CV243.2 v1(161.28,150.6) ; CC86.2 122.66,49.29 122.98,48.97 v1(122.98,48.97) 122.94,48.94 122.7,48.94 122.34,48.57 120.38,48.57 119.74,47.93 CC56.2 ; v1(107.03,103.21) 107.03,103.5 106.52,104 CC90.2 ; DA7.1 v1(18.1,24.44) ; v1(69.71,65.15) 70.14,65.57 CD28.2 ; U3.2 v1(212.84,34.01) ; v1(83.89,37.83) 83.89,38.17 83.85,38.21 CM6.2 ; PCI10.2 163.45,69.52 v1(162.72,68.79) ; EU4012.1 52.1,90.13 v1(52.64,90.67) ; CV211.2 v1(159.34,150.59) ; YL1.4 v1(17.84,83.96) ; UZ1.9 v1(160.31,32.81) ; C61.2 65.77,30.11 v1(65.61,30.26) 65.61,30.46 65.9,30.74 C60.2 ; RW11.1 67.71,138.48 67.66,138.43 v1(67.66,137.49) ; v1(128.08,52.36) 128.08,51.84 128.26,51.66 CC58.2 128.25,51.36 CZ21.2 ; CA1.2 v1(31.6,4.74) ; RA9.2 v1(39.45,14.49) ; RD21.2 57.86,66.13 57.42,65.7 v1(56.96,65.7) 56.49,65.7 RD18.2 ; PCS01.1 54.96,119.71 54.07,118.82 PD1.1 ; CV210.2 v1(160.3,150.6) ; CC28.2 106.43,63.98 v1(106.43,64.37) ; v1(169.81,31.67) PR40.2 ; CE32.1 35.67,67.13 v1(35.28,67.52) ; RV49.2 v1(165.76,122.74) ; CV344.2 164.96,148.63 164.75,148.84 v1(164.75,148.97) ; v1(165.15,30.48) 165.69,31.02 R10.2 165.65,31.85 165.48,31.85 ; CT93.2 19.48,128.62 20.01,129.15 v1(20.01,129.7) ; CD45.2 60.3,78.02 60.81,78.52 v1(60.81,78.54) ; v1(104.89,65.71) CC27.2 ; RE53.1 36.94,89.66 36.5,90.1 v1(36.5,90.19) ; v1(42.5,114.56) 42.76,114.3 RT84.2 RT78.2 ; CC38.2 104.57,69.63 v1(104.57,69.91) ; CM3.2 91.46,30.27 v1(90.6,31.13) ; CC62.2 CC63.2 CC101.2 143.76,42 v1(143.32,42.45) ; v1(76.5,64.95) 76.5,65.06 77,65.56 77.59,65.56 CD12.2 ; CV335.2 v1(158.54,114.81) ; v1(27.88,121.66) 28.12,121.42 RT121.2 ; CV213.2 v1(158.38,150.59) ; v1(61.6,127.14) PCS17.2
  GND1 w0.203: H10.1 101.31,132.53 ; H10.1 101.31,128.16 ; H10.1 102.91,128.75 ; H10.1 99.71,128.75 ; H10.1 102.91,131.94 ; H10.1 99.71,131.94 ; H10.1 99.13,130.35 ; H10.1 103.49,130.35 ; 5.37,124.74 JUSBC1.1 ; JUSBC1.1 5.37,126.29 ; JUSBC1.1 7.83,124.74 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 5.37,125.52 ; 135.1,37.38 HCPU4.1 ; HCPU4.1 137.38,37.38 ; HCPU4.1 139.67,39.81 ; HCPU4.1 139.67,42.23 ; HCPU4.1 137.38,42.23 ; HCPU4.1 135.1,39.81 ; HCPU4.1 135.1,42.23 ; HCPU4.1 139.67,37.38 ; 13.85,28.72 JUSB2.7 ; JUSB2.7 14.38,28.58 ; JUSB2.7 14.91,29.78 ; JUSB2.7 14.38,29.92 ; JUSB2.7 13.85,29.78 ; JUSB2.7 14.91,28.72 ; JUSB2.7 15.05,29.25 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 3.27,87.7 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 3.27,86.77 ; 6.9,110.52 H8.1 ; H8.1 5.38,111.08 ; H8.1 8.98,112.6 ; H8.1 4.82,112.6 ; H8.1 5.38,114.12 ; H8.1 8.42,111.08 ; H8.1 8.42,114.12 ; H8.1 6.9,114.68 ; H7.1 142.97,28.52 ; H7.1 139.62,27.1 ; H7.1 142.97,25.68 ; H7.1 143.48,27.1 ; H7.1 140.13,28.52 ; H7.1 141.55,29.03 ; H7.1 141.55,25.17 ; H7.1 140.13,25.68 ; 1.67,65.08 JLAN1.11 ; JLAN1.11 4.03,65.08 ; JLAN1.11 4.03,66.42 ; JLAN1.11 2.85,66.42 ; JLAN1.11 4.03,65.75 ; JLAN1.11 1.67,66.42 ; JLAN1.11 1.67,65.75 ; JLAN1.11 2.85,65.08 ; 10.59,99.89 JHDMI1.17 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 10.59,100.81 ; JHDMI1.17 10.47,100.35 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 11.63,100.35 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 6.1,116.1 ; JUSBC1.3 5.38,118.11 ; JUSBC1.3 6.82,116.1 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 5.38,117.18 ; JUSBC1.3 5.38,116.1 ; JUSBC1.5 3.02,126.35 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 1.6,124.69 ; JUSBC1.5 1.6,126.35 ; JUSBC1.5 3.02,124.69 ; JUSB2.13 7.77,37.1 ; JUSB2.13 5.03,37.98 ; JUSB2.13 6.4,37.98 ; JUSB2.13 7.77,37.98 ; JUSB2.13 5.03,37.1 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 11.47,104.1 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 12.75,103.17 ; 44.01,131.39 H12.1 ; H12.1 44.01,128.41 ; H12.1 46.99,128.41 ; H12.1 46.99,131.39 ; H12.1 45.5,127.87 ; H12.1 45.5,131.93 ; H12.1 43.47,129.9 ; H12.1 47.53,129.9 ; 10.59,94.81 JHDMI1.5 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 10.47,94.35 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 11.51,93.89 ; 12.14,92.39 JHDMI1.2 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 12.14,93.31 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 12.6,92.26 ; JHDMI1.2 13.18,92.85 ; 9.47,65.75 JLAN1.12 ; JLAN1.12 10.65,66.42 ; JLAN1.12 10.65,65.08 ; JLAN1.12 9.47,65.08 ; JLAN1.12 11.83,65.08 ; JLAN1.12 9.47,66.42 ; JUSB1.7 15.05,53.15 ; JUSB1.7 14.38,52.48 ; JUSB1.7 14.91,53.68 ; JUSB1.7 13.85,53.68 ; JUSB1.7 13.85,52.62 ; JUSB1.7 14.38,53.82 ; JUSB1.7 14.91,52.62 ; 211.42,65.5 H13.1 ; H13.1 211.42,63.57 ; H13.1 213.85,63.57 ; H13.1 211.42,67.43 ; H13.1 216.28,63.57 ; H13.1 213.85,67.43 ; H13.1 216.28,65.5 ; H13.1 216.28,67.43 ; 113.08,37.35 HCPU3.1 ; HCPU3.1 113.08,42.2 ; HCPU3.1 114.85,38.01 ; HCPU3.1 110.66,39.78 ; HCPU3.1 114.85,41.54 ; HCPU3.1 115.51,39.78 ; HCPU3.1 111.31,41.54 ; HCPU3.1 111.31,38.01 ; H1.1 8.27,129.08 ; H1.1 6.85,132.43 ; H1.1 5.43,129.08 ; H1.1 8.78,130.5 ; H1.1 8.27,131.92 ; H1.1 4.92,130.5 ; H1.1 6.85,128.57 ; H1.1 5.43,131.92 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.88,50.32 ; JUSB1.4 15.35,50.18 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.35,49.12 ; JUSB1.4 16.41,50.18 ; JUSB1.4 15.88,48.98 ; JUSB1.4 15.21,49.65 ; 141.35,115.58 H9.1 ; H9.1 141.35,118.77 ; H9.1 142.95,114.99 ; H9.1 140.77,117.18 ; H9.1 144.55,118.77 ; H9.1 144.55,115.58 ; H9.1 145.13,117.18 ; H9.1 142.95,119.36 ; 5.97,85.8 H4.1 ; H4.1 7.9,87.73 ; H4.1 9.32,84.38 ; H4.1 6.48,87.22 ; H4.1 6.48,84.38 ; H4.1 7.9,83.87 ; H4.1 9.83,85.8 ; H4.1 9.32,87.22 ; JUSB2.10 15.28,22.28 ; JUSB2.10 15.28,21.4 ; JUSB2.10 11.72,20.52 ; JUSB2.10 11.72,21.4 ; JUSB2.10 13.5,20.52 ; 11.72,44.42 JUSB1.10 ; JUSB1.10 11.72,45.3 ; JUSB1.10 15.28,46.18 ; JUSB1.10 13.5,44.42 ; JUSB1.10 15.28,44.42 ; JUSB1.10 15.28,45.3 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 5.37,116.1 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 5.37,116.88 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 2.02,106.93 ; JHDMI1.21 4.58,106 ; JHDMI1.21 2.02,106 ; JHDMI1.21 3.3,105.07 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 3.02,116.88 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 1.6,116.05 ; 110.66,100.81 HCPU1.1 ; HCPU1.1 115.51,98.52 ; HCPU1.1 115.51,103.09 ; HCPU1.1 113.08,103.09 ; HCPU1.1 113.08,98.52 ; HCPU1.1 110.66,98.52 ; HCPU1.1 110.66,103.09 ; HCPU1.1 115.51,100.81 ; JLAN1.9 11.83,83.22 ; JLAN1.9 10.65,83.22 ; JLAN1.9 9.47,82.55 ; JLAN1.9 9.47,81.88 ; JLAN1.9 10.65,81.88 ; JLAN1.9 11.83,82.55 ; JLAN1.9 11.83,81.88 ; JLAN1.9 9.47,83.22 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 6.1,126.3 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 5.38,125.22 ; JUSBC1.2 6.82,124.29 ; 5.03,45.3 JUSB1.11 ; JUSB1.11 7.77,45.3 ; JUSB1.11 5.03,44.42 ; JUSB1.11 7.77,44.42 ; JUSB1.11 6.4,44.42 ; 15.35,25.22 JUSB2.4 ; JUSB2.4 15.88,26.42 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.88,25.08 ; JUSB2.4 15.21,25.75 ; JUSB2.4 16.41,26.28 ; JUSB2.4 16.55,25.75 ; JUSB2.4 15.35,26.28 ; H5.1 9.42,42.62 ; H5.1 8,43.13 ; H5.1 6.58,39.78 ; H5.1 6.07,41.2 ; H5.1 9.42,39.78 ; H5.1 9.93,41.2 ; H5.1 6.58,42.62 ; H5.1 8,39.27 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 11.47,89.6 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 12.75,88.67 ; JUSB1.12 15.28,61.88 ; JUSB1.12 15.28,61 ; JUSB1.12 15.28,60.12 ; JUSB1.12 11.72,61.88 ; JUSB1.12 13.5,61.88 ; JUSB1.12 11.72,61 ; JUSB2.11 7.77,20.52 ; JUSB2.11 5.03,21.4 ; JUSB2.11 7.77,21.4 ; JUSB2.11 6.4,20.52 ; JUSB2.11 5.03,20.52 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 12.02,95.85 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 13.06,95.39 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.59,96.89 ; JHDMI1.11 10.47,97.35 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 10.59,97.81 ; JHDMI1.11 11.63,97.35 ; HCPU2.1 139.05,102.44 ; HCPU2.1 135.71,99.11 ; HCPU2.1 135.71,102.44 ; HCPU2.1 137.38,103.06 ; HCPU2.1 137.38,98.49 ; HCPU2.1 139.67,100.78 ; HCPU2.1 139.05,99.11 ; HCPU2.1 135.09,100.78 ; H6.1 207.45,65.78 ; H6.1 206.03,62.43 ; H6.1 209.38,63.85 ; H6.1 205.52,63.85 ; H6.1 208.87,62.43 ; H6.1 206.03,65.27 ; H6.1 208.87,65.27 ; H6.1 207.45,61.92 ; 5.03,61 JUSB1.13 ; JUSB1.13 7.77,61.88 ; JUSB1.13 5.03,61.88 ; JUSB1.13 6.4,61.88 ; JUSB1.13 7.77,61 ; JUSB2.12 15.28,37.1 ; JUSB2.12 15.28,36.22 ; JUSB2.12 11.72,37.98 ; JUSB2.12 13.5,37.98 ; JUSB2.12 11.72,37.1 ; 1.67,83.22 JLAN1.10 ; JLAN1.10 2.85,81.88 ; JLAN1.10 4.03,82.55 ; JLAN1.10 1.67,81.88 ; JLAN1.10 1.67,82.55 ; JLAN1.10 2.85,83.22 ; JLAN1.10 4.03,83.22 ; JLAN1.10 4.03,81.88
  VCC w0.203: 10.65,65.08 JLAN1.12 ; JLAN1.12 11.83,65.08 ; JLAN1.12 9.47,65.75 ; JLAN1.12 9.47,66.42 ; JLAN1.12 9.47,65.08 ; JLAN1.12 10.65,66.42 ; 5.03,61 JUSB1.13 ; JUSB1.13 7.77,61.88 ; JUSB1.13 5.03,61.88 ; JUSB1.13 7.77,61 ; JUSB1.13 6.4,61.88 ; 15.35,25.22 JUSB2.4 ; JUSB2.4 16.55,25.75 ; JUSB2.4 15.21,25.75 ; JUSB2.4 15.35,26.28 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.88,26.42 ; JUSB2.4 15.88,25.08 ; JUSB2.4 16.41,25.22 ; 12.02,95.85 JHDMI1.8 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 13.06,96.31 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 5.37,116.88 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 5.37,116.1 ; JUSBC1.4 7.83,117.65 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 12.6,92.26 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 12.14,93.31 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 5.38,125.22 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 6.1,126.3 ; 110.66,103.09 HCPU1.1 ; HCPU1.1 113.08,103.09 ; HCPU1.1 110.66,100.81 ; HCPU1.1 115.51,98.52 ; HCPU1.1 113.08,98.52 ; HCPU1.1 115.51,103.09 ; HCPU1.1 110.66,98.52 ; HCPU1.1 115.51,100.81 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 2.02,106 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 4.58,106 ; JHDMI1.21 2.02,106.93 ; 5.03,45.3 JUSB1.11 ; JUSB1.11 7.77,44.42 ; JUSB1.11 5.03,44.42 ; JUSB1.11 7.77,45.3 ; JUSB1.11 6.4,44.42 ; H1.1 8.78,130.5 ; H1.1 5.43,131.92 ; H1.1 8.27,129.08 ; H1.1 6.85,128.57 ; H1.1 4.92,130.5 ; H1.1 6.85,132.43 ; H1.1 8.27,131.92 ; H1.1 5.43,129.08 ; JUSB2.7 14.38,29.92 ; JUSB2.7 13.85,28.72 ; JUSB2.7 13.85,29.78 ; JUSB2.7 14.91,28.72 ; JUSB2.7 15.05,29.25 ; JUSB2.7 14.38,28.58 ; JUSB2.7 14.91,29.78 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.47,97.35 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 10.59,97.81 ; JHDMI1.11 10.59,96.89 ; JHDMI1.11 11.63,97.35 ; 11.47,104.1 JHDMI1.20 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 12.75,103.17 ; JHDMI1.20 12.75,105.03 ; 13.85,53.68 JUSB1.7 ; JUSB1.7 15.05,53.15 ; JUSB1.7 14.91,52.62 ; JUSB1.7 14.91,53.68 ; JUSB1.7 13.85,52.62 ; JUSB1.7 14.38,52.48 ; JUSB1.7 14.38,53.82 ; 10.47,94.35 JHDMI1.5 ; JHDMI1.5 11.51,93.89 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 10.59,94.81 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 11.51,94.81 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 5.38,117.18 ; JUSBC1.3 6.1,116.1 ; JUSBC1.3 6.82,116.1 ; JUSBC1.3 5.38,118.11 ; JUSB1.12 15.28,61.88 ; JUSB1.12 11.72,61.88 ; JUSB1.12 11.72,61 ; JUSB1.12 15.28,61 ; JUSB1.12 13.5,61.88 ; JUSB1.12 15.28,60.12 ; 6.07,41.2 H5.1 ; H5.1 8,39.27 ; H5.1 6.58,39.78 ; H5.1 9.93,41.2 ; H5.1 9.42,39.78 ; H5.1 9.42,42.62 ; H5.1 6.58,42.62 ; H5.1 8,43.13 ; JLAN1.10 4.03,82.55 ; JLAN1.10 1.67,83.22 ; JLAN1.10 4.03,83.22 ; JLAN1.10 1.67,82.55 ; JLAN1.10 1.67,81.88 ; JLAN1.10 2.85,81.88 ; JLAN1.10 4.03,81.88 ; JLAN1.10 2.85,83.22 ; JUSB2.12 15.28,37.1 ; JUSB2.12 13.5,37.98 ; JUSB2.12 11.72,37.1 ; JUSB2.12 15.28,36.22 ; JUSB2.12 11.72,37.98 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 3.27,87.7 ; JUSB2.13 6.4,37.98 ; JUSB2.13 7.77,37.1 ; JUSB2.13 5.03,37.98 ; JUSB2.13 7.77,37.98 ; JUSB2.13 5.03,37.1 ; 11.72,20.52 JUSB2.10 ; JUSB2.10 15.28,22.28 ; JUSB2.10 13.5,20.52 ; JUSB2.10 15.28,21.4 ; JUSB2.10 11.72,21.4 ; JLAN1.11 4.03,66.42 ; JLAN1.11 1.67,65.08 ; JLAN1.11 4.03,65.08 ; JLAN1.11 2.85,66.42 ; JLAN1.11 2.85,65.08 ; JLAN1.11 1.67,66.42 ; JLAN1.11 4.03,65.75 ; JLAN1.11 1.67,65.75 ; 7.9,83.87 H4.1 ; H4.1 6.48,84.38 ; H4.1 9.32,87.22 ; H4.1 9.83,85.8 ; H4.1 9.32,84.38 ; H4.1 6.48,87.22 ; H4.1 7.9,87.73 ; H4.1 5.97,85.8 ; 12.75,88.67 JHDMI1.23 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 11.47,89.6 ; JHDMI1.23 11.47,90.53 ; 15.88,48.98 JUSB1.4 ; JUSB1.4 15.35,50.18 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.21,49.65 ; JUSB1.4 15.35,49.12 ; JUSB1.4 15.88,50.32 ; JUSB1.4 16.41,49.12 ; JUSB1.4 16.41,50.18 ; JUSBC1.5 3.02,124.69 ; JUSBC1.5 3.02,126.35 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 1.6,126.35 ; JUSBC1.5 1.6,124.69 ; JUSB2.11 7.77,21.4 ; JUSB2.11 5.03,21.4 ; JUSB2.11 6.4,20.52 ; JUSB2.11 7.77,20.52 ; JUSB2.11 5.03,20.52 ; JLAN1.9 11.83,83.22 ; JLAN1.9 9.47,83.22 ; JLAN1.9 9.47,82.55 ; JLAN1.9 11.83,82.55 ; JLAN1.9 11.83,81.88 ; JLAN1.9 10.65,81.88 ; JLAN1.9 10.65,83.22 ; JLAN1.9 9.47,81.88 ; 10.59,99.89 JHDMI1.17 ; JHDMI1.17 10.47,100.35 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 10.59,100.81 ; JHDMI1.17 11.51,99.89 ; H8.1 8.98,112.6 ; H8.1 6.9,114.68 ; H8.1 8.42,114.12 ; H8.1 4.82,112.6 ; H8.1 5.38,114.12 ; H8.1 5.38,111.08 ; H8.1 6.9,110.52 ; H8.1 8.42,111.08 ; 11.72,45.3 JUSB1.10 ; JUSB1.10 15.28,46.18 ; JUSB1.10 15.28,45.3 ; JUSB1.10 15.28,44.42 ; JUSB1.10 13.5,44.42 ; JUSB1.10 11.72,44.42 ; 5.37,125.52 JUSBC1.1 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 7.83,124.74 ; JUSBC1.1 5.37,124.74 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 5.37,126.29 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 3.02,116.88 ; JUSBC1.6 1.6,116.05 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 3.02,117.71
  GND2 w0.203: 10.65,65.08 JLAN1.12 ; JLAN1.12 9.47,66.42 ; JLAN1.12 9.47,65.75 ; JLAN1.12 10.65,66.42 ; JLAN1.12 9.47,65.08 ; JLAN1.12 11.83,65.08 ; 8,39.27 H5.1 ; H5.1 9.93,41.2 ; H5.1 9.42,39.78 ; H5.1 9.42,42.62 ; H5.1 6.58,42.62 ; H5.1 6.07,41.2 ; H5.1 8,43.13 ; H5.1 6.58,39.78 ; JUSB2.7 14.91,29.78 ; JUSB2.7 13.85,28.72 ; JUSB2.7 14.91,28.72 ; JUSB2.7 14.38,28.58 ; JUSB2.7 14.38,29.92 ; JUSB2.7 13.85,29.78 ; JUSB2.7 15.05,29.25 ; 44.01,128.41 H12.1 ; H12.1 47.53,129.9 ; H12.1 46.99,128.41 ; H12.1 45.5,131.93 ; H12.1 46.99,131.39 ; H12.1 45.5,127.87 ; H12.1 44.01,131.39 ; H12.1 43.47,129.9 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 12.75,103.17 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 11.47,104.1 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 11.47,105.03 ; H9.1 145.13,117.18 ; H9.1 144.55,115.58 ; H9.1 141.35,118.77 ; H9.1 144.55,118.77 ; H9.1 141.35,115.58 ; H9.1 140.77,117.18 ; H9.1 142.95,114.99 ; H9.1 142.95,119.36 ; 140.13,25.68 H7.1 ; H7.1 143.48,27.1 ; H7.1 141.55,29.03 ; H7.1 139.62,27.1 ; H7.1 142.97,25.68 ; H7.1 140.13,28.52 ; H7.1 141.55,25.17 ; H7.1 142.97,28.52 ; 15.88,48.98 JUSB1.4 ; JUSB1.4 15.35,50.18 ; JUSB1.4 15.21,49.65 ; JUSB1.4 15.35,49.12 ; JUSB1.4 16.41,50.18 ; JUSB1.4 16.55,49.65 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.88,50.32 ; 5.38,126.3 JUSBC1.2 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 6.1,126.3 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 5.38,125.22 ; JUSB2.4 16.41,25.22 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.88,25.08 ; JUSB2.4 15.35,26.28 ; JUSB2.4 15.35,25.22 ; JUSB2.4 16.55,25.75 ; JUSB2.4 15.21,25.75 ; JUSB2.4 15.88,26.42 ; JUSB1.7 15.05,53.15 ; JUSB1.7 14.38,53.82 ; JUSB1.7 14.38,52.48 ; JUSB1.7 13.85,52.62 ; JUSB1.7 13.85,53.68 ; JUSB1.7 14.91,53.68 ; JUSB1.7 14.91,52.62 ; JHDMI1.21 4.58,106 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 2.02,106.93 ; JHDMI1.21 2.02,106 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 3.3,105.07 ; 12.14,96.31 JHDMI1.8 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 12.02,95.85 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 13.18,95.85 ; 206.03,62.43 H6.1 ; H6.1 208.87,65.27 ; H6.1 206.03,65.27 ; H6.1 209.38,63.85 ; H6.1 208.87,62.43 ; H6.1 207.45,61.92 ; H6.1 207.45,65.78 ; H6.1 205.52,63.85 ; JUSB2.13 7.77,37.1 ; JUSB2.13 6.4,37.98 ; JUSB2.13 5.03,37.1 ; JUSB2.13 7.77,37.98 ; JUSB2.13 5.03,37.98 ; 12.14,92.39 JHDMI1.2 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 12.14,93.31 ; JHDMI1.2 12.6,92.26 ; 11.72,20.52 JUSB2.10 ; JUSB2.10 15.28,22.28 ; JUSB2.10 15.28,21.4 ; JUSB2.10 11.72,21.4 ; JUSB2.10 13.5,20.52 ; 124.52,154.54 H11.1 ; H11.1 124.52,151.56 ; H11.1 127.5,154.54 ; H11.1 126.01,155.08 ; H11.1 127.5,151.56 ; H11.1 126.01,151.02 ; H11.1 128.04,153.05 ; H11.1 123.98,153.05 ; H13.1 216.28,63.57 ; H13.1 211.42,67.43 ; H13.1 213.85,67.43 ; H13.1 211.42,63.57 ; H13.1 213.85,63.57 ; H13.1 216.28,65.5 ; H13.1 211.42,65.5 ; H13.1 216.28,67.43 ; 11.72,61 JUSB1.12 ; JUSB1.12 15.28,61 ; JUSB1.12 15.28,61.88 ; JUSB1.12 11.72,61.88 ; JUSB1.12 15.28,60.12 ; JUSB1.12 13.5,61.88 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 10.47,100.35 ; JHDMI1.17 10.59,99.89 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 10.59,100.81 ; HCPU1.1 113.08,103.09 ; HCPU1.1 110.66,100.81 ; HCPU1.1 113.08,98.52 ; HCPU1.1 115.51,98.52 ; HCPU1.1 115.51,103.09 ; HCPU1.1 115.51,100.81 ; HCPU1.1 110.66,103.09 ; HCPU1.1 110.66,98.52 ; JHDMI1.5 11.51,93.89 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 10.47,94.35 ; JHDMI1.5 10.59,94.81 ; JHDMI1.5 11.63,94.35 ; 3.27,87.7 JHDMI1.22 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 5.83,88.63 ; HCPU2.1 139.67,100.78 ; HCPU2.1 139.05,99.11 ; HCPU2.1 137.38,98.49 ; HCPU2.1 137.38,103.06 ; HCPU2.1 135.71,99.11 ; HCPU2.1 139.05,102.44 ; HCPU2.1 135.71,102.44 ; HCPU2.1 135.09,100.78 ; 11.72,37.1 JUSB2.12 ; JUSB2.12 13.5,37.98 ; JUSB2.12 11.72,37.98 ; JUSB2.12 15.28,36.22 ; JUSB2.12 15.28,37.1 ; HCPU3.1 113.08,42.2 ; HCPU3.1 114.85,41.54 ; HCPU3.1 111.31,38.01 ; HCPU3.1 114.85,38.01 ; HCPU3.1 110.66,39.78 ; HCPU3.1 115.51,39.78 ; HCPU3.1 111.31,41.54 ; HCPU3.1 113.08,37.35 ; 5.43,131.92 H1.1 ; H1.1 8.27,129.08 ; H1.1 6.85,132.43 ; H1.1 5.43,129.08 ; H1.1 6.85,128.57 ; H1.1 4.92,130.5 ; H1.1 8.78,130.5 ; H1.1 8.27,131.92 ; 6.48,84.38 H4.1 ; H4.1 7.9,87.73 ; H4.1 9.32,84.38 ; H4.1 9.32,87.22 ; H4.1 7.9,83.87 ; H4.1 6.48,87.22 ; H4.1 5.97,85.8 ; H4.1 9.83,85.8 ; JUSB1.13 7.77,61 ; JUSB1.13 7.77,61.88 ; JUSB1.13 6.4,61.88 ; JUSB1.13 5.03,61 ; JUSB1.13 5.03,61.88 ; JUSB1.10 15.28,45.3 ; JUSB1.10 15.28,46.18 ; JUSB1.10 11.72,45.3 ; JUSB1.10 11.72,44.42 ; JUSB1.10 15.28,44.42 ; JUSB1.10 13.5,44.42 ; H8.1 8.42,114.12 ; H8.1 8.98,112.6 ; H8.1 6.9,110.52 ; H8.1 5.38,114.12 ; H8.1 5.38,111.08 ; H8.1 8.42,111.08 ; H8.1 4.82,112.6 ; H8.1 6.9,114.68 ; JUSB2.11 7.77,20.52 ; JUSB2.11 6.4,20.52 ; JUSB2.11 5.03,20.52 ; JUSB2.11 5.03,21.4 ; JUSB2.11 7.77,21.4 ; HCPU4.1 139.67,39.81 ; HCPU4.1 139.67,42.23 ; HCPU4.1 139.67,37.38 ; HCPU4.1 137.38,42.23 ; HCPU4.1 135.1,37.38 ; HCPU4.1 137.38,37.38 ; HCPU4.1 135.1,39.81 ; HCPU4.1 135.1,42.23 ; H10.1 102.91,128.75 ; H10.1 99.71,128.75 ; H10.1 99.71,131.94 ; H10.1 99.13,130.35 ; H10.1 101.31,128.16 ; H10.1 101.31,132.53 ; H10.1 102.91,131.94 ; H10.1 103.49,130.35 ; 5.38,116.1 JUSBC1.3 ; JUSBC1.3 5.38,117.18 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 5.38,118.11 ; JUSBC1.3 6.1,116.1 ; JUSBC1.3 6.82,116.1 ; 11.47,90.53 JHDMI1.23 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 11.47,89.6 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 12.75,88.67 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 14.03,88.67 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 5.37,124.74 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 5.37,126.29 ; JUSBC1.1 7.83,124.74 ; JUSBC1.1 5.37,125.52 ; JUSBC1.5 3.02,126.35 ; JUSBC1.5 1.6,124.69 ; JUSBC1.5 3.02,124.69 ; JUSBC1.5 1.6,126.35 ; JUSBC1.5 3.02,125.52 ; 1.6,116.05 JUSBC1.6 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 3.02,116.88 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 1.6,117.71 ; 6.4,44.42 JUSB1.11 ; JUSB1.11 7.77,45.3 ; JUSB1.11 5.03,45.3 ; JUSB1.11 5.03,44.42 ; JUSB1.11 7.77,44.42 ; JLAN1.11 4.03,65.08 ; JLAN1.11 1.67,66.42 ; JLAN1.11 4.03,65.75 ; JLAN1.11 2.85,66.42 ; JLAN1.11 4.03,66.42 ; JLAN1.11 1.67,65.08 ; JLAN1.11 1.67,65.75 ; JLAN1.11 2.85,65.08 ; JLAN1.10 4.03,82.55 ; JLAN1.10 1.67,83.22 ; JLAN1.10 1.67,81.88 ; JLAN1.10 4.03,83.22 ; JLAN1.10 4.03,81.88 ; JLAN1.10 1.67,82.55 ; JLAN1.10 2.85,81.88 ; JLAN1.10 2.85,83.22 ; 9.47,81.88 JLAN1.9 ; JLAN1.9 9.47,82.55 ; JLAN1.9 9.47,83.22 ; JLAN1.9 11.83,82.55 ; JLAN1.9 11.83,81.88 ; JLAN1.9 10.65,81.88 ; JLAN1.9 11.83,83.22 ; JLAN1.9 10.65,83.22 ; 10.47,97.35 JHDMI1.11 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 10.59,97.81 ; JHDMI1.11 10.59,96.89 ; JHDMI1.11 11.51,96.89 ; 5.37,116.1 JUSBC1.4 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 5.37,116.88 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 7.83,117.65
  BOTTOM w0.089: v1(142.24,75.48) 141.11,74.34 141.11,71.15 140.6,70.65 139.53,70.65 139.39,70.79 137.76,70.79 137.41,71.13 135.38,71.13 135.36,71.15 135.13,71.15 135.11,71.13 134.73,71.13 134.63,71.23 133.46,71.23 UC1.F37 ; RC151.2 141.7,69.54 138.22,69.54 137.34,68.66 135.37,68.66 135.36,68.67 135.13,68.67 135.12,68.66 134.77,68.66 133.8,69.64 133.56,69.64 UC1.F35
  BOTTOM w0.127: v1(164.75,148.97) v3(164.75,149.84) ; v1(136.13,49.79) 137.09,49.52 137.66,48.99 138.24,48.46 139.42,47.6 140.77,47.04 144.66,47.04 144.71,47.08 v1(145.76,47.08) ; v1(164.88,145.09) v3(164.88,145.91) ; v1(143.21,43.24) 140.24,45.4 139.58,46.06 138.72,46.55 137.25,47.56 136.34,48.29 135.85,48.68 134.93,49.39 134.45,49.39 133.7,50.14 UC1.F1 ; v1(164.88,135.38) v3(164.88,134.45) ; v3(13.9,112.53) RI16.2 ; v3(165.15,119.41) CV216.2 ; 151.42,46.67 v3(151.42,45.55) ; v1(125.48,96.98) 125.49,96.98 v3(126.09,96.38) ; v1(29.02,94.01) 29.02,93.2 v3(29.07,93.15) ; v1(113.34,83.88) 113.38,83.85 UC1.BB60 ; CV164.2 v3(162.01,115.74) ; v3(107.81,148.65) v1(108.37,149.21) ; 106.08,117.41 v3(106.97,117.41)
  BOTTOM w0.152: v1(117.77,91.31) 117.72,91.26 UC1.AT71 ; UC1.BB67 113.92,88.29 v1(113.34,88.87) ; UC1.AG71 122.73,90.47 122.76,90.5 122.76,90.93 122.83,91 122.83,91.27 v1(122.93,91.38)
  BOTTOM w0.178: UC1.AM71 120.08,90.58 120.08,91.31 v1(119.99,91.39) ; UC1.BB43 113.31,74.08 v1(113.29,74.1) ; UC1.BB26 113.49,64.14 113.44,64.09 v1(113.28,64.09) ; UC1.BB34 113.97,69.12 112.69,69.12 v1(112.65,69.16)
  BOTTOM w0.203: UC1.AP68 118.96,88.29 120.12,88.29 UC1.AM68 120.56,88.35 120.65,88.26 120.92,88.26 121.33,88.67 UC1.AK68 121.52,88.67 UC1.AH67 ; v1(121.7,79.03) 121.39,78.71 UC1.AL52 ; v1(113.39,86.24) 113.43,86.2 UC1.BB64 ; v1(113.08,66.36) 113.21,66.5 UC1.BB30 ; UC1.AN58 v1(119.33,83.3) ; JKB1.30 82.95,35.3 v1(82.95,35.3) ; UT3.5 30.98,129.04 v1(31.3,128.71) ; UC1.F38 v1(132.78,72.31) UC1.F40 ; UC1.AW26 116.27,64.12 116.27,64.74 116.19,64.81 UC1.AW28 ; v1(183.75,34.55) 183.75,34.63 184.2,35.08 JHDD.8 ; UC1.BA2 114.38,50.45 UC1.BA1 114.29,49.91 v1(113.82,49.91) ; UC1.AW16 116.19,59.45 116.28,59.54 116.28,59.94 116.19,60.02 UC1.AW18 116.19,60.68 116.49,60.98 ; UC1.D18 134.59,60.23 135.53,60.23 UC1.B18 ; UC1.AW30 116.3,66.7 116.3,67.35 116.19,67.45 UC1.AW32 ; v1(115.06,48.87) 115.34,48.87 115.66,49.2 115.79,49.2 116.05,49.46 116.09,49.46 116.4,49.77 UC1.AV1 ; UC1.AW23 116.19,62.47 116.26,62.4 116.26,61.65 UC1.AW21 ; UV1.F22 132.33,137.61 132.58,137.61 v1(132.58,137.61) ; v1(113.28,81.25) 113.28,81.25 UC1.BB55 ; UC1.AW34 116.19,69.51 116.22,69.54 116.22,69.83 116.19,69.86 UC1.AW36 116.19,70.74 116.22,70.77 116.22,71.06 116.19,71.09 UC1.AW38 116.19,71.8 v1(116.7,72.31) 116.24,72.78 UC1.AW41 116.19,73.24 116.22,73.27 116.22,73.56 116.19,73.59 UC1.AW43 ; UC1.AW12 116.3,56.85 116.3,57.44 116.19,57.55 UC1.AW14 ; UC1.H71 v1(132.33,91.17) ; UC1.F37 132.84,70.61 132.84,70.48 133.17,70.15 UC1.F35 ; UC1.AW51 116.19,78.46 116.29,78.36 116.29,78.08 116.19,77.99 UC1.AW49 ; UV1.AF32 116.14,144.51 v1(115.95,144.69) ; UC1.AW62 116.19,84.73 116.25,84.67 116.25,84.1 116.19,84.05 UC1.AW60 ; UC1.BA18 UC1.BB18 113.41,60.4 v1(113.41,60.4) ; UC1.AW6 116.18,53.19 115.03,53.19 UC1.BA6 UC1.BB6 114.16,53.22 113.54,53.22 113.48,53.16 v1(113.33,53.16) ; UC1.AT68 117.68,88.31 116.55,88.31 UC1.AV68 ; UC1.BB38 113.26,71.48 v1(113.22,71.44) ; UC1.C1 135.78,49.79 v1(136.13,49.79) ; v1(134.83,132.91) 134.67,132.91 134.58,133 UV1.B16 ; v1(121.4,76.88) UC1.AL48 ; UC1.AP58 v1(118.67,83.27) ; UZ5.11 v1(124.23,111.1) ; v1(121.45,80.54) UC1.AL55 ; UV1.AH32 v1(114.2,143.86) ; UV1.K2 128.94,122.08 v1(128.84,121.99) ; v1(122.98,48.97) 123.09,49.09 UC1.AF1
  BOTTOM w0.22: UV1.B20 134.53,136.2 v1(134.64,136.31) ; v1(134.5,129.48) 134.18,129.8 UV1.B12 ; UV1.B22 134.44,137.8 v1(135,138.36) ; UV1.B14 134.22,131.32 134.75,131.32 v1(134.81,131.27) ; v1(135.04,134.6) UV1.B18
  BOTTOM w0.25: v1(134.62,139.38) 134.6,139.38 134.6,139.4 UV1.B24 ; UV1.B26 134.14,141.48 v1(134.13,141.48) ; UV1.H17 130.73,134 131.35,134.62 v1(131.6,134.62) ; UV1.G31 131.35,143.81 131.35,143.88 131.16,144.07 131.16,144.45 v1(131.63,144.92)
  BOTTOM w0.254: v1(121.71,85.77) 122.01,86.07 UC1.AH64 ; v1(121.71,85.77) 122.06,85.42 UC1.AH63 ; v1(121.71,85.77) UC1.AK63 UC1.AM61 ; UC1.AR8 118.02,54.8 v1(118.02,54.94) ; 115.64,67.82 115.6,67.82 ; 115.64,67.82 UC1.AW32 116.19,68.29 116.5,68.6 v1(116.6,68.6) ; 115.64,67.82 v1(115.62,67.84) 115.6,67.82 ; 115.6,67.82 UC1.BA32 ; PUW01.8 142.45,110.08 142.45,110.44 141.63,111.26 141.63,111.37 141.72,111.46 141.73,111.46 141.74,111.45 141.74,111.4 ; UV14.H14 v1(155.91,118.74) ; UC1.G55 132.52,80.83 v1(132.84,80.51) ; UC1.B58 135.54,82.54 v1(135.09,82.54) 134.59,82.54 UC1.D58 134.49,82.58 UC1.E56 ; UC1.K18 131.11,59.94 131.48,59.57 ; UC1.L18 130.27,60.11 130.02,60.37 v1(129.86,60.37) 129.86,59.86 130.27,59.45 UC1.L17 130.16,59.31 130.16,58.88 UC1.L16 ; UC1.N65 v1(129.07,87.11) ; UV14.H13 v1(155.51,119.71) ; v1(119.3,68.75) 119.3,68.53 UC1.AN32 119.31,67.88 v1(119.31,67.73) 119.31,67.63 119.63,67.31 UC1.AN30 ; v1(143.21,43.24) 143.37,43.09 144.54,43.09 144.81,42.82 148.02,42.82 148.03,42.82 148.06,42.82 148.19,42.95 148.19,46.79 147.95,47.03 145.81,47.03 v1(145.76,47.08) ; UV14.N14 v1(152.31,118.91) ; UV14.L5 v1(153.11,126.11) UV14.M5 ; 120.78,52.2 121.03,51.94 UC1.AJ4 ; 120.78,52.2 v1(120.78,52.3) ; 120.78,52.2 120.52,51.94 UC1.AL4 120.44,51.9 120.24,51.7 120.24,51.33 120.44,51.13 UC1.AL2 ; UV14.M10 v1(153.11,122.91) UV14.L10 ; v1(118.02,59.5) 118.02,59.37 UC1.AR16 118.33,58.96 v1(117.97,58.6) 118.33,58.23 UC1.AR15 ; v1(156.71,140.09) 156.71,140.09 UV12.L5 ; UV14.P10 v1(151.51,122.11) ; UC1.AW36 v1(115.54,70.3) UC1.BA36 ; UC1.AM13 120.47,57.41 v1(120.73,57.41) 120.67,57.48 120.67,58.39 UC1.AK16 121.05,58.87 120.53,59.39 v1(120.53,59.52) 120.53,59.55 UC1.AK18 ; v1(119.32,70.39) UC1.AN37 119.63,70.97 v1(119.24,71.42) ; UV12.A12 148.71,145.13 v1(149.11,144.73) ; v1(220.13,31.77) 220.02,31.66 JFP.1 ; UV14.F5 v1(157.11,126.11) UV14.G5 ; UC1.B34 v1(135.06,70.19) UC1.D34 ; UC1.N68 v1(129.07,88.35) ; UC1.B66 UC1.D66 134.17,87.15 v1(134.17,87.12) 134.17,86.93 UC1.E65 ; UC1.E18 134.06,60.21 v1(134.06,60.43) 134.4,60.43 UC1.D18 ; v1(127.86,142.32) 128.14,142.04 UV1.L27 ; UC1.C25 v1(134.95,64.93) UC1.D26 134.19,65.23 133.95,65 UC1.J25 ; UC1.B39 135.29,72.95 v1(134.95,72.95) 134.84,72.95 UC1.D39 ; UC1.AP10 v1(118.55,55.83) 118.55,55.87 118.33,56.08 UC1.AR11 ; PUH01.8 164.08,52.05 v1(164.27,52.24) ; UV14.N3 v1(152.31,127.71) ; UV14.E3 v1(157.91,128.51) ; v1(158.32,118.78) 158.32,119.04 158.32,119.03 158.32,119.3 UV14.E14 ; UC1.B48 135.36,77.41 v1(135.11,77.41) 134.9,77.62 UC1.D48 134.55,77.45 134.59,77.41 UC1.D47 134.24,76.94 v1(134.11,76.81) 134.11,76.72 UC1.E46 ; UC1.G48 132.69,77.39 v1(132.88,77.72) ; UC1.C5 134.98,52.52 134.9,52.52 UC1.D6 134.29,52.6 134.29,52.54 UC1.F4 133.7,51.55 v1(133.8,51.44) 133.7,51.34 UC1.F2 133.78,50.89 133.78,50.4 UC1.F1 ; UV1.F2 132.13,122.98 132.13,121.99 v1(132.15,121.99) ; UC1.AD62 v1(124.46,85.67) ; UC1.AR28 UC1.AP28 UC1.AN28 119.68,66.33 119.68,66.06 UC1.AM27 ; UC1.AR28 118.33,66.59 118.11,66.82 ; UC1.AR28 UC1.AT28 118.11,66.8 118.11,66.82 ; UV12.B5 149.51,139.53 v1(149.91,139.93) ; UV14.G10 v1(157.11,122.91) UV14.F10 ; v1(108.62,32.74) 108.39,32.97 UX1.9 ; UV1.F6 132.27,125 132.53,124.74 v1(132.64,124.74) ; UC1.G66 v1(132.59,88.2) ; v1(136.51,91.05) UC1.B71 UC1.A70 ; v1(149.05,135.93) 148.71,136.28 UV12.A1 ; UC1.AT58 v1(117.97,83.29) UC1.AR58 ; UC1.AN33 119.63,69.18 v1(119.27,69.54) ; UV14.U12 148.34,120.54 v1(148.26,120.54) ; v1(123.71,57.04) 124.06,57.04 UC1.AD13 ; UV1.K32 129.12,144.37 v1(129.65,144.37) 129.74,144.29 UV1.J31 ; UV1.F14 132.14,131.28 v1(132.46,130.96) ; v1(124.81,61.74) 124.44,61.37 UC1.AD20 UC1.AD19 ; v1(124.81,61.74) 124.96,61.74 UC1.AB21 125.39,62.17 125.92,62.17 UC1.Y21 126.13,61.97 126.13,61.42 UC1.Y20 ; v1(124.81,61.74) 124.53,62.02 UC1.AD21 ; UV14.T10 v1(149.91,122.11) ; UX1.16 111.89,32.97 v1(111.67,32.74) ; v1(70.34,127.27) 70.44,127.27 70.81,126.9 JWLAN1.26 ; UC1.L2 v1(131.05,51.46) UC1.L4 ; UV12.C4 149.91,138.33 v1(149.11,138.33) 148.71,137.93 UV12.A3 ; UC1.E21 134.11,62.09 v1(134.11,62.27) 134.11,62.31 UC1.D22 134.78,62.75 134.88,62.65 135.47,62.65 UC1.B22 ; UC1.L20 130.12,61.37 v1(129.79,61.7) 129.47,62.02 UC1.N21 ; UC1.BA66 UC1.AY66 v1(116.1,87.88) UC1.AW66 116.28,87.35 116.28,86.39 UC1.AW64 116.24,86.26 116.24,85.48 116.19,85.44 UC1.AW62 v1(115.66,85.02) UC1.BA62 ; UX1.23 112.24,29.97 111.97,29.7 v1(111.67,29.7) ; UV12.M10 157.11,143.13 v1(157.1,143.13) 157.1,143.14 UV12.L10 ; UV1.G8 131.44,126.49 131.86,126.49 131.96,126.6 UV1.F8 132.37,126.6 132.42,126.55 132.61,126.55 v1(132.63,126.53) ; UZ4.5 132.77,115.41 v1(132.59,115.23) ; UC1.AF10 123.05,55.32 v1(122.79,55.07) ; v1(10.61,122.42) 10.24,122.78 DT4.2 ; UV1.M6 127.34,124.49 v1(127.34,124.48) ; UC1.H15 v1(132.14,58.6) 131.28,58.6 UC1.K16 131.48,59.14 131.48,59.57 ; UC1.B14 UC1.D14 134.08,57.8 133.97,57.68 v1(133.42,57.68) ; v1(151.72,135.76) 151.91,135.94 UV12.E1 ; UC1.AA65 v1(125.36,87.11) ; UC1.AM27 UC1.AM25 120.29,64.43 v1(119.96,64.11) 119.96,64.09 119.63,63.76 UC1.AN23 UC1.AP23 UC1.AR23 118.26,63.7 117.76,63.7 UC1.AT23 ; UC1.AM27 120.74,65.91 UC1.AL28 ; UC1.AM27 UC1.AK27 ; UV14.U1 v1(148.24,130.17) ; v1(161.92,144.73) 161.91,144.73 161.51,145.13 UV12.U12 ; v1(133.42,57.68) 133.17,57.43 UC1.F13 ; v1(133.42,57.68) 133.42,57.74 UC1.E15 133.82,58.3 v1(134.1,58.58) ; UC1.AM61 120.29,84.53 v1(119.95,84.19) 120.29,83.86 UC1.AM60 ; UC1.AM61 120.29,84.77 v1(119.95,85.11) ; UX1.32 108.39,29.47 v1(108.62,29.7) ; v1(125.66,61.1) 126.04,60.72 UC1.Y19 UC1.V18 ; UC1.AM43 120.3,74.6 UC1.AL45 120.74,75.06 UC1.AM45 120.29,75.55 v1(119.88,75.95) 120.29,76.35 UC1.AM46 v1(119.89,76.88) ; UC1.U10 127.2,55.62 v1(127.11,55.62) ; UC1.AW60 116.33,83.61 116.33,83.03 116.19,82.9 UC1.AW57 ; UC1.A5 136.63,52.26 v1(136.93,51.96) ; UC1.F22 133.18,62.81 132.86,63.19 v1(132.79,63.19) ; JHDD.8 184.2,36.38 183.94,36.63 182.98,36.63 182.7,36.36 JHDD.5 182.7,34.76 v1(182.53,34.59) 182.03,34.59 181.7,34.91 JHDD.3 ; v1(130.63,91.14) 130.98,90.8 UC1.K71 UC1.K70 ; UC1.AT42 UC1.AR42 118.33,73.81 v1(118.64,74.11) ; UC1.AF2 UC1.AF1 ; UV12.F10 152.71,143.53 v1(153.11,143.13) 153.51,143.52 UV12.G10 ; 132.84,70.48 UC1.J35 ; v1(123.77,124.66) 124.11,125 UV1.T6 ; YV1.2 109.31,142.96 CV18.2 109.68,142.32 109.3,141.94 105.88,141.94 105.6,142.22 105.6,146.09 106.94,147.43 110.11,147.43 110.3,147.23 110.3,145.14 111.85,143.59 v1(111.94,143.59) ; UC1.AK69 121.4,89.38 v1(121.18,89.16) 121.4,88.94 UC1.AK68 ; UC1.AW45 116.19,75.67 116.24,75.72 116.24,76.02 116.19,76.06 UC1.AW47 116.19,76.84 116.24,76.88 116.24,77.19 116.19,77.23 UC1.AW49 ; UC1.AW45 116.19,74.82 116.24,74.77 116.24,74.4 116.19,74.36 UC1.AW43 ; UC1.AW45 v1(115.69,75.26) UC1.BA45 ; v1(118.64,74.11) 118.98,73.77 ; v1(118.64,74.11) 118.33,74.42 UC1.AR43 118.33,74.63 v1(117.91,75.05) UC1.AR45 v1(117.91,75.98) 118.33,76.4 UC1.AR46 117.99,76.77 v1(117.99,76.89) 117.99,76.99 UC1.AR48 118.01,77.67 v1(118.01,77.84) 118.01,77.93 UC1.AR50 117.96,78.63 v1(117.96,78.72) 117.96,78.8 UC1.AR52 117.97,79.53 v1(117.97,79.6) 117.97,79.72 UC1.AR53 118.03,80.38 v1(118.03,80.55) 118.03,80.7 UC1.AR55 v1(117.98,81.47) UC1.AT56 ; 118.98,73.77 UC1.AP42 ; 118.98,73.77 118.98,73.81 v1(119.29,74.11) 119.63,73.77 UC1.AN42 119.31,73.36 v1(119.31,73.13) 119.31,73.09 UC1.AN40 ; UV12.U14 161.51,146.73 161.11,147.12 v1(161.11,147.13) ; UC1.BA10 115.48,55.55 v1(115.69,55.34) 115.9,55.55 UC1.AW10 116.27,55.48 116.27,54.98 v1(116.35,54.9) ; UC1.J13 131.29,57.22 131.7,56.81 ; UV14.A14 161.51,119.31 v1(161.88,118.94) ; UC1.E71 134.18,90.67 v1(134.18,91.16) ; UC1.G5 132.79,52.92 v1(132.79,53.09) 132.79,53.3 UC1.G6 ; v1(133.6,68.63) 133.6,68.68 UC1.F33 ; v1(133.6,68.63) UC1.F32 ; v1(133.6,68.63) 133.62,68.64 133.33,68.64 133.32,68.65 UC1.J32 ; UV14.A1 161.51,129.76 v1(161.17,130.1) ; UV1.C32 134.13,144.59 v1(134.13,144.62) ; UC1.G45 132.52,75.42 v1(132.82,75.12) 132.52,74.82 UC1.G43 ; UV12.F5 152.71,139.53 v1(153.11,139.93) 153.51,139.53 UV12.G5 ; UC1.T15 127.71,58.12 127.34,58.49 v1(127.33,58.49) 127.19,58.49 UC1.V16 126.88,58.8 126.88,59.38 UC1.V17 ; UV14.N12 v1(152.31,120.51) ; UC1.G43 132.07,74.14 UC1.J42 ; UC1.G43 132.52,74.53 132.76,74.3 132.76,74.18 v1(132.81,74.13) 132.81,74.05 UC1.F42 ; v1(151.49,143.18) 151.14,143.53 UV12.D10 ; UV12.R4 159.91,138.73 v1(160.31,138.33) 159.91,137.93 UV12.R3 ; UV1.B10 135.08,128.2 135.12,128.16 v1(135.49,128.16) ; v1(156.37,93.1) PUG01.14 ; UC1.BA49 112.03,77.66 v1(111.97,77.73) ; UV12.N3 158.31,137.93 157.91,138.33 v1(157.9,138.33) ; v1(126.04,126.21) 126.04,125.3 UV1.P6 ; UV1.J27 v1(129.74,142.45) ; UC1.AL38 v1(121.53,71.4) ; UC1.AB15 v1(125.66,58.43) UC1.AB16 ; UV12.T5 160.71,139.53 v1(160.31,139.93) ; UC1.B44 135.43,75.14 135.36,75.07 134.9,74.94 134.76,74.94 UC1.D44 134.44,75.03 134.06,75.03 v1(134.03,75.07) 134.03,75.2 134.59,75.76 UC1.D45 ; UV1.G27 131.28,141.86 v1(131.28,142.5) ; v1(132.79,63.19) 133.17,63.63 UC1.F23 ; v1(132.79,63.19) UC1.G22 UC1.K22 ; v1(124.81,59.11) 124.81,59.71 125.18,60.07 UC1.AB18 ; UC1.V17 UC1.Y17 ; UC1.V17 UC1.V18 ; v1(135.19,126.29) 134.96,126.29 134.65,126.6 UV1.B8 ; UC1.U63 v1(127.19,85.72) UC1.U64 ; UC1.AW26 116.19,63.73 116.27,63.65 116.27,63.38 116.19,63.3 UC1.AW23 115.54,62.84 v1(115.54,62.85) 115.53,62.84 UC1.BA23 ; UC1.AT68 118.11,88.35 118.18,88.28 118.46,88.28 118.52,88.35 UC1.AP68 v1(118.9,88.92) UC1.AP70 ; UV1.AD32 v1(117.74,144.82) ; v1(156.06,130.36) 155.91,130.2 UV14.H1 155.97,129.65 155.97,128.97 UV14.H2 ; UV12.U3 161.51,137.93 161.12,138.32 v1(161.12,138.33) ; v1(134.15,122.23) 133.78,122.6 UV1.C1 ; v1(150.72,137.52) 150.32,137.93 UV12.C3 ; JSSD1.9 37.38,36.31 v1(37.42,36.36) ; UC1.BA71 114.07,90.93 v1(113.83,90.93) 113.83,90.24 UC1.BB70 ; UV14.C4 160.31,127.71 v1(161.11,127.71) UV14.A3 ; v1(128.45,143.37) 128.45,143.35 128.7,143.09 128.7,142.9 128.94,142.66 UV1.K28 ; UC1.AW14 v1(115.56,57.97) UC1.BA14 ; UV1.AC24 UV1.AD25 117.74,140.26 v1(117.39,140.61) ; UC1.R13 129,57.71 v1(129,57.78) 129.51,57.27 UC1.N13 ; UV12.E3 151.91,137.93 v1(152.31,137.52) ; v1(116.35,54.9) 116.35,54.8 116.19,54.64 UC1.AW8 ; v1(116.35,54.9) 116.54,54.9 UC1.AU10 ; UC1.N6 129.51,52.6 v1(129.51,52.11) 128.9,52.72 UC1.R6 128.56,52.11 UC1.T4 UC1.T2 ; v1(121.4,67.74) UC1.AL32 ; UC1.N10 129.45,55.14 v1(129.18,55.14) ; UV14.E12 v1(157.91,120.51) ; UV1.F26 132.14,141.16 132.52,141.54 v1(132.52,142.1) 132.52,142.18 UV1.E28 ; UV12.E12 v1(152.31,145.53) ; 127.2,89.65 UC1.U69 v1(127.19,88.96) ; 127.2,89.65 v1(127.19,89.65) ; 127.2,89.65 127.38,89.83 127.38,89.83 127.53,89.97 UC1.U70 ; v1(160.02,135.76) 159.91,135.87 UV12.R1 ; v1(150.16,147.24) 150.31,147.09 UV12.C14 ; UV12.H2 UV12.H1 154.31,135.76 v1(154.31,135.76) ; v1(124.01,59.09) 124.33,58.77 UC1.AD16 ; UV1.F20 132.3,136.2 132.44,136.34 v1(132.6,136.34) ; v1(131.6,134.62) 131.62,134.6 UV1.F18 ; 131.48,59.57 UC1.H18 ; UV14.C1 159.91,130.05 v1(160.18,130.32) ; v1(150.2,130.27) 150.31,130.17 UV14.R1 ; UC1.U67 v1(127.19,87.69) ; UC1.B53 135.52,80.15 134.88,80.15 134.83,80.1 UC1.D53 134.49,80.1 v1(134.05,80.54) UC1.E53 ; UV1.AB32 119.7,144.56 v1(119.7,144.76) ; v1(116.09,91.19) UC1.AV71 UC1.AV70 UC1.AV69 116.33,88.82 v1(116.24,88.73) 116.24,88.62 UC1.AV68 ; UV12.R12 159.91,145.13 160.31,144.73 v1(160.31,144.73) 160.31,144.72 159.91,144.33 UV12.R11 ; 118.11,66.82 v1(118.11,66.84) ; UV14.A12 161.51,120.91 161.81,120.61 v1(162.08,120.61) ; UV12.R14 159.91,146.73 160.31,146.33 v1(160.31,146.33) 160.31,146.32 159.91,145.93 UV13.C13 ; UC1.W13 126.11,57.27 v1(125.84,57.01) ; UC1.G60 132.52,83.62 132.79,83.35 v1(132.83,83.35) 132.81,83.33 132.81,83.11 UC1.G58 ; DT3.2 v1(10.24,124.77) ; UC1.AT35 UC1.AR35 UC1.AP35 118.98,69.83 v1(119.27,69.54) ; UC1.F27 v1(133.41,65.91) UC1.F28 132.72,66.83 UC1.J28 ; UV14.K2 UV14.K1 154.31,130.2 v1(154.34,130.23) ; UV14.C14 159.91,118.94 v1(160.06,118.79) ; CC6.2 143.64,76.37 143.64,77.44 143.89,77.69 146.43,77.69 v1(146.44,77.71) 147.07,77.71 147.32,77.45 147.32,73.64 147.13,73.45 144.75,73.45 v1(144.65,73.36) ; v1(158.33,135.76) 158.31,135.78 UV12.N1 ; UV12.C1 150.31,136.22 v1(149.98,135.9) ; v1(151.9,147.25) 151.91,147.24 UV12.E14 ; v1(118.07,53.08) 118.07,52.92 UC1.AR5 ; UV14.E1 157.9,130.12 v1(157.9,130.22) ; UV14.N1 151.91,130.25 151.91,130.26 v1(151.91,130.29) ; v1(119.72,124.63) 119.35,125 UV1.AB6 ; v1(124.5,144.99) 124.14,144.63 UV1.T32 ; UV12.B10 149.51,143.53 v1(149.91,143.93) 150.31,144.32 UV12.C11 ; v1(119.95,62.25) 120.29,61.92 UC1.AM21 ; v1(117.34,57.69) 117.34,57.83 UC1.AU15 ; UV14.B5 160.47,126.27 v1(160.47,126.07) ; v1(132.85,85.14) 132.85,85.36 UC1.G63 ; v1(158.7,143.93) 158.71,143.93 159.11,143.53 UV12.P10 ; UV12.K1 155.91,136.32 v1(156.31,136.72) 155.91,137.12 UV12.K2 ; v1(116.7,72.31) UC1.AU38 ; UC1.BA41 115.43,72.78 v1(115.57,72.64) 115.7,72.78 UC1.AW41 ; UV12.A14 v1(148.34,147.1) ; v1(119.27,69.54) 119.63,69.9 UC1.AN35 ; UC1.AW34 116.19,69 v1(116.6,68.6) ; UC1.D30 135.08,67.71 v1(135.08,67.71) 135.09,67.71 UC1.B30 ; UV14.C11 v1(160.31,122.11) UV14.B10 ; UC1.AD8 124.53,54.26 v1(124.83,54.26) 125.13,54.26 UC1.AB8 ; UC1.J38 v1(132.78,72.31) ; UC1.L8 130.22,53.67 v1(130.07,53.67) ; v1(122.56,53.06) 122.51,53.06 UC1.AH6 122.52,52.37 122.67,52.37 UC1.AF4 ; v1(121.71,87.67) UC1.AH67 ; v1(160.31,143.93) 160.31,143.93 160.71,143.53 UV12.T10 ; v1(156.31,145.53) 155.91,145.93 UV12.K13 ; UC1.V18 UC1.T18 127.66,59.98 127.66,59.51 UC1.T17 128.09,59.08 v1(128.22,59.08) 128.55,59.42 UC1.P17 ; UC1.F8 133.17,54.68 132.85,55 v1(132.85,55.04) 132.52,55.36 UC1.G10 133.05,55.92 133.43,55.92 UC1.E11 134.28,56.31 UC1.D11 134.59,55.36 UC1.D10 v1(135.06,55.32) UC1.B10 ; UC1.AW18 UC1.BA18 ; v1(133.75,124.72) 134.02,125 UV1.B6 ; v1(153.97,118.85) 153.97,118.91 154.31,119.25 UV14.K14 ; 110.38,142.59 111.19,141.77 v1(112.71,141.77) ; UV14.R11 v1(149.91,121.31) UV14.R12 ; UC1.W9 126.85,54.67 127.05,54.47 v1(127.04,54.47) ; UV1.AD8 117.75,126.6 v1(118.11,126.24) ; UV1.AE7 116.94,125.75 v1(117.29,125.4) 117.69,125 UV1.AD6 ; 131.7,56.81 131.7,56.79 131.49,56.58 131.49,56.58 131.23,56.32 131.23,56.32 UC1.J11 130.87,56.31 130.87,56.31 130.57,56.01 UC1.L11 ; 131.7,56.81 132.17,56.81 v1(132.2,56.84) ; UV14.C12 v1(160.31,120.51) ; UC1.AW53 116.34,79.92 116.34,79.55 116.24,79.44 116.24,78.9 UC1.AW51 ; UC1.AW53 UC1.BA53 ; UC1.AW53 116.24,80.11 116.24,80.83 116.19,80.88 UC1.AW55 116.19,81.66 116.27,81.74 116.27,82.08 116.19,82.16 UC1.AW57 ; UC1.B62 UC1.D62 134.16,85.05 v1(134.07,85.14) ; UV15.C13 v1(149.91,119.71) UV14.R14 ; v1(150.67,144.67) 150.31,145.04 UV12.C12 ; v1(220.22,32.36) 220.3,32.36 221.02,31.64 JFP1.1 ; UC1.E6 133.96,53.57 v1(134.24,53.84) ; v1(120.77,54.48) 120.9,54.48 121.22,54.15 UC1.AK8 ; UC1.AW57 116.55,82.55 116.69,82.4 117.29,82.4 v1(117.35,82.34) ; UV1.H2 130.53,122.98 130.53,122.13 v1(130.45,122.05) ; UC1.AM55 120.29,81.07 v1(119.93,81.42) ; JSSD1.15 35.87,35.06 v1(35.67,35.26) ; UV14.K13 v1(153.91,120.51) ; UV12.H13 154.31,145.94 v1(154.71,146.35) 154.33,146.73 UV12.H14 ; UV1.R27 125.11,141.8 125.51,142.19 126.15,142.19 UV1.N27 ; v1(121.61,62.42) 121.31,62.71 UC1.AK22 121.11,62.6 121.11,62.08 UC1.AK21 ; v1(137.09,88.69) 137.03,88.69 UC1.A67 ; v1(116.6,68.6) 116.76,68.6 117.03,68.33 UC1.AU32 ; UV1.P32 125.01,144.2 v1(124.8,144.41) ; v1(134.28,89.41) 134.28,88.94 UC1.D69 UC1.F68 ; UV1.AA27 120.1,141.83 v1(120.1,142.32) ; UC1.J8 131.56,54.14 v1(131.56,53.94) ; UC1.AP38 118.98,71.96 v1(119.31,72.29) 119.63,71.97 UC1.AN38 ; UV12.N12 158.3,145.13 v1(157.9,145.53) ; v1(130.06,132.29) 130.04,132.29 130.04,131.99 130.43,131.6 UV1.H14 ; UV14.D10 159.08,122.51 v1(158.73,122.85) ; UV1.A30 135.09,143.4 135.13,143.36 v1(135.13,143.39) ; UV12.M5 157.51,139.53 157.9,139.14 v1(157.9,139.13) ; UV14.T5 v1(149.91,126.11) ; UV14.C3 v1(159.51,128.51) ; UC1.AJ15 121.7,57.93 v1(121.7,57.65) 122.08,57.27 UC1.AH13 ; UC1.BA57 v1(115.5,82.55) ; UC1.AT4 117.95,51.78 v1(117.95,51.45) 117.95,51.13 UC1.AT2 ; UC1.P20 128.59,61.46 128.85,61.72 v1(129.02,61.72) 128.72,62.02 UC1.P21 UC1.T21 ; v1(126.35,144.69) 126.84,144.2 UV1.M32 ; UV14.R3 v1(149.91,127.71) UV14.R4 ; v1(131.02,127.83) 131.03,127.83 131.03,127.92 131.31,128.2 UV1.G10 UV1.F10 ; UC1.BA28 115.44,65.32 v1(115.64,65.13) 115.83,65.32 UC1.AW28 116.19,65.74 116.24,65.78 116.24,66.14 116.19,66.18 UC1.AW30 ; UV1.AE27 v1(117.33,141.4) ; DT10.2 v1(10,116.26) ; UC1.N19 129.36,60.72 v1(129.05,60.41) 128.91,60.41 UC1.P19 ; UC1.AA68 v1(125.37,88.33) ; UC1.G52 132.64,79.17 133.01,78.8 v1(133.49,78.8) 133.57,78.8 133.82,78.55 UC1.E50 ; UC1.AL58 v1(121.47,82.37) ; UC1.U66 v1(127.19,87.06) ; UV12.K14 156.28,146.36 v1(156.28,146.35) ; UC1.AM8 120.29,54.74 120.78,55.23 v1(120.78,55.58) 120.83,55.58 UC1.AK11 ; UV14.U3 v1(149.11,127.71) ; UC1.AL35 v1(121.6,69.57) ; UV14.U14 v1(149.11,118.91) ; v1(157.91,147.13) 158.31,146.73 UV12.N14 ; UV12.U1 161.51,136.32 v1(161.91,135.92) ; UC1.AA2 125.74,51.22 125.64,51.33 v1(125.64,51.45) 125.64,51.84 UC1.AA4 125.87,51.94 126.3,52.37 126.3,52.59 UC1.W6 ; DT9.2 v1(10.02,117.65) ; v1(118.61,68.65) UC1.AP32
  BOTTOM w0.3: v1(123.57,144.59) 123.17,144.2 UV1.V32 ; v1(132.5,138.98) 132.5,138.99 132.33,139.33 UV1.F24 ; UV1.F12 132.14,129.73 v1(132.57,129.3) ; v1(129.37,124.61) 129.33,124.61 UV1.K6 ; UV1.AH10 114.79,128.45 v1(114.79,128.7)
  BOTTOM w0.305: v1(211.38,52.45) JEDP1.17 ; JSSD1.33 31.38,33.31 31.54,33.15 31.56,33.15 31.71,33 31.73,33 31.88,32.84 v1(31.89,32.84) ; v1(123.61,141.33) 123.55,141.4 123.55,141.59 UV1.U27 ; v1(25.42,35.17) 25.38,35.13 JSSD1.57 ; v1(118.14,142.11) 118.21,142.04 118.29,142.04 UV1.AC27 ; UV1.Y25 120.96,140.2 v1(121.41,140.65) 121.86,140.2 UV1.W25 ; UV1.AG12 114.79,129.25 v1(114.79,128.7) ; v1(122.54,141.27) 122.26,141 UV1.W26 ; v1(121.71,144.64) 121.38,144.64 UV1.Y32 ; JSSD1.27 32.87,33.19 32.54,32.85 v1(32.52,32.85) ; JSSD1.71 21.87,34.97 v1(21.71,35.14) 21.38,34.8 JSSD1.73 ; UV1.U9 123.1,127.4 v1(122.67,126.96) ; JDIMM2.107 67.96,83.49 v1(68.19,83.73) ; UV1.T25 124.12,140.2 123.68,140.64 v1(123.61,140.64) ; UV1.W27 121.74,141.81 v1(121.37,142.18) ; v1(129.31,128.69) 129.31,128.82 UV1.K11 ; v1(213.37,41.59) 213.01,41.95 JEDP1.38 ; UV1.H6 UV1.J7 129.8,125.8 v1(130.21,126.21) ; v1(33.77,31.58) 34.38,32.19 JSSD1.21 ; v1(40.08,88.26) 40.18,88.16 40.42,88.16 40.74,88.48 JDEG1.10 ; JSSD1.39 29.87,34.93 v1(30.07,35.12) ; C47.2 204.8,59.06 v1(204.73,59.06) ; v1(120.17,140.85) 120.17,140.03 UV1.AB24 ; JSSD1.75 v1(20.87,32.82) ; UV1.AC26 118.82,140.72 v1(119.01,140.72) ; v1(114.94,141.44) 115.3,141.8 ; 115.3,141.8 UV1.AG27 ; 115.3,141.8 115.3,141.83 UV1.AH28 ; JWLAN1.18 70.49,124.9 v1(70.28,125.12) ; v1(124.63,142.41) 124.94,142.1 UV1.R27 ; v1(134.95,64.93) 134.59,64.58 UC1.D25 ; JDIMM1.106 v1(69.6,83.74) ; JESPI1.9 v1(45.69,98.37) ; v1(118.16,127.77) UV1.AC9 ; UV1.AE14 116.94,131.05 v1(116.88,131) ; JSSD1.51 26.87,34.93 27.16,35.21 v1(27.16,35.37) ; v1(132.47,132.64) 132.47,132.69 132.16,133 UV1.F16 ; v1(213.39,54.45) JEDP1.13 ; v1(213.43,51.15) 213.17,51.15 212.98,50.95 JEDP1.20 211.55,50.95 211.55,50.95 ; v1(78.52,123.13) 78.31,123.13 77.97,122.8 77.97,122.37 78.19,122.15 JWLAN1.7 ; v1(28.41,35.33) 28.41,35.32 28.38,35.28 JSSD1.45 ; v1(129.39,138.07) 129.39,138.05 UV1.K22 ; UV1.U25 v1(122.71,140.62)
  BOTTOM w0.356: CC70.2 108.33,57.19 107.82,56.68 107.82,56.43 v1(107.83,56.43) ; v1(143.25,43.87) 143.44,43.87 CC17.2 ; CT79.2 16.23,119.43 v1(16.62,119.82) ; v1(177.64,64.04) 177.13,64.04 U2.5 ; CT78.2 41.21,120.37 v1(41.44,120.14) ; v1(32,127.71) CT77.2 ; CC18.2 142.67,46.04 v1(141.89,46.04)
  BOTTOM w0.381: UC6.3 145.68,89.05 145.3,88.67 C35.2 ; CU22.2 CU21.2 199.45,38.94 v1(199.82,38.58) ; UV1.V11 v1(122.78,129.44) ; UV2.3 108.1,121.12 108.4,120.82 v1(108.7,120.82) ; v1(143.04,70.75) 142.88,70.92 CC7.2 143.08,71.8 143.93,72.64 143.94,72.64 v1(144.65,73.36) ; v1(142.24,75.48) 142.37,75.61 CC6.2 ; UV1.AC17 118.25,133.71 v1(118.25,133.51) ; UV1.H20 130.07,136.87 130.07,136.91 v1(130.08,136.91) ; v1(144.98,91.04) 145.6,91.66 UC7.3 ; C51.2 96.12,35.72 95.55,35.14 95.55,33.92 93.81,32.19 90.66,32.19 ; v1(121.79,136.25) UV1.Y20 ; v1(124.91,127.63) 125.31,127.63 UV1.P9 ; CC69.2 109.16,52.68 v1(109.79,52.68) ; JTP1.5 121.05,31.33 120.62,31.76 119.5,31.76 118.69,32.57 C52.2 ; UV1.N25 126.67,140.2 v1(126.15,140.72) 125.63,140.2 UV1.P25 ; C46.2 C50.2 v1(223.3,32.77)
  BOTTOM w0.4: UV1.A3 134.8,123.14 134.8,122.95 v1(134.83,122.95)
  BOTTOM w0.406: JESPI1.12 42.55,99.37 v1(42.55,99.18) ; v1(21.96,131.36) EU4001.3 ; v1(42.04,93.98) JESPI1.11 ; JDEG1.12 40.29,85.63 v1(40.33,85.63) ; v1(27.88,121.66) EU4002.3 ; v1(45.88,87.21) 46.24,86.85 JDEG1.11
  BOTTOM w0.457: v1(175.11,35.04) 175.8,35.04 PBATT1.11
  BOTTOM w0.508: PC1810.2 PC1808.2 171.94,46.44 v1(171.73,46.66) ; CC15.2 v1(141.27,92.92) ; v1(164.9,139.63) 164.89,139.64 CV155.2 ; v1(104.02,32.41) 103.82,32.61 CC4.2 CC94.2 ; CC14.2 v1(144.98,91.04) ; C5.2 206.91,58.53 v1(206.45,58.53) ; JODD1.8 188.2,66.2 v1(187.8,65.8) 188.2,65.41 JODD1.7 ; RC68.2 121.48,44.84 v1(121.63,44.69) ; v1(145.8,85.93) 145.8,85.96 145.92,86.08 145.92,87.04 145.3,87.66 C35.2 ; v1(134.39,114.86) 134.18,114.86 CZ14.1 ; JODD1.14 191.2,66.31 v1(190.71,65.82) 191.2,65.33 JODD1.13 ; PC23.2 88.67,143.59 PQ18.3 ; v1(25.13,91.02) 25.51,91.4 25.84,91.4 PR508.2 PC516.2 PR511.2 ; v1(204.44,52.94) 204.22,52.94 PCB28.2 ; CX2.2 105.02,31.2 104.65,31.57 v1(104.65,32.44) 105.17,32.95 RX8.2 ; RV132.2 155.62,149.03 CV395.2 RV55.2 155.56,150.61 v1(155.53,150.64) ; RV38.2 148.53,115.36 v1(148.15,114.98) 148.1,115.03 148.09,115.03 147.87,115.25 147.87,115.26 147.64,115.48 CV97.2 ; CZ27.2 134.96,114.25 134.68,114.25 v1(134.11,113.67) ; RC131.1 141.74,89.59 141.74,89.89 141.47,90.15 v1(141.47,90.7) ; PCB33.2 146.53,32.66 PC11.2 146,33.42 v1(145.84,33.57) ; RC50.1 RC48.2 142.39,36.5 141.91,36.99 v1(141.91,37.45) ; RI16.2 v1(13.24,111.21) ; v1(96.88,149.03) 95.78,147.93 PQ15.3 ; CT22.2 CT20.2 24.91,117.69 v1(25.1,117.89) ; CT23.2 16.26,116.12 16.77,115.61 v1(16.89,115.61) 17.15,115.87 CT19.2 ; CV161.2 v1(165.76,126.86) ; PR1805.2 169.39,48.09 v1(169.7,48.4) ; v1(30.12,60.88) 29.75,60.88 29.4,60.53 SW1.2 ; SW3.6 134.32,32.4 v1(133.7,32.4) 133.54,32.4 SW3.4 ; v1(164.88,135.38) 164.89,135.39 CV158.2 ; v1(31.3,128.07) 30.55,127.32 CT4.2 ; CV219.2 157.62,115.74 CV335.2 v1(158.54,114.81) ; PQ6.3 93.21,143.81 v1(92.91,143.51) ; v1(120.89,117.59) 120.5,117.59 120.17,117.92 RV83.2 ; v1(17.24,47.32) 17.59,47.66 17.86,47.66 CU5.2 ; RC58.2 127.14,44.63 v1(127.44,44.92) 127.32,44.92 127.03,45.21 RC56.2 ; PRZ55.2 171.69,62 PCZ30.2 171.69,60.25 v1(171.96,59.99) ; PCW09.2 PRW02.2 139.28,112.77 v1(139.67,113.17) ; v1(140.67,94.53) RC132.1 ; v1(31.92,123.62) 31.86,123.68 CT5.2 ; v1(25.68,61.37) 25.05,60.75 CU10.2 ; CZ19.1 122.65,110.64 122.45,110.64 v1(122.01,111.08) 122.46,111.52 CZ18.1 ; v1(146.88,48.49) 146.62,48.75 RC64.2 ; v1(108.68,137.73) CV66.2 108.77,137.07 CV123.2 ; v1(204.73,59.06) 204.59,58.93 204.59,57.73 C4.2 ; PC1809.2 v1(174.51,45.95) ; JODD1.2 184.72,67.3 184.68,67.34 v1(184.21,67.34) ; JSSD1.76 19.78,31.8 v1(20.21,31.36) ; v1(125.79,106.46) 126.07,106.74 126.07,108.64 CZ17.2 ; PCW11.2 144.31,112.36 PRW04.2 v1(145.83,112.36) ; v1(137.5,117.92) CZ26.2 ; v1(89.62,121.91) 89.41,121.7 PHV01.2 ; CT46.2 10.13,121.4 9.99,121.27 v1(9.67,121.27) ; v1(141.61,112.87) 141.75,112.73 PRW10.2 141.75,111.41 141.74,111.4 PCW10.2 ; CV233.2 159.3,150.55 v1(159.34,150.59) ; v1(73,116.12) 72.65,115.77 CW6.2 ; v1(90.24,143.77) 89.88,144.14 PQ18.3 ; JFAN1.4 182.7,70.13 v1(182.71,69.02) ; CV334.2 v1(159.62,114.81) ; RV88.1 108.02,128.94 108.14,129.05 v1(108.14,129.58) ; UT6.2 40.51,130.39 CT2.2 40.51,132.28 v1(40.73,132.49) ; v1(139.08,90.97) RC133.1 ; v1(171.94,48.97) 171.59,49.32 PHZ04.2 171.6,49.62 PCZ23.2 ; v1(160.3,150.6) 160.31,150.59 CV230.2 ; PCZ34.2 168.82,53.7 PRZ64.2 169.24,54.24 169.84,54.84 169.88,54.84 v1(169.91,54.87) ; v1(143.04,70.75) 142.5,70.2 v1(142.5,69.75) 142.41,69.67 RC151.2 ; v1(180.02,67.62) 180.08,67.57 C21.2 ; YV1.4 v1(106.66,146.23) ; v1(149.68,41.7) 149.68,41.11 PC18.2 ; v1(131.45,110.56) CZ30.2 ; JFP.8 215.37,26.19 v1(215.02,25.84) ; v1(190.6,61.78) 190.37,61.55 PCB47.2 ; CX4.2 CX3.2 107.82,36.26 v1(107.89,36.19) ; v1(158.38,150.59) 158.28,150.48 CV235.2 ; v1(175.75,71.8) 175.75,70.99 176.31,70.44 ; v1(31.27,119.57) 31.18,119.49 CT15.2 ; RC87.2 98.2,39.46 v1(97.82,39.46) ; v1(18.32,7.08) 17.86,7.08 17.76,7.17 17.38,7.17 EC2301.2 ; CC79.2 129.2,38.48 CC3.2 128.76,38.49 v1(128.5,38.74) ; JTP1.10 127.71,27.79 v1(127.71,29.09) ; PCB39.2 209.13,46.13 PCB42.2 210.33,46.13 v1(210.62,45.84) ; v1(9.41,118.41) 9.71,118.71 CT47.2 ; v1(132.11,25.38) 132.49,25.76 SW3.5 ; v1(151.93,114.98) CV221.2 RV121.2 RV120.2 CV391.2 ; CZ20.1 v1(121.97,107.22) ; PC10.2 PR17.2 96.57,143.47 v1(97.07,142.96) ; JODD1.1 185.2,63.39 186.36,62.24 v1(186.97,62.24) ; RV151.1 127.07,118.36 v1(127.07,117.94) ; RC202.2 112.09,95.59 v1(111.51,96.17) ; v1(88.15,36.62) 87.91,36.86 R27.2 ; v1(106.29,28.75) 105.99,28.46 CX1.2 ; UZ4.9 134.41,116.91 v1(134.89,117.39) ; v1(211.34,41.14) 210.96,41.14 DA6.1 ; PQ18.3 89.22,145.28 PQ17.3 ; RV163.2 108.85,139.66 109.66,140.47 109.66,140.52 RV4.2 109.66,140.55 109.59,140.63 108.76,140.63 v1(108.64,140.5) ; JSPK1.6 16.5,2.01 15.3,3.21 v1(15.21,3.21) ; v1(154.59,32.74) 154.59,33.25 154.09,33.76 152.88,33.76 PBATT1.12 ; CV18.2 110.38,142.59 ; CV164.2 160.7,115.06 v1(160.63,115) ; RV368.1 124.93,120.51 125.44,121.02 v1(126.02,121.02) ; SW3.7 135.6,25.76 v1(135.97,25.38) ; v1(151.53,41.65) 151.53,41.14 PC17.2 150.53,41.03 PC12.2 ; v1(19.01,47.77) PR303.2 19.81,46.98 PR308.2 ; CZ13.1 v1(138.34,115.95) ; CC11.2 101.8,31.03 v1(101.8,30.22) ; PC7.2 89.25,147.71 v1(87.79,147.71) 87.79,148.63 PJPDC1.8 ; JIOB1.5 209.24,36.3 208.58,35.64 v1(208.21,35.64) ; PRZ65.2 169.02,57.14 v1(168.62,57.54) 169.07,57.99 PCZ36.2 ; PCG10.2 158.7,97.7 158.4,97.4 v1(158.13,97.4) 158.11,97.39 PHZ05.2 ; v1(123.19,117.52) 123.38,117.7 RV21.1 ; v1(24.27,130.79) 24.86,130.79 RT39.2 ; CT3.2 32.45,119.4 v1(32.65,119.59) ; JTP1.5 121.05,29.98 121.9,29.13 v1(123,29.13) ; JIOB1.8 206.24,37.27 206.39,37.42 v1(206.39,37.74) ; v1(144.71,94.72) 144.71,94.7 144.73,94.68 CC13.2 ; RV89.1 111.1,127.11 v1(111.38,127.4) ; CU9.2 v1(20.77,61.98) ; JUSB1.7 16.59,53.15 v1(17.15,52.59) ; UC3.4 123.69,33.25 v1(123.25,32.81) ; v1(184.18,65.55) 183.2,65.55 JODD1.26 ; CZ15.1 v1(129.72,113.26) ; v1(167.32,51.46) 167.02,51.76 PCH10.2 165.83,50.92 PRH09.2 ; v1(139.77,88.75) 139.74,88.73 C36.2 ; v1(23.27,76.35) 23.1,76.17 21.81,76.17 CL13.2 21.61,76.58 21.84,76.81 v1(22.83,76.81) ; JTP1.9 116.29,26.21 v1(116.29,25.97) ; PCB26.2 199.12,50.97 v1(198.8,51.29) ; CL12.2 v1(27.38,71.19) ; v1(115.25,44.62) 115.66,45.03 115.66,45.28 RC8.2 ; RC62.2 130.25,44.05 v1(130.41,44.21) ; v1(120.59,32.74) v2(120.59,33.55) 120.59,34.63 120.45,34.78 CX7.2 CX5.2 120.45,36.55 120.46,36.57 CX6.2 ; CV96.2 v1(150.94,117.33) ; CV157.2 164.89,137.9 v1(164.88,137.92) ; CV173.2 v1(165.15,130.82) ; RT4.2 v1(31.9,122.84) ; JKB1.32 v1(84.42,31.75) ; CV17.2 v1(108.16,146.83) ; RX5.2 106.6,26.7 v1(106.42,26.88) ; CV162.2 v1(165.76,127.94) ; RC54.2 122.13,43.66 v1(122.13,44.25) 122.61,44.25 122.84,44.03 122.84,43.96 123.19,43.6 RC52.2 ; JKB1.31 58.27,29.71 57.9,29.33 v1(57.69,29.33) ; EU2701.1 v1(216.71,35.37) 216.67,35.37 216.07,34.77 JIOB1.17 ; v1(212.58,37.96) 212.24,37.62 JIOB1.2 ; CC91.2 v1(111.8,60.39) ; JFAN1.5 v1(178.7,72.84) ; CV170.2 v1(165.77,124.7) ; PQ5.3 92.38,151.22 v1(92.79,150.81) 93.28,150.81 93.94,151.47 93.94,152.42 PR100.2 ; CV160.2 v1(165.77,125.78) ; v1(12.77,121.49) CT39.2 ; v1(183.71,54.65) 183.71,54.82 183.2,55.33 PCZ02.2 ; v1(29.93,38.57) 29.93,38.9 29.27,39.56 EU2604.1 ; CT1.2 RT2.2 36.15,116.34 v1(36.24,116.25) ; JIOB1.10 204.24,37.43 203.82,37.85 203.46,37.85 v1(202.79,38.53) ; CZ29.2 125.54,114.96 v1(125.22,115.27) CZ31.2 ; v1(209.46,48.93) U1.2 ; v1(36.86,132.18) CT7.2 ; v1(221.58,25.24) 222.17,25.24 223.17,26.24 JFP1.10 JFP.7 ; v1(200.39,65.8) JODD1.25 ; v1(223.53,31.95) C37.1 ; CV216.2 CV153.2 165.24,121.93 v1(165.78,121.93) ; CT38.2 25.05,129.71 v1(25.05,129.22) 25.05,128.76 RT40.2 ; RV118.2 v1(165.76,123.62) ; CT8.2 35.94,130.08 v1(35.94,130.46) ; RC156.2 130.56,95.34 v1(130.34,95.56) ; v1(130.72,108.46) 129.93,107.67 CZ16.1 ; JSPK1.5 12.12,2.78 v1(12.63,3.28) ; CZ28.2 134.41,118.08 v1(134.87,118.08) ; v1(42.83,118.99) JCCG4.2 ; RC147.2 140.72,82.96 v1(141.49,82.2) ; v1(142.29,94.42) CC12.2 ; CU8.2 v1(19.05,61.98) ; CC2.1 v1(108.58,47.24) ; PQ20.3 v1(102.36,148.12) ; RV135.2 v1(164.9,141.85) ; UU1.2 v1(19.97,51.75)
  vias: v1(0.49,126.66) v1(0.53,82.74) v1(0.53,65.75) v1(1.45,115.73) v1(1.36,81.78) v1(1.55,66.52) v1(1.61,83.42) v1(1.65,65.13) v1(1.95,107.34) v1(1.95,105.07) v1(1.98,130.68) v1(1.98,127.95) v1(2.72,115.73) v1(2.8,83.87) v1(2.87,133.67) v1(2.93,87.68) v1(2.93,86.41) v1(2.93,85.14) v1(3.23,88.67) v1(3.9,81.78) v1(4.09,66.52) v1(4.25,65.1) v1(4.49,105.03) v1(4.64,112.6) v1(4.93,64.09) v1(4.93,62.82) v1(4.93,61.55) v1(4.93,44.72) v1(4.93,43.45) v1(4.93,38.37) v1(5.24,133.67) v1(5.16,81.9) v1(5.21,65.97) v1(5.72,88.67) v1(5.77,114.56) v1(5.77,110.64) v1(5.76,105.03) v1(5.86,82.95) v1(5.89,41.2) v1(6.34,65.32) v1(6.51,133.67) v1(6.52,118.19) v1(6.89,124.43) v1(6.95,43.03) v1(6.95,39.37) v1(7.03,105.03) v1(7.13,82.95) v1(7.55,65.58) v1(7.78,133.67) v1(7.83,81.79) v1(7.75,45.97) v1(7.86,60.33) v1(8.03,114.56) v1(8.03,110.64) v1(8.3,105.03) v1(8.44,66.52) v1(8.44,22.07) v1(8.56,36.43) v1(8.82,88.67) v1(9.02,45.97) v1(9.05,133.67) v1(9.1,81.78) v1(9.13,60.33) v1(9.05,43.03) v1(9.05,39.37) v1(9.16,112.6) v1(9.57,105.03) v1(9.67,123.08) v1(9.71,66.52) v1(9.71,22.07) v1(9.83,36.43) v1(10.09,88.67) v1(10.11,41.2) v1(10.32,133.67) v1(10.29,45.97) v1(10.4,60.33) v1(10.49,103.23) v1(10.48,90.73) v1(10.65,63.71) v1(10.77,104.69) v1(10.93,4.38) v1(10.93,3.11) v1(10.93,1.84) v1(10.94,0.57) v1(10.98,89.56) v1(10.98,22.07) v1(11.1,36.43) v1(11.59,133.67) v1(11.64,81.77) v1(11.56,45.97) v1(11.67,60.33) v1(12.2,0.43) v1(12.43,80.78) v1(12.4,40.04) v1(12.35,38.92) v1(12.86,133.67) v1(13.45,121.83) v1(13.45,115.98) v1(13.47,0.43) v1(13.85,44.13) v1(13.85,43.54) v1(13.85,42.91) v1(13.85,42.32) v1(13.93,24.11) v1(14.13,133.67) v1(14.18,58.76) v1(14.28,120.94) v1(14.26,47.44) v1(14.44,44.15) v1(14.44,43.57) v1(14.44,42.93) v1(14.43,35.44) v1(14.43,22.94) v1(14.74,0.43) v1(15.17,131.83) v1(15.2,130.06) v1(15.17,118.47) v1(15.4,133.67) v1(16.01,0.43) v1(16.67,133.67) v1(16.77,41.88) v1(17.28,0.43) v1(17.5,42.67) v1(17.94,133.67) v1(17.93,97.06) v1(17.93,95.26) v1(17.92,93.07) v1(17.92,91.27) v1(18.23,89.44) v1(18.44,123.37) v1(18.44,121.95) v1(18.55,0.43) v1(19.01,55.66) v1(19.21,133.67) v1(19.56,124.78) v1(19.56,123.37) v1(19.56,121.95) v1(19.56,120.54) v1(19.82,0.43) v1(20.2,30.69) v1(20.2,30.06) v1(20.48,133.67) v1(20.68,123.37) v1(20.68,121.95) v1(20.8,54.54) v1(20.8,53.72) v1(20.81,30.69) v1(20.81,30.06) v1(21.09,0.43) v1(21.4,94.95) v1(21.4,93.07) v1(21.36,91.21) v1(21.62,32.94) v1(21.75,133.67) v1(21.78,125.45) v1(21.95,89.84) v1(22.01,53.04) v1(22.01,52.45) v1(22.26,43.65) v1(22.35,32.72) v1(22.35,32.14) v1(22.35,31.55) v1(22.36,77.64) v1(22.36,0.43) v1(22.46,96.63) v1(22.93,97.01) v1(23.02,133.67) v1(23.08,83.38) v1(23.08,82.26) v1(23.08,81.14) v1(23.58,104.25) v1(23.61,90.79) v1(23.63,0.43) v1(23.68,53.04) v1(23.68,52.34) v1(24.18,105.9) v1(24.21,104.25) v1(24.2,83.38) v1(24.2,82.26) v1(24.2,81.14) v1(24.29,133.67) v1(24.81,105.9) v1(24.8,104.25) v1(24.77,15.22) v1(24.77,13.25) v1(24.77,11.28) v1(24.9,0.43) v1(25.31,83.38) v1(25.31,82.26) v1(25.31,81.14) v1(25.45,105.9) v1(25.55,120.75) v1(25.56,133.67) v1(25.56,97.17) v1(25.74,124.99) v1(26.15,119.11) v1(26.08,105.9) v1(26.17,0.43) v1(26.49,77.71) v1(26.67,126.27) v1(26.74,15.22) v1(26.74,13.25) v1(26.74,11.28) v1(26.83,133.67) v1(26.81,77.19) v1(27.12,85.21) v1(27.44,0.43) v1(27.52,63.76) v1(28.1,133.67) v1(28.05,72.98) v1(28.4,130.46) v1(28.4,129.21) v1(28.44,96.55) v1(28.44,95.91) v1(28.44,95.28) v1(28.44,94.64) v1(28.44,94.01) v1(28.48,84.89) v1(28.64,98.19) v1(28.6,51.54) v1(28.7,15.22) v1(28.7,13.25) v1(28.7,11.28) v1(28.71,0.43) v1(29.02,129.84) v1(29.02,96.55) v1(29.02,95.91) v1(29.02,95.28) v1(29.02,94.64) v1(29.04,51.11) v1(29.27,98.19) v1(29.37,133.67) v1(29.64,130.46) v1(29.64,129.21) v1(29.6,96.55) v1(29.6,95.91) v1(29.6,95.28) v1(29.6,94.64) v1(29.6,94.01) v1(29.75,30.16) v1(29.75,29.5) v1(29.98,0.43) v1(30.16,96.75) v1(30.16,96.12) v1(30.16,95.48) v1(30.16,94.85) v1(30.16,94.21) v1(30.25,29.19) v1(30.26,29.8) v1(30.54,38.11) v1(30.64,133.67) v1(31.25,0.43) v1(31.91,133.67) v1(32.52,0.43) v1(32.68,49.04) v1(32.68,47.84) v1(32.75,37.6) v1(32.8,105.27) v1(33.18,133.67) v1(33.28,48.44) v1(33.3,40.91) v1(33.79,0.43) v1(33.87,49.04) v1(33.87,47.84) v1(34.32,125.37) v1(34.32,121.23) v1(34.27,14.71) v1(34.45,133.67) v1(34.53,39.45) v1(35.06,0.43) v1(35.39,132.65) v1(35.72,133.67) v1(35.66,108.84) v1(35.66,106.3) v1(35.67,2.82) v1(35.67,1.55) v1(35.85,83.55) v1(36.08,40.65) v1(36.22,28.81) v1(36.24,3.96) v1(36.25,114.59) v1(36.39,125.37) v1(36.39,123.3) v1(36.39,121.23) v1(36.85,29.43) v1(36.85,28.19) v1(36.99,133.67) v1(36.97,108.84) v1(36.97,106.3) v1(37.08,54.9) v1(37.47,28.81) v1(37.5,4.03) v1(38.03,114.59) v1(38.01,36.36) v1(38.26,133.67) v1(38.28,108.84) v1(38.28,106.3) v1(38.41,25.33) v1(38.41,24.75) v1(38.46,125.37) v1(38.46,123.3) v1(38.46,121.23) v1(38.77,4.03) v1(38.9,58.03) v1(39.43,117.65) v1(39.53,133.67) v1(39.59,108.84) v1(39.59,106.3) v1(39.72,23.31) v1(40.03,117.64) v1(40.04,4.03) v1(40.31,23.31) v1(40.8,133.7) v1(40.77,20.32) v1(40.77,19.05) v1(40.77,17.78) v1(40.77,16.51) v1(40.77,15.24) v1(40.77,13.97) v1(40.77,12.7) v1(40.77,11.43) v1(40.77,10.16) v1(40.77,8.89) v1(40.77,7.62) v1(40.77,6.35) v1(40.77,5.08) v1(40.9,108.84) v1(40.9,106.3) v1(40.89,23.31) v1(40.98,21.59) v1(41.47,23.31) v1(41.61,114.56) v1(41.79,134.48) v1(41.93,140.82) v1(41.93,139.55) v1(41.93,138.28) v1(41.93,137.01) v1(41.93,135.74) v1(41.9,32.41) v1(42.06,23.31) v1(42.22,108.84) v1(42.22,106.3) v1(42.17,29.93) v1(42.18,21.93) v1(42.52,33.09) v1(42.54,32.41) v1(42.64,23.31) v1(42.78,29.93) v1(43.09,141.37) v1(43.23,23.31) v1(43.29,129.9) v1(43.45,21.93) v1(43.8,55.88) v1(44.36,141.37) v1(44.4,131.81) v1(44.39,127.99) v1(44.43,22.77) v1(44.7,24.53) v1(45.28,24.53) v1(45.63,141.37) v1(45.67,22.93) v1(45.87,24.53) v1(46.45,24.53) v1(46.61,131.81) v1(46.6,127.99) v1(46.77,134.91) v1(46.9,141.37) v1(46.95,111.82) v1(46.95,111.12) v1(46.94,22.93) v1(47.04,24.53) v1(47.41,134.91) v1(47.65,111.82) v1(47.65,111.12) v1(47.71,129.9) v1(48.07,134.92) v1(48.17,141.37) v1(48.21,22.93) v1(48.76,44.93) v1(48.92,32.56) v1(49.09,45.44) v1(49.44,141.37) v1(49.45,44.93) v1(49.46,45.89) v1(49.5,32.56) v1(49.48,22.93) v1(49.82,108.14) v1(50.08,32.56) v1(50.26,131.06) v1(50.4,124.91) v1(50.71,141.37) v1(50.71,124.39) v1(50.67,32.56) v1(50.75,22.93) v1(51.02,124.91) v1(51.29,127.72) v1(51.25,32.56) v1(51.98,141.37) v1(52.02,22.93) v1(53.25,141.37) v1(53.29,22.93) v1(54.52,141.37) v1(54.56,22.93) v1(55.79,141.37) v1(55.79,129.98) v1(55.83,22.93) v1(56.14,108.5) v1(56.33,110.02) v1(56.42,135.78) v1(56.37,129.98) v1(56.5,123.12) v1(56.75,103.46) v1(56.75,102.06) v1(56.75,100.66) v1(56.83,99.24) v1(56.84,98.24) v1(56.76,96.69) v1(56.84,91.29) v1(56.82,88.12) v1(56.89,109.07) v1(56.89,94.59) v1(56.93,93.24) v1(56.92,89.74) v1(56.92,83.85) v1(56.9,64.11) v1(56.99,129.98) v1(57.02,85.74) v1(56.98,63.24) v1(56.98,62.24) v1(56.98,61.24) v1(56.98,59.24) v1(56.98,57.74) v1(56.98,55.74) v1(56.98,54.74) v1(56.98,51.74) v1(56.98,50.74) v1(56.98,49.74) v1(56.98,48.74) v1(56.98,47.24) v1(56.96,46.36) v1(56.99,45.38) v1(57.06,141.37) v1(57.08,123.11) v1(57.1,22.93) v1(57.29,136.48) v1(57.58,129.98) v1(58.2,137.09) v1(58.33,141.37) v1(58.37,22.93) v1(59.52,52.74) v1(59.6,141.37) v1(59.65,137.09) v1(59.64,22.93) v1(59.72,107.34) v1(60.05,79.98) v1(60.05,73.71) v1(59.98,72.34) v1(60.05,69.06) v1(60.07,84.09) v1(60.35,91.28) v1(60.43,102.07) v1(60.37,58.42) v1(60.37,47.52) v1(60.75,106.21) v1(60.81,108.89) v1(60.81,103.46) v1(60.81,100.73) v1(60.81,98.24) v1(60.81,95.48) v1(60.81,92.57) v1(60.81,89.27) v1(60.75,64.95) v1(60.75,61.64) v1(60.75,59.61) v1(60.75,56.63) v1(60.75,54.66) v1(60.75,50.88) v1(60.75,49.24) v1(60.75,46.19) v1(60.87,141.37) v1(60.91,22.93) v1(61.51,72.34) v1(61.59,84.09) v1(61.57,81.81) v1(61.57,79.98) v1(61.55,76.69) v1(61.57,73.71) v1(61.57,70.51) v1(61.57,69.06) v1(61.57,66.89) v1(61.7,85.67) v1(61.9,107.38) v1(61.9,63.68) v1(61.9,52.75) v1(61.95,96.75) v1(61.95,74.78) v1(62.14,141.37) v1(62.18,22.93) v1(62.33,108.89) v1(62.27,106.21) v1(62.33,103.46) v1(62.33,100.73) v1(62.33,98.24) v1(62.33,95.48) v1(62.33,92.57) v1(62.33,89.27) v1(62.33,78.54) v1(62.28,64.95) v1(62.28,61.64) v1(62.28,59.61) v1(62.28,56.63) v1(62.28,54.66) v1(62.28,50.88) v1(62.28,49.24) v1(62.28,46.19) v1(62.71,102.07) v1(62.7,91.28) v1(62.66,58.42) v1(62.66,47.52) v1(63.03,72.34) v1(63.12,84.09) v1(63.09,81.81) v1(63.09,79.98) v1(63.09,78.54) v1(63.08,76.69) v1(63.09,70.51) v1(63.09,69.06) v1(63.09,66.89) v1(63.22,85.67) v1(63.41,141.37) v1(63.45,22.93) v1(63.8,106.21) v1(63.8,64.95) v1(63.8,61.64) v1(63.8,59.61) v1(63.8,56.63) v1(63.8,54.66) v1(63.8,50.88) v1(63.8,49.24) v1(63.8,46.19) v1(63.86,108.89) v1(63.86,103.46) v1(63.86,100.73) v1(63.86,98.24) v1(63.86,95.48) v1(63.86,92.57) v1(63.86,89.27) v1(64.19,107.38) v1(64.24,96.75) v1(64.24,74.78) v1(64.18,63.68) v1(64.18,52.75) v1(64.64,84.09) v1(64.55,72.34) v1(64.62,69.06) v1(64.68,141.37) v1(64.74,85.67) v1(64.72,22.93) v1(65.01,47.49) v1(65.95,141.37) v1(65.99,22.93) v1(67.22,141.37) v1(67.26,22.93) v1(67.74,95.19) v1(67.75,87.54) v1(67.7,62.82) v1(67.68,56.81) v1(67.81,109.13) v1(67.8,103.16) v1(67.8,99.71) v1(67.84,98.2) v1(67.81,93.64) v1(67.78,85.25) v1(67.81,54.91) v1(67.76,52.62) v1(67.87,107.12) v1(67.91,105.32) v1(67.91,88.94) v1(67.85,66.35) v1(67.88,49.51) v1(67.94,46.02) v1(68.49,141.37) v1(68.53,22.93) v1(68.93,112.33) v1(69.44,102.04) v1(69.41,59.73) v1(69.49,105.32) v1(69.46,103.17) v1(69.46,99.71) v1(69.52,97.7) v1(69.5,91.54) v1(69.54,57.74) v1(69.52,50.27) v1(69.59,109.13) v1(69.59,95.48) v1(69.59,87.51) v1(69.62,85.25) v1(69.62,56.13) v1(69.59,54.52) v1(69.59,48.02) v1(69.65,93.79) v1(69.65,51.43) v1(69.65,46.02) v1(69.76,141.37) v1(69.8,22.93) v1(70.94,141.77) v1(71.07,22.93) v1(71.38,146.78) v1(71.38,145.51) v1(71.38,144.24) v1(71.38,142.97) v1(72.31,63.77) v1(72.34,22.93) v1(72.49,74.78) v1(72.5,73.8) v1(72.65,131.22) v1(72.65,129.7) v1(72.65,128.18) v1(72.71,84.53) v1(72.75,81.64) v1(72.75,79.82) v1(72.73,76.57) v1(72.68,72.44) v1(72.75,70.52) v1(72.87,86.49) v1(73.05,91.28) v1(73.07,102.02) v1(73.07,58.34) v1(73.07,47.52) v1(73.21,150.47) v1(73.2,51.01) v1(73.3,149.08) v1(73.3,148.47) v1(73.32,103.34) v1(73.35,61.8) v1(73.51,106.04) v1(73.51,100.73) v1(73.51,95.48) v1(73.51,92.57) v1(73.51,89.27) v1(73.45,64.95) v1(73.45,59.68) v1(73.45,56.82) v1(73.45,54.2) v1(73.45,48.86) v1(73.45,46.27) v1(73.56,98.15) v1(73.61,22.93) v1(73.91,149.08) v1(73.91,148.47) v1(74.18,131.22) v1(74.18,129.7) v1(74.18,128.18) v1(74.23,84.53) v1(74.21,73.82) v1(74.21,72.44) v1(74.27,81.64) v1(74.27,79.82) v1(74.27,78.43) v1(74.25,76.57) v1(74.27,70.52) v1(74.27,69.06) v1(74.4,86.49) v1(74.48,150.47) v1(74.52,149.08) v1(74.52,148.47) v1(74.6,63.59) v1(74.6,52.75) v1(74.67,107.23) v1(74.65,96.75) v1(74.65,74.78) v1(74.84,103.34) v1(74.79,51.04) v1(74.87,61.8) v1(74.88,22.93) v1(75.03,106.04) v1(75.03,100.73) v1(75.03,95.48) v1(75.03,92.57) v1(75.03,89.27) v1(74.98,64.95) v1(74.98,59.68) v1(74.98,56.82) v1(74.98,54.2) v1(74.98,48.86) v1(74.98,46.27) v1(75.13,149.08) v1(75.13,148.47) v1(75.09,98.15) v1(75.23,109.14) v1(75.34,91.28) v1(75.36,102.02) v1(75.36,58.34) v1(75.36,47.52) v1(75.74,149.08) v1(75.74,148.47) v1(75.7,131.22) v1(75.7,129.7) v1(75.7,128.18) v1(75.73,72.44) v1(75.75,150.47) v1(75.76,84.53) v1(75.79,81.64) v1(75.79,78.43) v1(75.78,76.57) v1(75.79,70.52) v1(75.79,69.06) v1(75.79,66.89) v1(75.92,86.49) v1(76.15,22.93) v1(76.31,51.04) v1(76.37,103.34) v1(76.4,61.8) v1(76.5,59.68) v1(76.5,54.2) v1(76.5,48.86) v1(76.5,46.27) v1(76.56,106.04) v1(76.56,100.73) v1(76.61,98.15) v1(76.56,95.48) v1(76.56,92.57) v1(76.56,89.27) v1(76.76,109.14) v1(76.94,96.75) v1(76.88,52.75) v1(77.02,150.47) v1(76.95,107.23) v1(77.33,120.69) v1(77.28,84.53) v1(77.32,70.52) v1(77.32,69.06) v1(77.45,86.49) v1(77.42,22.93) v1(77.68,134.76) v1(77.76,132.99) v1(77.86,138.74) v1(77.89,137.65) v1(77.89,136.15) v1(77.9,120.83) v1(78.29,150.47) v1(78.69,22.93) v1(79.56,150.47) v1(79.96,22.93) v1(80.17,140.42) v1(80.38,62.46) v1(80.44,60.29) v1(80.39,58.4) v1(80.37,56.86) v1(80.4,54.92) v1(80.47,103.19) v1(80.51,100.73) v1(80.5,96.62) v1(80.46,89.29) v1(80.54,83.99) v1(80.64,107.1) v1(80.59,105.01) v1(80.65,97.96) v1(80.57,94.47) v1(80.57,66.18) v1(80.67,138.88) v1(80.67,138.12) v1(80.67,137.36) v1(80.67,136.6) v1(80.69,133.56) v1(80.74,127.88) v1(80.83,150.47) v1(81.02,56.87) v1(81.08,54.92) v1(81.21,65.02) v1(81.23,22.93) v1(81.44,127.39) v1(81.45,149.49) v1(81.91,147.29) v1(81.95,128.9) v1(82.03,127.39) v1(82.03,113.32) v1(82.04,57.29) v1(82.1,150.47) v1(82.09,149.49) v1(82.1,67.7) v1(82.47,147.1) v1(82.5,22.93) v1(82.65,57.31) v1(83.37,150.47) v1(83.69,40.68) v1(83.77,22.93) v1(84.27,139.2) v1(84.32,40.68) v1(84.64,150.47) v1(84.64,127.24) v1(84.64,126.65) v1(84.64,74.09) v1(84.65,133.55) v1(84.65,132.79) v1(84.67,130.75) v1(84.67,129.99) v1(84.67,129.23) v1(84.86,139.2) v1(84.95,40.68) v1(85.04,22.93) v1(85.28,130.75) v1(85.28,129.99) v1(85.28,129.23) v1(85.38,148.45) v1(85.47,139.2) v1(85.91,150.47) v1(85.89,130.75) v1(85.89,129.99) v1(85.89,129.23) v1(85.99,148.45) v1(86.1,74.09) v1(86.31,22.93) v1(86.5,130.75) v1(86.5,129.99) v1(86.5,129.23) v1(87.11,130.75) v1(87.11,129.99) v1(87.11,129.23) v1(87.18,150.47) v1(87.58,22.93) v1(87.71,130.75) v1(87.71,129.99) v1(87.71,129.23) v1(88.32,130.75) v1(88.32,129.99) v1(88.32,129.23) v1(88.39,150.86) v1(88.68,46.15) v1(88.89,151.99) v1(88.93,130.75) v1(88.93,129.99) v1(88.93,129.23) v1(88.85,22.93) v1(89.1,31.18) v1(89.19,153.3) v1(89.54,130.75) v1(89.54,129.99) v1(89.54,129.23) v1(89.53,46.15) v1(90.12,22.93) v1(90.24,153.97) v1(90.15,130.75) v1(90.15,129.99) v1(90.15,129.23) v1(90.76,130.75) v1(90.76,129.99) v1(90.76,129.23) v1(91.37,130.75) v1(91.37,129.99) v1(91.37,129.23) v1(91.39,22.93) v1(91.51,153.97) v1(91.98,130.75) v1(91.98,129.99) v1(91.98,129.23) v1(92.47,36.98) v1(92.59,130.75) v1(92.59,129.99) v1(92.59,129.23) v1(92.66,22.93) v1(92.78,153.97) v1(93.2,130.75) v1(93.2,129.99) v1(93.93,22.93) v1(94.05,153.97) v1(94.56,131.71) v1(95.23,63.76) v1(95.2,22.93) v1(95.32,153.97) v1(96.47,22.93) v1(96.59,153.97) v1(97.04,110.57) v1(97.28,29.39) v1(97.74,22.93) v1(97.91,29.39) v1(98.15,152.07) v1(98.55,29.39) v1(98.67,30.44) v1(98.81,110.57) v1(99.01,22.93) v1(99.55,152.07) v1(100.28,22.93) v1(101.41,153.97) v1(101.5,23.31) v1(102.55,153.96) v1(102.63,23.88) v1(103.32,144.87) v1(103.83,152.47) v1(103.75,145.3) v1(103.9,23.88) v1(104.67,143.32) v1(104.73,119.91) v1(105.11,143.75) v1(105.05,119.39) v1(105.17,23.88) v1(105.32,119.91) v1(105.28,61.19) v1(105.44,153.97) v1(105.63,119.39) v1(105.9,119.91) v1(106.05,71.49) v1(106.05,52.81) v1(106.11,65.95) v1(106.44,23.88) v1(106.49,153.97) v1(107.06,83.54) v1(107.13,75.42) v1(107.13,62.37) v1(107.19,80.12) v1(107.71,23.88) v1(107.76,153.97) v1(107.76,64.37) v1(108.08,71.48) v1(108.08,65.95) v1(108.21,86.15) v1(108.27,83.54) v1(108.62,31.22) v1(108.71,69.89) v1(108.84,73.83) v1(109.03,153.97) v1(108.97,80.12) v1(108.98,23.88) v1(109.09,81.58) v1(109.09,75.48) v1(109.08,62.37) v1(109.16,78.03) v1(109.73,64.37) v1(109.86,88.09) v1(110.05,71.48) v1(109.98,65.95) v1(110.14,32.74) v1(110.14,31.22) v1(110.14,29.7) v1(110.24,90.15) v1(110.25,23.88) v1(110.3,153.97) v1(110.68,73.77) v1(110.68,69.89) v1(111.29,149.72) v1(111.52,23.88) v1(111.57,153.97) v1(111.69,64.39) v1(111.67,31.22) v1(112.46,149.65) v1(112.79,23.88) v1(112.88,126.05) v1(113.02,153.98) v1(114.06,23.88) v1(114.3,149.65) v1(114.53,155.07) v1(114.69,127.54) v1(114.82,120.99) v1(114.89,94.31) v1(115.33,23.88) v1(115.75,155.07) v1(116.12,149.66) v1(116.6,23.88) v1(116.91,148.57) v1(117.02,155.07) v1(117.33,61.36) v1(117.41,112.56) v1(117.57,122.51) v1(117.87,23.88) v1(118.05,112.56) v1(117.97,86.03) v1(117.97,61.35) v1(118.12,122.2) v1(118.18,129.77) v1(118.29,155.07) v1(118.43,97.78) v1(118.43,95.93) v1(118.75,147.74) v1(118.67,86.03) v1(119.14,23.88) v1(119.3,86.03) v1(119.56,155.07) v1(119.78,132.48) v1(119.84,86.94) v1(120.05,99.19) v1(120.05,97.85) v1(120.05,96.01) v1(120.18,128.2) v1(120.27,154.02) v1(120.41,23.88) v1(121.73,153.07) v1(121.68,23.88) v1(121.82,130.39) v1(122.17,96.9) v1(122.23,95) v1(122.85,71.85) v1(122.93,131.51) v1(122.87,79.04) v1(122.95,23.88) v1(122.95,68.11) v1(123.12,58.44) v1(123.25,94.49) v1(123.74,136.3) v1(123.8,155.06) v1(123.9,77.66) v1(124.08,79.04) v1(124.12,71.85) v1(124.09,68.11) v1(124.21,64.98) v1(124.22,23.88) v1(124.46,88.98) v1(124.46,88.33) v1(124.46,87.68) v1(124.46,87.01) v1(124.46,86.36) v1(124.54,77.67) v1(124.64,133.39) v1(124.57,131.49) v1(124.66,74.27) v1(125.22,79.04) v1(125.23,76.73) v1(125.26,71.85) v1(125.3,68.11) v1(125.48,64.98) v1(125.49,23.88) v1(125.68,136.34) v1(125.83,76.72) v1(125.87,74.27) v1(126.14,111.1) v1(126.49,79.04) v1(126.47,71.85) v1(126.64,137.24) v1(126.6,136.36) v1(126.57,68.11) v1(126.74,132.48) v1(126.68,64.98) v1(126.8,146.27) v1(126.76,23.88) v1(127.01,74.27) v1(127.15,39.53) v1(127.43,146.27) v1(127.7,79.04) v1(127.74,71.85) v1(127.69,38.03) v1(127.78,68.11) v1(127.95,64.98) v1(128.03,23.88) v1(128.19,76.65) v1(128.22,74.27) v1(128.38,155.07) v1(128.88,79.04) v1(128.94,71.85) v1(128.98,68.11) v1(129.16,64.98) v1(129.3,23.88) v1(129.75,155.06) v1(129.83,76.6) v1(129.83,75.99) v1(130.15,71.85) v1(130.27,68.11) v1(130.57,23.88) v1(130.9,154.57) v1(130.92,86.4) v1(130.92,85.75) v1(131.84,23.88) v1(132.16,154.57) v1(132.32,27.91) v1(133.11,23.88) v1(133.43,154.57) v1(133.64,37.49) v1(133.93,146.99) v1(134.15,106.05) v1(134.43,105.52) v1(134.38,23.88) v1(134.7,154.57) v1(134.73,106.05) v1(135.01,105.52) v1(135.31,106.05) v1(135.59,105.52) v1(135.65,23.88) v1(135.85,30.67) v1(135.9,106.05) v1(135.97,154.57) v1(136.18,105.52) v1(136.92,23.88) v1(137.24,154.57) v1(137.17,31.52) v1(138.19,23.88) v1(138.44,154.98) v1(138.7,53.08) v1(139.38,23.88) v1(139.71,155.07) v1(139.81,72.47) v1(140.98,155.07) v1(142.25,155.07) v1(142.39,97.37) v1(142.4,96.78) v1(142.4,96.12) v1(142.41,95.53) v1(143.52,155.07) v1(143.77,23.88) v1(144.79,155.07) v1(144.89,23.88) v1(146.03,27.45) v1(146.01,23.88) v1(146.06,155.07) v1(146.75,150.65) v1(147.2,23.88) v1(147.33,155.07) v1(147.44,62.06) v1(147.44,61.48) v1(147.44,60.89) v1(147.6,150.65) v1(147.56,85.85) v1(147.79,79.21) v1(148.19,82.1) v1(148.35,23.88) v1(148.37,79.21) v1(148.6,155.07) v1(149.51,108.19) v1(149.62,23.88) v1(149.87,155.07) v1(150.1,108.19) v1(150.68,108.19) v1(150.89,23.88) v1(151.14,155.07) v1(152.16,23.88) v1(152.31,89.4) v1(152.31,88.79) v1(152.34,65.13) v1(152.34,64.49) v1(152.34,63.86) v1(152.34,63.22) v1(152.28,48.27) v1(152.41,155.07) v1(152.69,47.79) v1(152.88,108.2) v1(152.92,89.4) v1(152.92,88.79) v1(152.88,48.34) v1(152.92,35.93) v1(153.27,47.84) v1(153.37,113.24) v1(153.37,112.66) v1(153.43,23.88) v1(153.46,108.2) v1(153.68,155.07) v1(154.67,35.57) v1(154.7,23.88) v1(154.95,155.07) v1(155.24,108.22) v1(155.82,108.22) v1(155.97,23.88) v1(156.22,155.07) v1(156.22,148.14) v1(156.71,28.4) v1(157.24,23.88) v1(157.42,28.43) v1(157.49,155.03) v1(157.76,74.26) v1(157.76,73.63) v1(157.76,73.04) v1(158,53.88) v1(158.07,91.67) v1(158.31,41.85) v1(158.4,46.86) v1(158.54,94.03) v1(158.51,23.88) v1(158.58,54.47) v1(158.58,53.88) v1(158.66,154.57) v1(158.73,57.79) v1(158.73,57.21) v1(158.75,42.27) v1(158.92,92.89) v1(158.92,91.33) v1(159.17,54.47) v1(159.17,53.88) v1(159.3,57.56) v1(159.44,41.36) v1(159.75,54.16) v1(159.75,53.58) v1(159.78,23.88) v1(159.93,154.57) v1(159.93,57.56) v1(160.03,41.36) v1(160.21,92.89) v1(160.21,91.33) v1(160.33,54.16) v1(160.33,53.58) v1(160.33,52.99) v1(160.57,57.56) v1(160.61,41.36) v1(160.89,53.93) v1(160.89,53.35) v1(160.89,52.76) v1(160.89,52.18) v1(160.89,51.6) v1(161.05,23.88) v1(161.2,154.57) v1(161.16,80.76) v1(161.16,80.13) v1(161.16,79.54) v1(161.16,78.91) v1(161.2,57.56) v1(161.51,92.89) v1(161.51,91.33) v1(161.79,89.78) v1(161.84,57.56) v1(161.85,89.18) v1(161.86,82.53) v1(161.86,81.94) v1(161.86,81.32) v1(161.86,80.74) v1(161.86,80.12) v1(161.86,79.53) v1(161.86,78.91) v1(162.06,92.03) v1(162.25,66.43) v1(162.27,90.59) v1(162.32,23.88) v1(162.35,89.99) v1(162.44,89.18) v1(162.47,154.57) v1(162.5,82.53) v1(162.5,81.94) v1(162.5,81.32) v1(162.5,80.74) v1(162.5,80.12) v1(162.5,79.53) v1(162.5,78.91) v1(162.82,90.39) v1(162.95,86.44) v1(162.95,85.14) v1(162.95,83.85) v1(163.02,89.18) v1(163.05,91.99) v1(163.06,89.84) v1(163.08,82.53) v1(163.08,81.94) v1(163.08,81.32) v1(163.08,80.74) v1(163.08,80.12) v1(163.08,79.53) v1(163.13,78.91) v1(163.1,67.65) v1(163.1,66.08) v1(163.29,87.29) v1(163.51,90.39) v1(163.64,91.99) v1(163.64,89.82) v1(163.62,89.19) v1(163.59,23.88) v1(163.74,154.57) v1(163.65,83.3) v1(163.67,82.53) v1(163.67,81.94) v1(163.67,81.32) v1(163.67,80.74) v1(163.67,80.12) v1(163.67,79.53) v1(163.7,64.37) v1(163.7,63.73) v1(163.7,63.1) v1(163.7,62.46) v1(163.77,78.91) v1(164.14,90.39) v1(164.22,91.99) v1(164.23,89.81) v1(164.21,89.19) v1(164.34,64.37) v1(164.34,63.73) v1(164.34,63.1) v1(164.34,62.46) v1(164.39,67.65) v1(164.39,66.08) v1(164.51,86.44) v1(164.51,85.14) v1(164.51,83.85) v1(164.72,90.39) v1(164.81,91.99) v1(164.82,89.82) v1(164.86,23.88) v1(165.01,154.57) v1(164.97,64.43) v1(164.97,63.8) v1(164.97,63.16) v1(164.97,62.53) v1(165.39,91.99) v1(165.38,90.36) v1(165.41,89.78) v1(165.38,38.15) v1(165.61,64.43) v1(165.61,63.8) v1(165.61,63.16) v1(165.61,62.53) v1(165.65,86.82) v1(165.69,67.65) v1(165.69,66.08) v1(165.68,38.69) v1(165.97,91.99) v1(166,38.15) v1(166.13,23.88) v1(166.24,66.79) v1(166.24,64.43) v1(166.24,63.8) v1(166.24,63.16) v1(166.24,62.53) v1(166.28,154.57) v1(166.3,38.69) v1(166.51,65.01) v1(166.63,38.15) v1(166.72,70.75) v1(166.72,70.16) v1(166.88,64.43) v1(166.88,63.8) v1(166.88,63.16) v1(166.88,62.53) v1(166.89,38.69) v1(167.2,64.94) v1(167.22,38.15) v1(167.43,152.76) v1(167.4,23.88) v1(167.51,64.43) v1(167.51,63.8) v1(167.51,63.16) v1(167.51,62.53) v1(167.47,38.69) v1(167.76,102.7) v1(167.77,102.09) v1(167.77,101.45) v1(167.77,100.82) v1(167.8,38.15) v1(168.03,45.42) v1(168.06,38.69) v1(168.39,38.15) v1(168.61,44.42) v1(168.64,38.69) v1(168.67,23.88) v1(168.98,38.15) v1(169.07,151.95) v1(169.07,150.68) v1(169.07,149.41) v1(169.07,148.14) v1(169.07,146.87) v1(169.07,145.6) v1(169.07,144.33) v1(169.07,143.06) v1(169.07,141.79) v1(169.09,140.52) v1(169.17,139.25) v1(169.2,45.42) v1(169.2,43.41) v1(169.24,38.71) v1(169.25,137.98) v1(169.33,136.71) v1(169.41,135.45) v1(169.49,134.18) v1(169.57,132.91) v1(169.66,131.64) v1(169.73,130.38) v1(169.82,129.11) v1(169.83,84.15) v1(169.83,83.53) v1(169.9,127.84) v1(169.94,23.88) v1(169.98,126.57) v1(170.06,125.31) v1(170.14,124.04) v1(170.22,122.77) v1(170.3,121.5) v1(170.38,120.24) v1(170.46,118.97) v1(170.54,117.7) v1(170.62,116.44) v1(170.7,115.17) v1(170.78,114) v1(171.21,23.88) v1(171.35,104.98) v1(171.43,103.76) v1(171.51,102.49) v1(171.59,101.23) v1(171.67,99.96) v1(171.75,98.69) v1(171.83,97.42) v1(171.91,96.16) v1(172,94.89) v1(172.07,93.62) v1(172.16,92.35) v1(172.24,91.09) v1(172.38,89.82) v1(172.48,23.88) v1(172.6,88.57) v1(172.89,87.34) v1(173.25,86.12) v1(173.41,57.92) v1(173.41,55.9) v1(173.41,53.88) v1(173.69,84.93) v1(173.75,23.88) v1(174.19,83.76) v1(174.76,82.63) v1(175.02,23.88) v1(175.4,81.53) v1(175.43,57.92) v1(175.43,55.9) v1(175.43,53.88) v1(176.1,80.47) v1(176.29,23.88) v1(176.87,79.46) v1(176.92,43.02) v1(177.45,57.92) v1(177.45,55.9) v1(177.45,53.88) v1(177.56,23.88) v1(177.69,78.49) v1(178.57,77.57) v1(178.72,69.82) v1(178.83,23.88) v1(179.15,68.45) v1(179.5,76.71) v1(179.59,68.05) v1(179.62,33.12) v1(180.1,23.88) v1(180.18,33.31) v1(180.48,75.9) v1(180.76,48.38) v1(181.34,48.5) v1(181.37,23.88) v1(181.51,75.15) v1(181.72,27.65) v1(181.72,26.38) v1(181.72,25.11) v1(181.94,48.48) v1(181.9,28.9) v1(182.57,74.47) v1(183.11,29.28) v1(183.68,73.85) v1(184.38,29.28) v1(184.72,73.12) v1(185.53,72.14) v1(185.61,65.27) v1(185.62,34.55) v1(185.65,29.28) v1(186.52,71.35) v1(186.8,34.55) v1(186.92,29.28) v1(187.03,31.85) v1(187.6,39.11) v1(187.67,70.81) v1(188.24,39.11) v1(188.19,29.28) v1(188.82,70.28) v1(188.91,61.62) v1(188.93,39.11) v1(189.46,29.28) v1(189.57,39.11) v1(189.97,69.74) v1(190.29,34.39) v1(190.73,29.28) v1(191.12,69.2) v1(192,29.28) v1(192.29,68.7) v1(193.01,61.95) v1(193.27,29.28) v1(193.55,68.89) v1(194.06,31.74) v1(194.54,29.28) v1(194.7,31.73) v1(194.81,69) v1(194.81,35.83) v1(195.41,35.84) v1(195.61,47.22) v1(195.61,46.59) v1(195.61,45.95) v1(195.81,29.28) v1(195.99,35.84) v1(196.06,68.77) v1(196.25,47.22) v1(196.25,46.59) v1(196.25,45.95) v1(196.25,45.32) v1(196.57,44.81) v1(196.58,35.83) v1(196.83,59.92) v1(196.88,47.22) v1(196.88,46.59) v1(196.88,45.95) v1(196.88,45.32) v1(197.08,29.28) v1(197.2,44.81) v1(197.29,68.46) v1(197.47,59.92) v1(197.52,47.22) v1(197.52,46.59) v1(197.52,45.95) v1(197.52,45.32) v1(197.52,44.3) v1(197.84,44.81) v1(198.1,59.92) v1(198.15,45.32) v1(198.15,44.3) v1(198.35,29.28) v1(198.53,68.2) v1(198.53,44.81) v1(198.74,59.92) v1(199.37,59.92) v1(199.62,29.28) v1(199.78,67.97) v1(200.89,29.28) v1(201.04,67.79) v1(201.52,56.24) v1(201.52,55.6) v1(201.52,54.97) v1(201.52,54.33) v1(202.16,29.28) v1(202.3,67.65) v1(203.45,47.01) v1(203.45,44.77) v1(203.43,29.28) v1(203.57,67.55) v1(204.12,59.48) v1(204.57,45.89) v1(204.7,29.28) v1(204.84,67.48) v1(205.34,63.85) v1(205.68,47.01) v1(205.68,44.77) v1(205.97,29.28) v1(206.4,65.68) v1(206.4,62.02) v1(206.83,55.34) v1(206.79,41.14) v1(206.79,39.38) v1(207.24,29.28) v1(207.56,55.57) v1(208.2,55.57) v1(208.5,65.68) v1(208.5,62.02) v1(208.51,29.28) v1(208.83,55.57) v1(209.58,67.63) v1(209.56,63.85) v1(209.78,29.28) v1(211.05,29.28) v1(211.17,67.8) v1(212.32,29.28) v1(213.44,49.37) v1(213.46,28.72) v1(213.53,27.46) v1(213.53,26.19) v1(213.53,24.92) v1(214.28,23.88) v1(215.55,23.88) v1(216.11,68.79) v1(216.06,55.24) v1(216.19,53.17) v1(216.16,51.4) v1(216.4,49.06) v1(216.39,48.45) v1(216.4,47.84) v1(216.61,45.84) v1(216.62,43.67) v1(216.82,23.88) v1(217.41,68.97) v1(217.69,62.74) v1(218.02,61.16) v1(218,60.54) v1(217.99,53.63) v1(218.01,49.07) v1(218.09,23.88) v1(218.63,61.15) v1(218.64,60.51) v1(218.68,68.97) v1(218.65,52.23) v1(218.66,50.48) v1(219.36,23.88) v1(219.87,65.24) v1(219.95,68.97) v1(220.51,37.94) v1(220.63,23.88) v1(221.22,68.97) v1(221.24,62.01) v1(221.9,23.88) v1(221.95,36.24) v1(222.49,68.97) v1(222.67,67.9) v1(222.77,62.01) v1(223.17,23.88) v1(223.63,41.41) v1(223.73,60.05) v1(223.76,68.97) v1(224.11,67.14) v1(224.44,23.88) v1(224.82,65.34) v1(225.03,68.97) v1(225.01,47.9) v1(224.97,46.63) v1(224.97,45.36) v1(224.97,44.09) v1(224.97,42.82) v1(224.97,41.55) v1(224.97,40.28) v1(224.97,39.01) v1(224.97,37.74) v1(224.97,36.47) v1(224.97,35.2) v1(224.97,33.93) v1(224.97,32.66) v1(224.97,31.39) v1(224.97,30.12) v1(224.97,28.85) v1(224.97,27.58) v1(224.97,25.04) v1(225.1,53.55) v1(225.33,51.75) v1(225.3,49.14) v1(225.66,59.83) v1(225.92,63.03) v1(225.87,50.27) v1(226.07,53.22) v1(226.3,68.97) v1(226.37,58.15) v1(226.53,61.37) v1(226.52,51.36) v1(226.59,65.16) v1(227.18,52.45) v1(227.55,68.74) v1(227.73,53.59) v1(227.97,67.54) v1(227.97,66.27) v1(227.97,65) v1(227.97,63.73) v1(227.97,62.46) v1(227.97,61.19) v1(227.97,59.92) v1(227.97,58.65) v1(227.97,57.38) v1(227.97,56.11) v1(227.96,54.84) v3(26.18,80.83) v3(26.77,97.95) v3(36.13,34.7) v3(39.3,125.08) v3(44.89,134.65) v3(45.55,23.88) v3(45.91,25.36) v3(57.69,46.36) v3(76.74,149.08) v3(78.93,46.29) v3(86.46,41.09) v3(94.5,129.88) v3(102.78,61.65) v3(104.66,145.49) v3(115.96,112.48) v3(137.58,105.82) v3(153.67,105.7) v3(156.63,106.76) v3(157.78,90.08) v3(158.3,80.32) v3(161.37,107.25) v3(161.58,111.62) v3(162.8,63.56) v3(167.62,91.47) v3(191.22,59.85) v3(197.7,58.4)
