# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 124.27,137.08 124.29,137.05 124.33,137.01 124.36,136.84 124.37,136.78 124.35,136.72 124.35,136.51 124.34,136.43 124.05,136.14 124.04,136.14 123.89,136.05 123.8,135.9 123.79,135.88 121.25,133.34 121.24,133.34 121.09,133.25 121,133.1 120.99,133.08 120.25,132.34 120.24,132.34 120.09,132.25 120,132.1 119.99,132.08 119.66,131.75 119.2,131.75 119.07,131.87 119.07,132.22 119.5,132.65 119.52,132.69 119.53,132.7 119.65,132.82 119.7,132.98 119.7,132.98 119.73,133.06 119.81,133.08 119.82,133.08 119.91,133.08 119.99,133.11 120,133.12 120.07,133.12 120.4,133.45 120.42,133.45 120.55,133.51 120.65,133.62 120.7,133.81 120.63,134 120.63,134.03 120.97,134.37 121.48,134.37 122.81,135.69 122.81,136.2 123.12,136.52 123.15,136.5 123.51,136.49 123.7,136.81 123.7,136.83 123.85,136.99 123.87,136.99 123.94,137.03 124,137.08
GND on BOTTOM (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.14,46.13 15.14,44.94 14.76,44.56 12.61,44.56 11.84,43.79 11.84,37.98 12.02,37.8 14.66,37.8 15.09,37.37 15.09,36.24 14.62,35.78 14.58,35.09 14.16,34.55 14.16,34.19 13.71,34.19 13.71,34.82 13.74,34.84 14.2,35.62 13.5,36.21 5,36.21 4.79,36.29 4.71,36.5 4.71,45.9 4.79,46.11 5,46.19 13.5,46.19 14.2,46.78 13.74,47.56 13.71,47.58 13.71,48.11 14.16,48.11
GND on BOTTOM (solid shape): 126.3,134.96 126.19,134.57 126.14,134.56 125.37,133.8 125.36,133.75 125.27,133.61 125.11,133.57 124.93,133.53 124.85,133.37 124.78,133.24 124.64,133.19 124.56,133.19 124.37,133 124.36,132.95 124.3,132.84 124.14,132.76 123.53,132.16 123.56,132.06 123.54,131.89 123.4,131.78 123.36,131.77 123.14,131.55 123.12,131.46 123.11,131.43 123.09,131.39 123.09,131.37 122.43,130.71 122.43,130.67 121.92,130.16 121.66,130.16 121.58,130.26 121.47,130.33 121.41,130.4 121.43,130.5 123.18,132.24 123.18,132.27 123.91,133 123.92,133.05 123.98,133.16 124.14,133.23 124.47,133.56 124.5,133.56 125.03,134.09 125.2,134.09 125.91,134.8 125.92,134.85
GND on BOTTOM (solid shape): 118.1,86.3 118.33,86.18 118.57,86.3 118.75,86.3 118.98,86.18 119.22,86.3 119.4,86.3 119.45,86.24 119.52,86.2 119.58,86.15 119.59,86.08 119.67,85.75 120,85.67 120.03,85.68 120.13,85.59 120.08,85.48 120.06,85.45 120.03,85.46 119.84,85.45 119.68,85.34 119.51,85.34 119.25,85.47 118.98,85.36 118.97,85.34 118.88,85.34 118.86,85.36 118.61,85.47 118.35,85.36 118.33,85.34 118.24,85.34 118.23,85.36 117.97,85.47 117.71,85.36 117.7,85.34 117.61,85.34 117.57,85.39 117.47,85.47 117.47,85.7 117.5,85.71 117.66,85.87 117.69,86.1 117.68,86.12 117.74,86.19 117.76,86.19 117.85,86.23 117.92,86.3
GND on BOTTOM (solid shape): outline of 133 points within 80.17,122.15 93.53,139.39
GND on BOTTOM (solid shape): 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 10.89,66.75 11.68,65.96 11.68,64.82 15.1,61.4 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75
GND on BOTTOM (solid shape): 10.71,90.66 11.01,90.36 13.32,90.36 13.78,89.9 13.78,89.24 12.05,87.51 12.05,81.94 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.2,79.2 12.2,80.85 12,81.35 11.5,81.55 7.6,81.55 7.6,82.05 7.4,82.55 6.9,82.75 6.1,82.75 5.6,82.55 5.4,82.05 5.4,81.55 0.6,81.55 0.39,81.64 0.3,81.85 0.3,83.35 0.39,83.56 0.6,83.65 2,83.65 2.5,83.85 2.7,84.35 2.7,88.6 2.79,88.81 3,88.9 10.05,88.9 10.74,89.48 10.29,90.26 10.25,90.27 10.25,91.41 10.71,91.41
GND on BOTTOM (solid shape): outline of 84 points within 120.86,57.89 123.75,62.19
GND on BOTTOM (solid shape): outline of 98 points within 120.11,130.77 126.98,137.49
GND on BOTTOM (solid shape): outline of 183 points within 123.91,128.71 127.37,133.23
GND on BOTTOM (solid shape): outline of 285 points within 185.35,33.68 190.51,36.78
GND on BOTTOM (solid shape): outline of 439 points within 75.38,127.68 82.15,140.88
GND on BOTTOM (solid shape): outline of 1794 points within 0.2,0.2 228.2,155.3
GND on BOTTOM (solid shape): outline of 1961 points within 210.11,36.21 228.2,69.2
GND on BOTTOM (solid shape): outline of 15284 points within 55.46,44.79 98.21,114.86
GND on IN1 (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 14.66,22.94 15.09,22.51 15.09,21.17 14.56,20.64 4.71,20.64 4.71,22 4.79,22.21 5,22.29 13.5,22.29 14.2,22.88 13.74,23.66 13.71,23.68 13.71,24.54 14.16,24.54
GND on IN1 (solid shape): outline of 89 points within 166.04,68.54 168.72,71.56
GND on IN1 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,44.94 14.75,44.55 12.58,44.55 11.85,43.81 11.85,37.98 12.12,37.7 14.54,37.7 14.87,37.37 14.87,36.02 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN1 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,44.94 14.86,44.65 12.68,44.65 11.85,43.82 11.85,37.98 12.12,37.7 14.54,37.7 14.87,37.37 14.87,36.02 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN1 (solid shape): 5.39,66.25 5.6,65.75 6.1,65.54 6.9,65.54 7.4,65.75 7.61,66.25 7.61,66.74 10.9,66.74 11.65,65.99 11.65,64.97 11.65,64.97 11.65,64.87 15.09,61.43 15.09,60.35 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.41 13.71,58.41 13.71,58.72 13.74,58.74 14.2,59.52 13.5,60.11 5,60.11 4.79,60.19 4.71,60.4 4.71,64.2 4.5,64.7 4,64.91 0.6,64.91 0.39,64.99 0.31,65.2 0.31,66.45 0.39,66.66 0.6,66.74 5.39,66.74
GND on IN1 (solid shape): 10.71,90.66 10.71,90.66 10.71,90.55 10.83,90.46 10.94,90.34 16.51,90.34 16.81,90.04 16.81,89.09 16.65,88.92 15.79,88.92 15.19,88.32 12.94,88.32 12.05,87.42 12.05,84.09 12.05,84.09 12.05,81.87 12.15,81.81 12.24,81.74 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.21,79.2 12.21,80.85 12,81.35 11.5,81.56 7.61,81.56 7.61,82.05 7.4,82.55 6.9,82.76 6.1,82.76 5.6,82.55 5.39,82.05 5.39,81.56 0.6,81.56 0.39,81.64 0.31,81.85 0.31,83.35 0.39,83.56 0.6,83.64 2,83.64 2.5,83.85 2.71,84.35 2.71,88.6 2.79,88.81 3,88.89 10.05,88.89 10.74,89.48 10.29,90.26 10.26,90.28 10.26,91.4 10.71,91.4
GND on IN1 (solid shape): outline of 184 points within 79.82,126.36 94.09,134.22
GND on IN1 (solid shape): outline of 195 points within 19.31,27.54 29.68,54.49
GND on IN1 (solid shape): outline of 472 points within 39.5,21.37 56.12,31.06
GND on IN1 (solid shape): outline of 1178 points within 181.05,23.65 228.2,75.55
GND on IN1 (solid shape): outline of 1401 points within 14.08,88.94 30.54,106.6
GND on IN1 (solid shape): outline of 1795 points within 0.21,0.2 228.2,155.3
GND on IN1 (solid shape): outline of 1944 points within 184.55,42.6 210.88,56.65
GND on IN2 (solid shape): 209.07,55.68 209.07,55.46 208.96,55.35 207.18,55.35 206.92,55.09 206.63,55.09 206.52,55.21 206.52,55.4 206.9,55.78 208.96,55.78
GND on IN2 (solid shape): 134.77,114.93 134.79,114.82 134.7,114.75 132.6,114.75 132.6,114.75 131.11,114.75 130.24,115.63 129.92,115.63 129.92,116.44 133.25,116.44
GND on IN2 (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 14.66,22.87 15.1,22.43 15.1,21.17 14.56,20.63 4.7,20.63 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on IN2 (solid shape): 89.01,133.12 89.01,131.58 89.45,131.14 89.54,131.14 89.55,131.13 89.73,131.08 89.91,131.14 93.25,131.14 93.72,130.67 93.72,129.19 93.26,128.74 89.14,128.74 88.71,128.3 88.71,126.77 88.3,126.36 84.45,126.36 84.24,126.58 84.24,127.61 84.28,127.62 84.33,127.61 84.76,127.72 84.75,128.16 84.73,128.23 84.75,128.29 84.76,128.74 84.33,128.84 84.28,128.83 84.24,128.85 84.24,131.23 84.29,131.24 84.35,131.22 84.82,131.26 84.84,131.73 84.82,131.8 84.84,131.86 84.82,132.34 84.35,132.37 84.35,133.61 84.57,133.83 88.3,133.83
GND on IN2 (solid shape): 14.16,47.85 14.43,47.6 14.6,47.28 15.15,46.73 15.15,44.94 14.85,44.64 12.7,44.64 11.85,43.79 11.85,37.98 12,37.83 14.77,37.83 15.15,37.45 15.15,36.64 14.92,36.42 14.9,36.42 14.53,36.04 14.59,35.91 14.63,35.78 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 6.96,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.72,45.99 4.76,46.07 4.86,46.16 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN2 (solid shape): 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 10.87,66.75 11.65,65.96 11.65,64.88 15.12,61.41 15.12,60.37 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75
GND on IN2 (solid shape): 10.71,90.66 10.71,90.66 10.71,90.55 10.82,90.46 10.92,90.36 13.46,90.36 13.89,89.94 13.89,89.2 13.55,88.86 11.94,88.86 11.76,88.68 11.76,81.98 12.01,81.89 12.24,81.74 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.21,79.2 12.21,80.85 12,81.35 11.5,81.56 8.24,81.56 7.61,81.56 7.61,82.05 7.4,82.55 6.9,82.76 6.1,82.76 5.6,82.55 5.39,82.05 5.39,81.56 3.68,81.56 0.6,81.56 0.39,81.64 0.31,81.85 0.31,83.35 0.39,83.56 0.6,83.64 2,83.64 2.5,83.85 2.71,84.35 2.71,88.6 2.79,88.81 3,88.89 10.05,88.89 10.74,89.48 10.29,90.26 10.26,90.28 10.26,91.4 10.71,91.4
GND on IN2 (solid shape): 172.62,89.5 172.68,89.43 176.43,80.42 183.82,74.04 184.78,73.38 185.55,72.51 185.83,72.11 186.04,71.87 186.31,71.7 192.07,69.01 192.48,68.91 192.91,68.95 193.27,69.05 194.56,69.24 195.85,69.07 206.29,67.7 216.71,69.19 216.72,69.2 226.9,69.2 227.82,68.82 228.2,67.9 228.2,55.03 228.02,53.75 227.51,52.57 225.94,49.94 225.39,48.65 225.2,47.27 225.2,23.95 225.11,23.74 224.9,23.65 213.6,23.65 213.39,23.74 213.3,23.95 213.3,27.53 213.59,27.81 213.7,27.83 213.76,27.74 213.76,24.11 224.74,24.11 224.74,47.27 224.94,48.78 225.54,50.18 227.12,52.8 227.58,53.88 227.74,55.03 227.74,67.9 227.49,68.49 226.9,68.74 216.79,68.74 206.26,67.24 195.73,68.62 194.56,68.78 193.39,68.61 193.03,68.51 192.44,68.45 191.87,68.6 186.11,71.28 185.74,71.52 185.45,71.85 185.17,72.25 184.47,73.03 183.6,73.63 176.05,80.15 172.22,89.36 172.33,89.47 172.35,89.47 172.44,89.47 172.53,89.5
GND on IN2 (solid shape): outline of 1859 points within 0.2,0.21 228.19,155.29
GND on IN2 (solid shape): outline of 2445 points within 171.79,23.65 228.2,88.85
GND on IN2 (solid shape): outline of 15918 points within 102.11,113.71 170.98,155.3
GND on IN2 (solid shape): outline of 23010 points within 55.66,43.23 125.71,112.94
GND on IN3 (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 15.1,22.51 15.1,21.17 14.56,20.63 5.52,20.63 5.51,20.63 4.7,20.63 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on IN3 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,44.94 14.84,44.63 12.67,44.63 11.85,43.81 11.85,37.98 12.12,37.7 14.54,37.7 14.87,37.37 14.87,36.02 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN3 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,44.94 14.85,44.65 12.66,44.65 11.85,43.84 11.85,37.98 12.12,37.7 14.54,37.7 14.87,37.37 14.87,36.02 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN3 (solid shape): 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 10.89,66.75 11.65,65.99 11.65,64.88 15.1,61.44 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75
GND on IN3 (solid shape): 10.71,90.66 10.71,90.66 10.71,90.55 10.93,90.36 11.09,90.11 13.37,90.11 13.76,89.72 13.76,89.26 11.69,87.2 11.69,82.02 11.73,81.99 12,81.9 12.24,81.74 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.21,79.2 12.21,80.85 12,81.35 11.5,81.56 7.61,81.56 7.61,82.05 7.4,82.55 6.9,82.76 6.1,82.76 5.6,82.55 5.39,82.05 5.39,81.56 0.6,81.56 0.39,81.64 0.31,81.85 0.31,83.35 0.39,83.56 0.6,83.64 2,83.64 2.5,83.85 2.71,84.35 2.71,88.6 2.79,88.81 3,88.89 10.05,88.89 10.74,89.48 10.29,90.26 10.26,90.28 10.26,91.4 10.71,91.4
GND on IN3 (solid shape): outline of 264 points within 213.04,23.65 225.2,34.09
GND on IN3 (solid shape): outline of 92 points within 161.96,119.89 170.63,154.8
GND on IN3 (solid shape): outline of 584 points within 202.65,50.72 228.2,69.2
GND on IN3 (solid shape): outline of 1805 points within 0.21,0.2 228.2,155.3
GND on GND1: outline of 259 points within 0.2,0.2 228.2,151.13
GND on VCC: 106.23,145.6 106.23,145.6 102.72,145.6 102.72,147.95 105.17,147.95 107.29,150.07 117.15,150.07 121.62,145.6
GND on VCC: 57.13,42.71 56.64,43.2 56.64,109.03 58.4,110.79 87.4,110.79 90.57,107.61 115.97,107.61 122.18,101.41 122.18,94 118.37,90.19 118.37,78.49 118.27,78.4 118.27,78.19 118.37,78.09 118.37,73.68 117.73,73.05 117.73,65.29 117.63,65.02 117.73,64.76 117.73,63.67 113.43,63.67 112.02,62.25 112.02,49.7 101.37,49.7 94.38,42.71
GND on VCC: 175.52,58.15 173.2,58.15 173.18,58.13 173.18,53.66 173.2,53.65 177.66,53.65 177.69,53.67 177.69,58.14 177.68,58.15 175.53,58.15
GND on VCC: 154.32,143.95 154.02,144.25 154.02,145.24 154.66,145.88 154.66,146.66 154.4,146.91 154.4,148.42 154.89,148.9 156.01,148.9 156.37,148.54 156.37,147.61 156.05,147.29 156.05,145.71 155.67,145.33 155.67,144.06 155.57,143.95
GND on VCC: 32.57,119.31 32.22,119.67 32.22,126.47 32.73,126.98 39.35,126.98 40.17,126.17 40.17,120.26 39.22,119.31
GND on VCC: 12.2,79.9 12.2,80.85 12,81.35 11.5,81.55 7.6,81.55 7.6,82.05 7.4,82.55 6.9,82.75 6.1,82.75 5.6,82.55 5.4,82.05 5.4,81.55 0.6,81.55 0.39,81.64 0.3,81.85 0.3,83.35 0.39,83.56 0.6,83.65 2,83.65 2.5,83.85 2.7,84.35 2.7,88.6 2.79,88.81 3,88.9 10.05,88.9 10.75,89.5 10.25,90.27 10.25,103.43 10.75,104.2 10.05,104.8 2,104.8 1.79,104.89 1.7,105.1 1.7,107.3 1.79,107.51 2,107.6 3.35,107.6 3.85,107.8 4.05,108.3 4.05,114.8 3.85,115.3 3.35,115.5 0.5,115.5 0.29,115.59 0.2,115.8 0.2,126.6 0.29,126.81 0.5,126.9 1.05,126.9 1.55,127.1 1.75,127.6 1.75,133.6 1.84,133.81 2.05,133.9 23.77,133.9 24.03,133.63 24.03,119.87 23.51,119.34 18.12,119.34 13.18,114.4 13.18,108.09 18.88,102.39 18.88,89.55 16.13,86.8 16.13,85.53 20.73,80.93 20.73,79.27 20.52,79.05 16.07,79.05 15.23,79.9
GND on VCC: 11,0.2 10.79,0.29 10.7,0.5 10.7,4.6 10.67,4.81 10.58,4.99 10.97,5.38 13.28,5.38 14.62,6.72 16.65,6.72 17.28,7.35 18.72,7.35 19.15,6.92 24.9,6.92 26.32,8.34 26.32,10.81 25.95,11.18 24.77,11.18 24.42,10.83 24.42,8.8 23.98,8.36 23.08,8.36 22.01,9.43 22.01,9.63 21.55,10.1 19.58,10.1 19.47,10.21 19.47,11.13 19.57,11.24 20.85,11.24 21.42,11.81 24.22,11.81 24.55,12.13 24.55,15.37 24.6,15.43 29.17,15.43 30.85,17.1 31.28,17.1 31.71,17.53 31.71,18.04 41,18.04 41,4.1 40.92,3.9 40.72,3.8 40.7,3.8 36.6,3.8 36.1,3.6 35.9,3.1 35.9,0.5 35.81,0.29 35.6,0.2
GND on VCC: 4.7,20.33 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.2,22.9 13.7,23.67 13.7,34.83 14.2,35.6 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.2,46.8 13.7,47.57 13.7,58.73 14.2,59.5 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 10.88,66.75 15.46,62.16 20.74,62.16 20.74,55.25 22.39,53.6 22.39,45.9 21.43,44.95 21.43,44.93 21.37,44.87 21.37,44.66 21.43,44.59 21.43,24.62 19.66,24.62 19.13,24.09 19.13,23.33 18.37,22.56 16.29,22.56 15.73,22.01 15.73,21.25 14.81,20.33
GND on GND2: outline of 296 points within 0.2,0.2 228.2,155.3
VCCGT_B+ on TOP (solid shape): 166.01,95.22 166.01,92.48 165.97,92.44 162.42,92.44 162.31,92.54 162.31,95.25 162.57,95.51 165.73,95.51
VCCGT_B+ on BOTTOM (solid shape): 160.09,100.81 160.64,100.81 160.64,101.37 160.89,101.37 160.89,100.81 161.44,100.81 161.44,101.37 161.79,101.37 162.85,100.31 163.51,100.31 163.51,100.31 167.77,100.31 168.23,99.85 168.23,95.14 168.69,94.67 168.69,92.26 169.07,91.88 169.07,89.96 169.01,89.89 168.64,89.89 168.44,90.1 168.44,91.56 168.06,91.94 168.06,92.59 167.91,92.73 166.36,92.73 166.03,92.4 162.87,92.4 162.83,92.44 162.83,93.27 162.66,93.44 159.66,93.44 159.62,93.48 159.62,94.6 159.68,94.66 160.93,94.66 161.17,94.9 161.17,95.49 161.17,95.49 161.17,95.57 161.29,95.69 161.87,95.69 162.05,95.88 162.05,98.21 161.67,98.59 159.2,98.59 158.94,98.85 158.94,100.9 159.03,100.99 159.04,100.99 159.42,101.37 160.09,101.37
VCCSA_B+ on TOP (solid shape): 162.77,62.47 162.77,60.8 162.64,60.68 162.64,59.88 162.63,59.79 162.64,59.69 162.64,59.63 162.58,59.56 159.39,59.56 159.03,59.92 159.03,62.48 159.51,62.96 162.28,62.96
VCCSA_B+ on BOTTOM (solid shape): 163.23,62.8 163.23,62.29 163.44,62.08 163.88,62.08 163.99,61.97 163.99,60.64 163.76,60.41 162.83,60.41 162.66,60.24 162.66,59.91 162.64,59.81 162.66,59.72 162.66,59.64 162.63,59.61 161.28,59.61 160.82,60.07 158.21,60.07 158.09,60.19 158.09,60.7 158.15,60.76 158.66,60.76 158.85,60.96 158.85,62.89 158.99,63.03 162.99,63.03
VDD10 on TOP (solid shape): 22.3,87.92 22.3,87.1 22.3,87.1 22.3,86.4 22.17,86.27 21.11,86.27 20.99,86.38 20.99,87.91 21.14,88.05 22.16,88.05
VDD10 on BOTTOM (solid shape): 21.85,82.2 21.85,80.82 21.74,80.71 21.2,80.71 21.1,80.61 20.55,80.61 20.35,80.8 20.35,82.14 20.53,82.32 21.74,82.32
VDD10 on IN1 (solid shape): 22.78,81.35 22.77,81.31 22.83,80.89 23.25,80.83 23.28,80.85 23.88,80.26 23.88,78.83 23.58,78.53 22.29,78.53 22.04,78.78 22.04,79.47 21.52,79.99 21.04,79.99 20.65,80.37 20.65,81.58 20.8,81.73 22.4,81.73
VDD10 on IN3 (solid shape): 22.23,87.67 22.23,86.48 21.96,86.2 21.11,86.2 20.89,86.41 20.89,87.68 21.12,87.91 22,87.91
VDD10 on IN3 (solid shape): 22.32,81.82 22.32,81.54 21.39,80.61 20.61,80.61 20.48,80.74 20.48,81.33 21.48,82.33 21.81,82.33
VDD_1.2V on TOP (solid shape): 36.15,27.64 36.15,26.82 35.14,25.81 34.96,25.81 34.84,25.68 34.84,25.05 34.77,24.98 32.15,24.98 31.99,25.14 31.99,25.99 32.11,26.11 33.85,26.11 35.45,27.72 36.07,27.72
VDDREG on TOP (solid shape): 23.38,85.81 23.38,84.87 23.3,84.79 23.3,83.96 23.25,83.91 23.14,83.91 23.09,83.97 23.09,84.72 22.93,84.88 22.8,84.88 22.76,84.88 22.65,84.99 22.65,85.82 22.72,85.9 23.19,85.9 23.29,85.9
VDDREG on BOTTOM (solid shape): 23.69,85.55 23.69,85.34 23.95,85.09 23.95,84.6 23.8,84.46 22.04,84.46 21.94,84.56 21.94,85.46 22.04,85.56 22.65,85.56 22.76,85.67 22.76,85.79 22.87,85.9 23.34,85.9
+BIF_VDDC on TOP (solid shape): 125.47,137.59 125.47,136.88 125.47,136.83 125.38,136.74 124.88,136.74 124.74,136.88 124.03,136.88 123.94,136.97 122.87,136.97 122.69,137.15 122.69,137.68 122.87,137.86 125.2,137.86
+BIF_VDDC on TOP (solid shape): 123.3,143.62 123.3,142.94 123.9,142.33 123.9,142.12 123.85,142.12 123.85,142.02 123.54,141.71 121.89,141.71 121.65,141.96 121.67,141.99 121.67,142.36 121.34,142.53 121.26,142.56 121.23,142.64 121.23,143.71 121.26,143.75 123.17,143.75
+BIF_VDDC on IN3 (solid shape): outline of 433 points within 121.61,136.88 126.19,142.89
+CCG_VBUS on TOP (solid shape): 77.73,144.6 77.73,142.24 77.53,142.03 76.42,142.03 76.2,142.26 76.2,144.57 76.44,144.81 77.52,144.81
+CCG_VBUS on TOP (solid shape): 45.58,140.2 45.58,137.35 45.69,137.23 45.69,136.34 45.65,136.3 43.19,136.3 42.91,136.58 42.91,140.14 43.19,140.42 45.35,140.42
+CCG_VBUS on TOP (solid shape): 39.72,129.83 39.72,129.01 40.23,128.5 40.23,127.34 39.7,127.34 39.7,126.68 39.47,126.46 39.01,126.46 38.74,126.73 38.74,127.83 38.69,127.89 38.69,127.93 38.63,127.99 38.63,129.91 38.72,130 39.55,130
+CCG_VBUS on TOP (solid shape): 12.11,121.65 12.11,121.38 11.91,121.18 11.59,121.18 11.51,121.1 11.51,120.47 11.13,120.09 11.13,119.55 10.94,119.36 10.4,119.36 10.26,119.5 9,119.5 8.9,119.6 7.91,119.6 7.85,119.66 6.97,119.66 6.81,119.66 6.66,119.75 6.48,119.74 6.47,119.75 6.47,120.01 6.51,120.04 6.59,120.04 6.67,120.05 6.83,120.05 6.87,120 8.04,120 8.15,119.97 8.26,119.98 8.32,120 8.38,120.03 10.4,120.03 10.8,120.43 10.8,121.47 11.12,121.79 11.97,121.79
+CCG_VBUS on TOP (solid shape): outline of 186 points within 11.99,126.4 17.54,132.74
+CCG_VBUS on BOTTOM (solid shape): 14.69,128.91 14.69,127.5 14.57,127.38 12.03,127.38 11.9,127.52 11.9,129.09 12.15,129.34 14.26,129.34
+CCG_VBUS on BOTTOM (solid shape): outline of 118 points within 7.47,118.43 12.11,122.79
+CCG_VBUS on IN1 (solid shape): 76.86,143.18 76.86,141.44 76.7,141.28 76.09,141.28 75.84,141.54 75.84,143.01 76.09,143.26 76.77,143.26
+CCG_VBUS on IN1 (solid shape): outline of 271 points within 37.47,127.6 47.73,140.52
+CCG_VBUS on IN2 (solid shape): outline of 2724 points within 8.09,118.7 45.01,140.46
+CCG_VBUS on IN3 (solid shape): 45.82,140.08 45.82,133.41 45.25,132.84 45.25,132.76 45.2,132.75 44.46,132.57 43.79,132.2 42.71,130.57 42.93,128.63 42.93,128.62 42.93,127.94 42.35,127.36 39.06,127.36 38.71,127.72 38.7,127.83 38.65,127.93 38.65,130.07 38.69,130.1 38.72,130.1 38.74,130.1 39.24,130.41 38.77,130.76 38.74,130.75 38.65,130.83 38.65,132.81 38.75,132.91 39.08,132.91 39.1,132.93 39.13,132.93 39.22,132.86 39.19,132.75 39.43,132.13 39.66,132.75 39.64,132.86 39.73,132.93 40.5,132.93 40.63,132.92 40.65,132.88 40.62,132.83 40.69,132.14 40.93,132.79 40.88,132.9 40.96,132.98 42.19,133.74 42.67,135.1 42.67,140.04 43.09,140.46 45.44,140.46
+CCG_VBUS_1 on TOP (solid shape): 51.96,139.99 51.96,137.71 51.85,137.6 50.84,137.6 50.41,137.18 50.41,136.7 50.41,136.69 50.41,136.52 50.28,136.39 49.26,136.39 49.17,136.3 45.93,136.3 45.88,136.36 45.88,137.13 46.2,137.45 46.2,140.4 46.41,140.61 51.34,140.61
+CHARGER_SRC on TOP (solid shape): 201.07,56.62 201.07,53.64 200.95,53.51 199.74,53.51 199.55,53.7 199.55,56.43 199.77,56.65 201.04,56.65
+CHARGER_SRC on BOTTOM (solid shape): 201.33,60.24 201.33,56.68 200.98,56.33 200.98,53 200.78,52.8 199.4,52.8 199.11,52.51 199.11,52.5 198.47,51.86 194.09,51.86 193.9,52.05 193.9,52.43 194.98,53.51 194.98,55.99 194.85,56.11 187.62,56.11 187.37,56.36 187.37,57.54 187.89,57.54 187.89,58.24 187.37,58.24 187.37,58.74 187.89,58.74 187.89,59.44 187.37,59.44 187.37,60.03 187.45,60.1 196.31,60.1 196.31,57.01 196.83,56.49 199.73,56.49 199.88,56.65 199.96,56.65 199.96,56.72 200.22,56.98 200.22,60.04 199.89,60.37 196.58,60.37 196.31,60.1 187.45,60.1 187.63,60.28 190.65,60.28 190.89,60.52 190.89,61.22 191.05,61.38 200.19,61.38
+DC_IN on TOP (solid shape): 85.07,148.1 85.28,148.1 85.38,148.09 85.48,148.1 85.89,148.1 85.99,148.09 86.09,148.1 86.21,148.1 86.47,147.84 86.47,147.52 87.11,146.87 88.16,146.87 88.46,146.66 88.79,146.81 88.9,146.7 89.87,146.7 89.88,146.7 90,146.68 90.13,146.7 90.14,146.7 90.44,146.7 90.55,146.24 91.02,146.3 91.82,146.3 92.6,147.07 93.75,147.07 94.08,146.74 94.08,144.58 94.01,144.52 91.52,144.52 91.26,144.27 90.04,144.27 89.76,143.99 89.44,143.99 89.12,143.99 89.1,143.99 89.1,144.41 89.09,144.5 89,144.51 88.59,144.51 88.59,143.99 88.32,143.99 88.3,143.99 88.3,144.51 87.79,144.51 87.79,143.99 86.22,143.99 86.21,143.98 86.18,143.98 85.77,143.57 83.81,143.57 83.8,143.56 83.59,143.56 83.45,143.7 83.45,144.76 83.31,144.9 83.31,146.88 82.55,147.65 82.39,147.65 82.34,147.7 82.34,148.26 82.46,148.38 84.8,148.38
+DC_IN_SS on TOP (solid shape): 93.63,142.36 93.63,138.3 93.25,137.92 91.82,137.92 91.62,138.12 91.62,142.38 91.84,142.6 93.39,142.6
+DC_IN_SS on TOP (solid shape): 99.77,146.36 99.96,146.36 100.17,146.15 100.17,143.38 99.73,142.93 99.72,142.93 99.55,142.76 97.52,142.76 97.44,142.8 97.42,142.89 97.28,143.25 96.89,143.26 96.86,143.24 96.78,143.31 96.29,143.31 95.91,142.93 94.71,142.93 94.4,143.25 94.4,146.3 94.78,146.68 99.45,146.68
+DC_IN_SS on BOTTOM (solid shape): 203.47,60.49 203.47,60.13 202.46,59.13 202.47,59.12 202.19,58.84 202,58.84 201.48,59.36 201.48,60.3 200.98,60.79 200.98,60.97 201.75,61.74 202.21,61.74
+DC_IN_SS on IN2 (solid shape): 203.47,60.69 203.47,60.06 202.69,59.27 202.11,59.27 201.14,60.24 201.14,60.5 201.89,61.25 202.91,61.25
+DC_IN_SS on IN2 (solid shape): outline of 121 points within 91.59,137.24 100.49,146.17
+DCBAT_LCD on BOTTOM (solid shape): 213.01,60.49 213.01,58.94 212.85,58.78 211.74,58.78 211.36,58.4 211.36,57 211.11,56.75 205.9,56.75 205.56,57.08 205.56,58.81 205.61,58.86 206.05,58.86 206.1,58.81 206.1,58.38 206.18,58.29 206.18,58.29 206.32,58.14 206.35,58.14 206.54,57.95 207.65,57.95 207.81,58.11 207.81,58.53 208.12,58.84 209.58,58.84 211.36,60.62 212.89,60.62
+LAN_VDD33 on TOP (solid shape): 22.56,80.9 22.56,80.4 22.55,80.39 22.55,79.78 22.39,79.61 22.39,78.98 22.08,78.67 21.29,78.67 21.09,78.87 21.09,79.88 21.65,80.44 21.65,80.86 21.78,80.98 22.48,80.98
+LAN_VDD33 on TOP (solid shape): 28.39,80.72 28.41,80.7 28.85,80.7 28.9,80.64 28.9,80.26 28.79,80.14 28.07,80.14 27.69,80.52 27.69,80.67 26.79,81.56 25.9,81.56 25.84,81.61 25.84,81.71 25.91,81.78 27.33,81.78
+LAN_VDD33 on TOP (solid shape): 19.81,86.85 19.81,86.01 18.89,85.09 18.62,85.09 18.25,85.07 18.23,84.7 18.24,84.66 18.22,84.63 18.1,84.51 17.31,84.51 17.3,84.5 15.02,84.5 14.91,84.61 14.91,85.12 15.45,85.12 15.45,85.55 14.91,85.55 14.91,86.68 15.11,86.88 15.99,86.88 16.66,86.2 18.61,86.2 18.89,86.49 18.89,86.85 19.03,86.98 19.68,86.98
+LAN_VDD33 on BOTTOM (solid shape): 28.13,82.35 28.13,80.77 27.96,80.6 26.89,80.6 26.74,80.75 26.74,82.52 26.83,82.61 27.87,82.61
+LAN_VDD33 on BOTTOM (solid shape): 22.26,80.42 22.26,78.81 22.17,78.72 21.21,78.72 21.08,78.86 21.08,80.24 21.25,80.42 21.26,80.42 21.31,80.47 22.2,80.47
+LAN_VDD33 on BOTTOM (solid shape): 21.28,85.44 21.28,84.56 21.43,84.56 21.69,84.3 21.69,83.61 21.65,83.57 21.06,83.57 21.06,83.58 20.9,83.73 20.27,83.73 19.97,84.03 19.97,85.1 20.35,85.47 21.25,85.47
+LAN_VDD33 on IN2 (solid shape): outline of 473 points within 15.85,78.63 22.31,87.83
+LAN_VDD33 on IN3 (solid shape): 27.69,81.44 28.06,81.44 28.18,81.33 28.18,80.7 28.05,80.57 27.29,80.57 25.99,79.27 23.11,79.27 22.58,78.74 21.11,78.74 20.91,78.94 20.91,80.03 21.08,80.2 21.51,80.2 22.31,80.99 22.76,80.99 23.08,80.79 23.4,80.99 23.87,80.99 24.2,80.79 24.52,80.99 24.99,80.99 25.44,80.81 25.65,81.25 25.65,81.28 26.1,81.74 27.39,81.74
+LCDVDD on TOP (solid shape): 213.05,49.46 213.05,48.22 212.99,48.16 211.57,48.16 211.57,48.16 210.89,48.16 210.71,47.98 209.6,47.98 209.44,48.14 208.62,48.14 208.51,48.25 208.51,48.5 208.8,48.79 208.8,48.96 209.1,48.96 209.1,48.9 209.11,48.85 209.12,48.8 209.15,48.75 209.18,48.71 209.21,48.67 209.26,48.64 209.3,48.61 209.35,48.59 209.4,48.58 209.46,48.57 209.51,48.58 209.56,48.59 209.61,48.61 209.66,48.64 209.7,48.67 209.74,48.71 209.77,48.75 209.79,48.8 209.8,48.85 209.81,48.9 209.81,48.96 209.8,49.01 209.79,49.06 209.77,49.11 209.74,49.15 209.7,49.19 209.66,49.23 209.61,49.25 209.56,49.27 209.51,49.28 209.46,49.29 209.4,49.28 209.35,49.27 209.3,49.25 209.26,49.23 209.21,49.19 209.18,49.15 209.15,49.11 209.12,49.06 209.11,49.01 209.1,48.96 208.8,48.96 208.8,49.22 209.09,49.51 210.34,49.51 210.36,49.49 210.41,49.47 210.46,49.46 210.51,49.45 210.56,49.45 210.61,49.45 210.66,49.47 210.7,49.49 210.76,49.52 210.81,49.57 212.95,49.57
+LCDVDD on BOTTOM (solid shape): 211.55,49.16 211.55,48.36 211.4,48.2 211.09,48.2 210.64,47.75 210.57,47.74 210.2,47.74 210.1,47.84 210.1,48.98 210.42,49.31 210.45,49.31 210.49,49.35 211.36,49.35
+LCDVDD_LCD on TOP (solid shape): 214.41,57.09 214.41,56.72 214.85,56.28 214.85,55.2 214.73,55.08 214.2,55.08 214.06,55.21 214.06,55.71 213.65,56.13 213.11,56.13 213,56.02 213,56.02 212.88,55.9 212.88,54.16 212.8,54.07 212.8,52.64 212.88,52.55 212.88,51.58 212.89,51.58 212.89,51.48 213.04,51.32 213.04,50.78 213.01,50.74 213.01,50.38 213.04,50.35 213.04,50.19 213.02,50.17 213.01,49.89 211.66,49.89 211.62,49.93 211.62,51.36 211.75,51.49 211.75,55.78 212.38,56.4 212.38,57.72 212.44,57.78 213.72,57.78
+LCDVDD_LCD on BOTTOM (solid shape): 214.8,57.53 214.8,57.29 214.79,57.28 214.79,56.32 214.66,56.19 213.39,56.19 213.08,56.51 213.08,56.66 212.95,56.78 211.91,56.78 211.81,56.88 211.81,57.57 211.85,57.65 211.93,57.67 211.98,57.67 212.77,57.67 212.89,57.7 212.99,57.78 214.55,57.78
+PCIE_VDDC on TOP (solid shape): 127.3,143.05 127.3,142.02 127.69,141.62 127.69,138.26 127.5,138.07 126.42,138.07 126.41,138.06 122.31,138.06 121.85,138.52 121.85,139.31 121.94,139.39 125.1,139.39 125.26,139.56 125.26,140.37 125.12,140.51 124.88,140.51 124.82,140.57 124.82,140.72 125.8,140.72 125.8,140.67 125.81,140.61 125.83,140.56 125.86,140.52 125.89,140.48 125.93,140.44 125.97,140.41 126.02,140.39 126.07,140.37 126.13,140.36 126.18,140.36 126.23,140.37 126.28,140.39 126.33,140.41 126.38,140.44 126.41,140.48 126.45,140.52 126.47,140.56 126.49,140.61 126.51,140.67 126.51,140.72 126.51,140.77 126.49,140.82 126.47,140.87 126.45,140.92 126.41,140.96 126.38,141 126.33,141.03 126.28,141.05 126.23,141.07 126.18,141.07 126.13,141.07 126.07,141.07 126.02,141.05 125.97,141.03 125.93,141 125.89,140.96 125.86,140.92 125.83,140.87 125.81,140.82 125.8,140.77 125.8,140.72 124.82,140.72 124.82,142.03 125.07,142.29 125.07,142.6 124.88,142.8 124.5,142.8 124.5,142.79 124.29,142.69 124.2,142.78 123.98,143.1 124.88,144 126.34,144
+PCIE_VDDC on BOTTOM (solid shape): 116.74,121.17 116.74,117.96 116.53,117.75 116.53,116.71 116.99,116.25 116.99,115.22 116.75,114.98 114.49,114.98 114.43,115.05 114.43,116.4 114.59,116.56 114.59,120.37 114.85,120.63 114.87,120.64 115.07,120.74 115.17,120.94 115.17,120.96 115.55,121.33 116.57,121.33
+PCIE_VDDC on IN1 (solid shape): outline of 2026 points within 112.75,120.1 127.93,142.96
+PWR_SRC_AC on BOTTOM (solid shape): 187.24,60.07 187.24,59.34 187.24,59.34 187.24,59.32 187.76,59.32 187.76,58.87 187.24,58.87 187.24,58.84 187.24,58.84 187.24,58.14 187.24,58.14 187.24,58.12 187.76,58.12 187.76,57.67 187.24,57.67 187.24,57.64 187.24,57.64 187.24,57 186.97,56.73 183.3,56.73 183.23,56.8 183.23,56.82 183.23,56.9 183.21,56.99 183.2,57.01 183.2,58.14 183.26,58.21 183.68,58.21 183.74,58.14 183.74,57.45 183.93,57.26 184.44,57.26 184.63,57.45 184.63,58.14 184.69,58.21 185.07,58.21 185.52,58.65 185.52,60.11 185.65,60.24 187.06,60.24
+SDC_IN on TOP (solid shape): 65.05,138.96 66.34,138.96 66.48,138.82 66.48,138.22 66.33,138.07 66.33,137.15 66.34,137.14 66.34,137.05 66.21,136.91 66.19,136.91 65.92,136.31 66.53,136.57 66.53,136.59 66.57,136.63 66.62,136.66 66.67,136.66 67.47,136.66 68.44,135.69 68.44,135.19 68.88,134.74 68.88,134.02 68.82,133.92 68.17,134.08 67.86,133.63 67.86,133.45 67.91,133.24 68.05,133.07 68.09,132.99 68.06,132.92 67.86,132.72 67.85,132.71 67.77,132.65 67.71,132.57 67.71,132.56 67.18,132.03 67.18,131.18 66.49,130.5 66.49,130.32 66.37,130.2 65.08,130.2 64.87,129.98 63.24,129.98 62.58,130.64 62.58,136.66 63.28,137.36 63.28,139.01 63.44,139.17 64.83,139.17
+SDC_IN on TOP (solid shape): outline of 184 points within 94.08,137.98 108.73,153.22
+SDC_IN on TOP (solid shape): outline of 542 points within 159.61,68.51 186.39,119.06
+SDC_IN on BOTTOM (solid shape): 130.44,152.38 130.56,152.36 130.68,152.38 135.94,152.38 136.18,152.14 136.18,149.79 135.86,149.47 130.56,149.47 130.04,149.99 130.04,152.07 130.35,152.38
+SDC_IN on BOTTOM (solid shape): 168.22,121 168.46,121 168.75,120.71 168.75,116.71 168.28,116.23 168.28,114.6 168.2,114.51 167.65,114.51 167.26,114.51 166.87,114.47 163.44,114.47 163.23,114.68 163.23,116.64 163.74,117.15 165.77,117.15 166.24,117.62 166.24,120.62 166.63,121.01 168.21,121.01
+SDC_IN on BOTTOM (solid shape): 185.19,61.77 185.19,59.34 185.09,59.24 184.53,59.24 184.53,59.77 184.17,60.13 183.81,59.77 183.81,59.24 183.36,59.24 183.23,59.37 183.23,61.4 183.23,61.49 183.3,61.56 183.3,61.85 183.42,61.97 185,61.97
+SDC_IN on BOTTOM (solid shape): 109.78,152.99 109.78,150.67 109.64,150.53 108.41,150.53 106.05,148.18 104.12,148.18 103.68,148.62 102.05,148.62 101.95,148.73 101.95,149.94 102.82,150.75 103.47,151.73 103.5,151.73 104.5,151.73 105.62,152.16 106.16,153.23 109.54,153.23
+SDC_IN on BOTTOM (solid shape): 171.48,91.44 173.9,82.69 179.63,75.64 179.65,75.62 179.65,75.46 178.5,74.31 178.23,74.31 178.16,74.39 176.36,76.15 176.36,76.36 175.52,77.2 174.49,78.55 174.49,78.94 174.4,79.07 173.44,80.39 172.49,81.71 172.46,81.74 172.33,81.87 172.31,81.91 171.01,84.24 170.28,86.8 170.28,86.86 169.76,87.38 169.76,87.44 169.6,87.59 169.6,88.62 169.26,88.96 169.26,92.07 168.88,92.45 168.88,94.8 168.44,95.25 168.44,100.48 168.46,100.5 168.44,100.78 168.44,100.98 168.44,102.8 168.72,103.08 168.72,103.25 170.73,103.25
+SDC_IN on IN3 (solid shape): outline of 1549 points within 64.5,130.99 106.79,151.71
+SDC_IN on VCC: outline of 103 points within 102.71,60.83 186.47,154.33
+SPLL_VDDC on TOP (solid shape): 132.03,124.21 132.03,123.79 132.88,122.94 132.88,122.68 133.06,122.5 133,122.11 133.35,121.91 133.42,121.83 133.42,119.21 133.36,119.15 132.6,119.15 132.56,119.18 132.56,120.82 131.94,121.44 131.94,121.54 131.97,121.62 132.06,121.64 132.5,122.07 131.91,122.25 131.88,122.24 131.86,122.24 131.84,122.25 131.31,122.79 131.31,123.97 131.31,123.97 131.31,124.21 131.49,124.39 131.85,124.39
+TP_VDD on BOTTOM (solid shape): 118.32,33.55 118.32,32.02 118.33,32.01 118.33,29.35 118.11,29.12 116.62,29.12 116.25,29.48 116.25,31.28 116.66,31.69 116.66,32.08 117.31,32.74 117.31,32.78 117.32,32.79 117.32,33.47 117.49,33.64 118.23,33.64
+TPAN_VDD on TOP (solid shape): 212.93,40.56 212.93,39.76 212.91,39.73 212.91,38.2 212.86,38.2 212.82,38.22 212.23,37.9 212.89,37.77 212.93,37.8 212.97,37.78 212.98,37.76 212.98,35.25 212.35,34.62 211.57,34.62 211.5,34.68 211.5,34.7 211.44,34.75 211.44,35.29 211.33,35.4 211.33,35.42 211,35.75 210.98,35.75 210.91,35.82 209.41,35.82 209.4,35.83 209.22,35.83 209.04,36.01 209.04,37.49 208.77,37.75 208.4,37.75 208.31,37.84 208.31,39.22 208.47,39.37 210.44,39.37 210.66,39.6 211.08,39.6 211.61,39.67 211.67,40.21 211.66,40.22 211.66,40.31 211.67,40.32 211.72,40.44 211.73,40.58 211.83,40.67 212.83,40.67
+TPAN_VDD on BOTTOM (solid shape): 212.93,41.01 212.93,40.72 213,40.65 213,39.52 212.82,39.34 211.95,39.34 211.79,39.49 211.79,41.01 211.9,41.11 212.83,41.11
+TPAN_VDD_F on TOP (solid shape): 213.75,40.63 213.76,40.6 213.78,40.55 213.8,40.51 213.96,40.37 214.16,40.35 214.18,40.35 214.9,39.64 216.11,39.64 216.27,39.47 216.27,35.69 216.13,35.55 216.13,34.59 215.96,34.43 213.93,34.43 213.71,34.64 213.71,35.7 213.71,37.79 213.62,37.88 213.62,37.91 213.52,38.23 213.2,38.32 213.17,38.32 213.06,38.42 213.06,40.55 213.14,40.63
+TPAN_VDD_F on BOTTOM (solid shape): 214.58,39.83 214.58,38.75 214.97,38.36 215.77,38.36 215.9,38.23 215.9,37.13 215.83,37.06 214.72,37.06 213.31,38.47 213.31,39.79 213.45,39.92 214.49,39.92
+V_DDR_REFA on TOP (solid shape): 71.99,67.75 71.99,67.19 72.03,67.15 72.86,67.15 72.99,67.02 72.99,66.77 72.86,66.64 72.29,66.64 72.1,66.45 72.1,64.4 71.97,64.26 71.48,64.26 71.4,64.35 71.4,67.76 71.44,67.8 71.94,67.8
+V_DDR_REFB on TOP (solid shape): 59.27,68.32 59.27,67.4 59.46,67.21 60.16,67.21 60.29,67.09 60.29,66.77 60.16,66.64 59.4,66.64 59.3,66.54 59.3,65.01 59.23,64.95 58.72,64.95 58.67,64.99 58.67,65.02 58.67,68.34 58.69,68.36 59.23,68.36
+VCHGR on TOP (solid shape): 178.75,46.01 178.75,43.52 178.62,43.39 177.22,43.39 177.02,43.58 177.02,45.98 177.2,46.16 178.6,46.16
+VCHGR on BOTTOM (solid shape): 178.86,45.8 178.86,43.99 179.08,43.77 179.65,43.77 179.8,43.62 179.8,43.22 179.74,43.16 179.1,43.16 178.85,42.9 178.85,42.59 179.1,42.33 179.74,42.33 179.8,42.27 179.8,41.89 179.81,41.88 179.81,41.7 179.77,41.65 178.28,41.65 178.2,41.74 178.2,41.94 178.2,41.95 178.2,42.38 178.18,42.4 178.19,42.43 178.05,42.84 177.62,42.82 177.56,42.8 177.49,42.82 177.43,42.86 177.35,42.89 177.29,42.93 177.27,43 177.21,43.23 177.02,43.36 176.99,43.38 176.99,45.84 177.12,45.98 178.68,45.98
+VCHGR on BOTTOM (solid shape): outline of 538 points within 148.45,28.89 172.09,38.67
+VCHGR on IN1 (solid shape): 179,45.75 179,43.72 178.64,43.37 177.23,43.37 177.06,43.53 177.06,45.13 177.12,45.2 177.12,45.73 177.39,46 178.75,46
+VCHGR on IN2 (solid shape): outline of 269 points within 169.85,37.36 178.95,46.38
+VGA_CORE on TOP (solid shape): 116.58,126.12 116.58,125.76 116.88,125.47 116.88,125.09 117.3,124.66 117.3,124.4 115.46,122.56 114.83,121.93 114.39,121.93 113.19,123.12 113.19,124.24 115.73,126.78 115.92,126.78
+VGA_CORE on TOP (solid shape): 122.4,124.71 122.4,122.35 122.2,122.15 122.2,121.29 122.11,121.2 122.11,120.32 122.05,120.26 116.9,120.26 116.71,120.46 116.71,120.96 116.86,121.11 118.19,121.11 118.57,121.49 118.57,121.66 119.25,122.35 119.25,122.68 119.61,123.04 119.96,123.04 120.94,124.02 120.94,124.62 121.23,124.91 122.2,124.91
+VGA_CORE on TOP (solid shape): 125.61,132.12 125.61,131.76 125.83,131.54 125.83,131.49 125.85,131.46 125.86,131.45 125.88,131.44 125.88,131.26 125.52,130.89 125.52,130.77 125.42,130.59 125.45,130.39 125.45,130.38 125.45,130.32 125.52,130.26 125.52,130.06 126,129.58 126,129.33 125.85,129.19 125.31,129.19 124.83,129.67 124.83,131.16 124.93,131.27 124.93,131.63 124.88,131.68 124.88,132.19 124.94,132.25 125.48,132.25
+VGA_CORE on TOP (solid shape): 119.41,132.27 119.41,131.26 119.98,130.69 121.07,130.69 121.23,130.53 121.23,130.24 121.42,130.04 121.97,130.04 122.77,130.84 123.07,130.84 123.2,130.71 123.2,130.02 123.04,129.86 122.74,129.86 122.61,129.72 122.5,129.62 122.46,129.48 122.41,129.43 122.41,128.06 122.37,128.02 121.78,128.02 121.74,128.07 121.74,128.79 121.06,129.47 120.16,129.47 120.16,129.46 119.97,129.27 119.65,129.27 119.51,129.42 119.05,129.42 118.04,130.43 118.04,131.22 118.33,131.51 118.33,132.32 118.52,132.51 119.17,132.51
+VGA_CORE on BOTTOM (solid shape): 126.58,130.15 126.58,129.85 126.08,129.35 126.06,129.35 125.97,129.31 125.89,129.25 125.39,129.25 125.32,129.3 125.24,129.34 125.17,129.41 125.2,129.51 125.43,129.74 125.43,129.79 125.47,129.86 125.49,129.94 125.76,130.2 125.77,130.2 125.89,130.24 125.99,130.31 126.41,130.31
+VGA_CORE on BOTTOM (solid shape): outline of 86 points within 120.56,134.49 122.68,137.18
+VGA_CORE on BOTTOM (solid shape): outline of 194 points within 94.78,120.33 107.43,141.85
+VGA_CORE on BOTTOM (solid shape): outline of 328 points within 117.77,126.6 127.87,137.12
+VGA_CORE on IN1 (solid shape): outline of 2144 points within 115.5,120.45 127.93,137.68
+VGA_CORE on IN2 (solid shape): outline of 6541 points within 102.08,120.29 128.25,147.92
+VGA_CORE on IN3 (solid shape): outline of 1841 points within 115.22,123.17 127.94,136.61
+VGA_CORE on VCC: 99.67,119.55 96.65,122.58 96.65,144.59 97.13,145.08 105.46,145.08 105.59,145.21 105.59,145.09 122.13,145.09 122.15,145.08 125.99,145.08 125.99,136.33 127.89,134.43 127.89,132.74 126.62,131.47 126.62,129.98 127.89,128.71 127.89,127.02 125.99,125.12 125.99,119.55
ACIN_CHG on BOTTOM (solid shape): 201.41,52.07 201.41,49.86 201.37,49.82 200.39,49.82 200.29,49.92 200.29,52.08 200.46,52.26 201.23,52.26
AUD_AGND on BOTTOM (solid shape): 17.48,13.11 17.48,12.48 17.13,12.12 15.24,12.12 15.21,12.15 15.21,13.48 15.25,13.52 17.08,13.52
AUD_AGND on GND1: 10.14,5.29 10.07,5.3 10,5.3 2.85,5.3 2.64,5.39 2.55,5.6 2.55,8.25 2.64,8.46 2.85,8.55 13.55,8.55 14.25,9.15 13.75,9.92 13.75,15.38 14.25,16.15 13.55,16.75 2.85,16.75 2.64,16.84 2.55,17.05 2.55,18.45 2.64,18.66 2.85,18.75 4,18.75 4.5,18.95 4.7,19.45 4.7,19.79 15,19.79 16.21,21.01 16.21,21.77 16.5,22.06 18.58,22.06 19.64,23.12 19.64,23.88 19.87,24.11 28.38,24.11 29.42,23.07 29.42,20.38 30.15,19.64 30.54,19.64 30.77,19.41 30.77,18.62 31.2,18.19 31.2,17.74 31.07,17.61 30.64,17.61 28.96,15.93 24.39,15.93 24.04,15.58 24.04,12.36 23.99,12.31 21.2,12.31 20.63,11.74 19.37,11.74 18.96,11.34 18.96,9.98 19.35,9.59 21.33,9.59 21.5,9.42 21.5,9.22 22.87,7.86 24.19,7.86 24.93,8.59 24.93,10.62 24.98,10.68 25.74,10.68 25.82,10.6 25.82,8.55 24.69,7.42 19.37,7.42 18.94,7.86 17.1,7.86 16.5,7.25 14.39,7.25 13.05,5.91 10.75,5.91
AUD_AGND on VCC: 10.14,5.29 10.07,5.3 10,5.3 2.85,5.3 2.64,5.39 2.55,5.6 2.55,8.25 2.64,8.46 2.85,8.55 13.55,8.55 14.25,9.15 13.75,9.92 13.75,15.38 14.25,16.15 13.55,16.75 2.85,16.75 2.64,16.84 2.55,17.05 2.55,18.45 2.64,18.66 2.85,18.75 4,18.75 4.5,18.95 4.7,19.45 4.7,19.82 15.02,19.82 16.24,21.04 16.24,21.8 16.5,22.06 18.58,22.06 19.64,23.12 19.64,23.88 19.87,24.11 28.38,24.11 29.42,23.07 29.42,20.38 30.15,19.64 30.54,19.64 30.77,19.41 30.77,18.62 31.2,18.19 31.2,17.74 31.07,17.61 30.64,17.61 28.96,15.93 24.39,15.93 24.04,15.58 24.04,12.37 23.99,12.32 21.2,12.32 20.63,11.76 19.36,11.76 18.94,11.34 18.94,9.99 19.36,9.58 21.33,9.58 21.33,9.58 21.5,9.41 21.5,9.22 22.87,7.86 24.19,7.86 24.93,8.59 24.93,10.62 24.98,10.68 25.74,10.68 25.82,10.6 25.82,8.55 24.69,7.42 19.39,7.42 18.96,7.86 17.05,7.86 16.44,7.25 14.41,7.25 13.06,5.9 10.75,5.9
AUD_AGND on GND2: 10.17,5.28 10.09,5.3 10,5.3 2.85,5.3 2.64,5.39 2.55,5.6 2.55,8.25 2.64,8.46 2.85,8.55 13.55,8.55 14.25,9.15 13.75,9.92 13.75,15.38 14.25,16.15 13.55,16.75 2.85,16.75 2.64,16.84 2.55,17.05 2.55,18.45 2.64,18.66 2.85,18.75 4,18.75 4.5,18.95 4.7,19.45 4.7,19.81 15,19.81 16.23,21.04 16.23,21.8 16.46,22.03 18.55,22.03 19.66,23.13 19.66,23.89 19.89,24.13 28.38,24.13 29.43,23.07 29.43,20.4 30.22,19.62 30.54,19.62 30.77,19.38 30.77,18.62 31.21,18.18 31.21,17.75 31.04,17.58 30.6,17.58 28.95,15.93 24.44,15.93 24.04,15.53 24.04,12.36 24,12.31 21.2,12.31 20.63,11.74 19.36,11.74 18.96,11.34 18.96,9.99 19.36,9.58 21.33,9.58 21.5,9.42 21.5,9.22 22.85,7.87 24.21,7.87 24.93,8.59 24.93,10.62 24.97,10.66 25.77,10.66 25.82,10.62 25.82,8.55 24.69,7.42 19.38,7.42 18.94,7.87 17.07,7.87 16.44,7.23 14.39,7.23 13.06,5.91 10.79,5.91
AUD_SPK_L+ on TOP (solid shape): 26.67,10.57 26.67,8.43 26.67,7.47 26.54,7.34 25.85,7.34 25.78,7.41 25.78,7.85 26.08,8.15 26.16,8.15 26.37,8.36 26.37,9.33 26.42,9.38 26.42,10.56 26.53,10.66 26.58,10.66
AUD_SPK_L+_C on TOP (solid shape): 14.71,4.85 16.9,4.85 17.24,4.5 17.24,3.97 16.93,3.65 15.32,3.65 15.28,3.69 14.5,3.69 14.19,4 14.19,4.88 14.32,5.01 14.54,5.01
AUD_SPK_L+_C on TOP (solid shape): 26.61,7.09 26.61,6.44 26.61,6.44 26.61,5.76 26.29,5.44 26.29,4.61 26.1,4.42 25.78,4.42 25.66,4.55 25.66,7.03 25.78,7.15 26.54,7.15
AUD_SPK_L+_C on BOTTOM (solid shape): 14.8,6.43 14.8,3.98 14.67,3.85 14.16,3.85 14.04,3.98 14.04,6.41 14.26,6.64 14.59,6.64
AUD_SPK_L+_C on IN2 (solid shape): 26.23,5.38 26.23,4.59 25.14,3.5 22.23,3.5 21.97,3.61 21.71,3.5 21.71,3.5 21.22,3.01 16.14,3.01 15.49,3.65 14.35,3.65 14.07,3.93 14.07,4.69 14.37,5 14.56,5 14.64,5.08 17.56,5.08 18.61,4.02 20.15,4.02 21.2,5.08 23.95,5.08 24.14,4.88 24.72,4.88 25.38,5.55 26.07,5.55
AUD_SPK_L- on TOP (solid shape): 27.05,10.65 27.05,8.93 27.14,8.85 27.14,8.84 27.2,8.76 27.28,8.7 27.28,8.7 27.58,8.4 27.59,8.39 27.64,8.32 27.72,8.26 27.73,8.26 27.81,8.17 27.81,7.47 27.69,7.34 27.05,7.34 26.93,7.47 26.93,8.36 26.8,8.49 26.8,8.63 26.81,8.69 26.8,8.76 26.8,9.01 26.81,9.08 26.8,9.14 26.8,10.65 26.86,10.71 26.99,10.71
AUD_SPK_L-_C on TOP (solid shape): 13.94,4.8 13.94,3.68 14.77,2.85 17.01,2.85 17.22,2.65 17.22,2.03 16.99,1.8 16.29,1.8 16.06,1.56 13.74,1.56 13.12,2.19 13.12,4.76 13.35,4.99 13.75,4.99
AUD_SPK_L-_C on TOP (solid shape): 27.7,7.22 27.74,7.17 27.74,6.51 27.6,6.37 27.57,6.37 27.57,6.34 27.56,6.33 27.56,4.78 27.42,4.63 26.97,4.63 26.83,4.49 26.56,4.49 26.55,4.48 26.42,4.61 26.42,5.31 26.74,5.63 26.74,6.39 26.86,6.52 26.86,7.22
AUD_SPK_L-_C on BOTTOM (solid shape): 13.72,6.46 13.72,3.92 13.65,3.85 13.08,3.85 13.02,3.92 13.02,6.47 13.17,6.61 13.57,6.61
AUD_SPK_L-_C on IN2 (solid shape): outline of 237 points within 14.16,1.17 28.07,5.49
AUD_SPK_R+ on TOP (solid shape): 27.88,10.46 27.88,9.69 28.64,8.93 28.64,8.87 28.45,8.68 28.26,8.68 27.62,9.31 27.62,10.52 27.69,10.58 27.75,10.58
AUD_SPK_R+ on TOP (solid shape): 27.64,4.31 27.64,3.47 27.49,3.32 27.16,3.32 26.96,3.52 26.55,3.52 26.53,3.54 26.53,4.28 26.56,4.32 26.67,4.31 26.74,4.32 26.91,4.32 27.05,4.45 27.49,4.45
AUD_SPK_R+ on IN3 (solid shape): 28.2,6.1 28.2,5.46 28.04,5.16 28.2,4.87 28.2,3.71 27.82,3.33 27.04,3.33 26.96,3.41 26.96,4.45 27.03,4.66 26.96,4.88 26.96,5.04 27.03,5.25 26.96,5.46 26.96,6.05 27.26,6.36 27.95,6.36
AUD_SPK_R+ on IN3 (solid shape): 28.86,9.38 28.86,8.95 28.53,8.62 28.33,8.62 27.54,9.41 27.14,9.41 27.03,9.3 27.03,8.16 27.16,8.03 27.16,7.55 27.11,7.5 26.27,7.5 26.18,7.59 26.18,7.87 26.2,7.88 26.2,8.26 26.37,8.5 26.29,8.8 26.27,8.86 26.29,8.92 26.37,9.22 26.2,9.46 26.2,9.84 26.6,10.24 28,10.24
AUD_SPK_R+_C on TOP (solid shape): 20.49,4.85 20.55,4.85 22.49,4.85 22.59,4.85 22.61,4.87 23.43,4.87 23.63,4.67 23.63,4.66 23.85,4.27 24.26,4.12 25.02,4.12 25.14,4.13 25.26,4.17 25.27,4.17 25.34,4.17 25.47,4.3 26.23,4.3 26.29,4.23 26.29,3.6 26.23,3.53 23.94,3.53 23.71,3.8 23.37,3.89 21.97,3.89 21.71,3.84 21.5,3.68 20.11,3.68 19.39,4.4 19.39,4.93 19.52,5.06 19.81,5.06 19.87,5.12 20.22,5.12
AUD_SPK_R+_C on BOTTOM (solid shape): 17.02,6.2 19.12,6.2 19.12,6.19 19.68,6.19 20.42,5.46 20.42,4.63 19.91,4.12 19.59,4.12 19.47,4.25 19.47,4.38 18.72,5.12 16.19,5.12 16,5.31 16,6.04 16.02,6.06 16.02,6.41 16.32,6.71 16.51,6.71
AUD_SPK_R- on TOP (solid shape): 27.43,10.65 27.43,9.31 28.13,8.61 28.13,8.42 28.01,8.3 27.87,8.3 27.18,8.98 27.18,10.65 27.24,10.71 27.37,10.71
AUD_SPK_R- on TOP (solid shape): 27.22,3.13 27.3,3.13 27.64,2.78 27.64,1.57 27.49,1.42 26.66,1.42 26.66,1.42 26.52,1.42 26.49,1.45 26.49,2.36 26.53,2.41 26.53,3.16 26.56,3.18 27.17,3.18
AUD_SPK_R- on IN3 (solid shape): 29.47,2.5 29.47,1.74 29.25,1.51 26.62,1.51 26.44,1.69 26.44,2.29 26.84,2.7 29.27,2.7
AUD_SPK_R- on IN3 (solid shape): 28.07,8.68 28.11,8.63 28.16,8.59 29.52,7.22 29.52,6.51 29.32,6.31 28.74,6.31 27.61,7.44 27.61,8.23 27.19,8.64 27.19,9.1 27.31,9.23 27.52,9.23
AUD_SPK_R-_C on TOP (solid shape): 26.29,3.22 26.29,2.39 26.23,2.33 25.66,2.33 25.34,2.65 25.27,2.65 25.26,2.65 25.02,2.7 24.78,2.65 24.77,2.65 24.51,2.65 23.62,1.76 19.23,1.76 18.99,2 18.99,2.56 19.2,2.77 21.56,2.77 21.75,2.66 21.97,2.62 23.37,2.62 23.81,2.8 24,3.23 24.01,3.28 26.23,3.28
AUD_SPK_R-_C on BOTTOM (solid shape): 15.75,6.46 15.75,5.12 16.07,4.8 18.05,4.8 18.12,4.77 18.15,4.7 18.33,4.38 18.7,4.39 18.73,4.41 19.12,4.02 19.12,3.78 20.23,2.68 20.23,2.22 20.04,2.03 19.51,2.03 19.5,2.01 18.67,2.01 18.48,2.2 18.48,2.96 18.45,3 18.45,3.04 17.96,3.04 17.5,3.5 15.9,3.5 15.56,3.84 15.5,3.84 15.11,4.23 15.11,6.46 15.31,6.65 15.56,6.65
BGATE_CHG on BOTTOM (solid shape): 207.11,44.5 207.11,43.93 207.08,43.8 207.11,43.66 207.11,43.51 207.02,43.42 206.52,43.42 206.23,43.71 206.23,44.56 206.28,44.61 206.99,44.61
BOOT1_CHG on BOTTOM (solid shape): 201.17,46.61 201.21,46.47 201.32,46.36 201.51,46.16 201.69,46.16 202.06,45.79 202.81,45.79 202.86,45.74 202.86,45.65 202.8,45.58 201.95,45.58 201.9,45.63 201.16,45.63 201.07,45.65 200.99,45.63 200.57,45.63 200.5,45.7 200.5,46.59 200.54,46.63 201.15,46.63
BST1_VGA on TOP (solid shape): 77.17,127.94 77.17,127.45 77.38,127.25 77.89,127.25 78.06,127.42 78.06,127.67 78.08,127.69 78.71,127.69 78.77,127.63 78.77,126.87 78.58,126.68 76.97,126.68 76.41,127.24 76.41,127.66 76.27,127.8 76.27,127.96 76.32,128.01 77.1,128.01
BST2_VGA on TOP (solid shape): 77.5,134.17 77.5,133.33 77.35,133.13 77.37,132.89 77.37,132.62 77.18,132.43 77.18,131.46 77.11,131.39 76.34,131.39 76.26,131.47 76.26,132.71 76.54,132.99 76.54,133.61 76.74,133.81 76.74,134.17 76.81,134.23 77.44,134.23
BST_1.2V on TOP (solid shape): 40.3,30.68 40.3,29.64 40.21,29.55 40.18,29.55 39.59,29.34 39.33,28.78 39.25,28.7 37.98,28.7 37.94,28.75 37.94,28.87 37.99,28.92 38.79,28.92 39.13,29.27 39.26,29.27 39.44,29.45 39.44,30.7 39.53,30.79 40.19,30.79
BST_3V on BOTTOM (solid shape): 21.47,41.26 21.47,40.58 21.36,40.47 21.36,39.54 21.32,39.51 20.66,39.51 20.61,39.56 20.61,40.39 20.68,40.47 20.68,41.03 20.66,41.05 20.66,41.79 20.74,41.87 20.86,41.87
BST_5V on BOTTOM (solid shape): 24.23,100.45 24.23,99.77 24.79,99.21 24.79,98.37 24.75,98.32 24.56,98.32 24.28,98.6 24.18,98.85 23.93,98.95 23.91,98.98 23.81,99.15 23.64,99.24 23.28,99.61 23.28,100.45 23.34,100.52 24.16,100.52
BST_+1.35VGPU_R on TOP (solid shape): 147.42,108.56 147.42,107.91 147.35,107.83 146.82,107.83 146.64,107.65 145.92,107.65 145.83,107.74 145.83,108.57 145.91,108.64 147.33,108.64
BST_+1VALW_R on TOP (solid shape): 162.42,50.84 162.42,49.98 162.39,49.95 161.75,49.95 161.54,50.16 160.88,50.16 160.82,50.22 160.82,50.8 160.9,50.88 162.38,50.88
BST_VCCSA on TOP (solid shape): 165.58,61.22 165.58,60.94 166.09,60.44 166.09,60.13 165.96,60 165.11,60 164.81,60.31 164.81,61.29 164.86,61.35 165.45,61.35
BST_VCCSA_R on TOP (solid shape): 164.2,61.25 164.2,60.32 164.35,60.17 164.35,59.42 164.27,59.34 163.48,59.34 163.42,59.39 163.42,60.19 163.36,60.25 163.36,61.29 163.45,61.38 164.08,61.38
BST_VGT1 on BOTTOM (solid shape): 160.53,96.75 160.53,96.18 160.47,96.12 160.34,96.12 160.02,95.8 160.02,94.97 159.96,94.91 159.7,94.91 159.64,94.97 159.64,95.54 159.64,95.54 159.64,96.75 159.7,96.82 160.47,96.82
BST_VGT1_R on BOTTOM (solid shape): 161.8,98.15 161.8,97.64 161.67,97.51 159.77,97.51 159.64,97.64 159.64,98.15 159.77,98.28 161.67,98.28
DCIN_CHG on TOP (solid shape): 203.81,51.14 203.81,49.17 202.03,49.17 201.67,49.53 201.67,51.19 201.79,51.3 203.65,51.3
DCIN_CHG on BOTTOM (solid shape): 203.06,51.07 203.06,49.48 203.27,49.26 203.27,47.64 203.22,47.58 202.87,47.58 202.78,47.68 202.78,48.29 201.59,49.49 201.59,51.01 201.73,51.15 202.97,51.15
DP_VSSR on BOTTOM (solid shape): outline of 329 points within 111.82,130.69 115.88,133.15
DP_VSSR on BOTTOM (solid shape): outline of 810 points within 111.29,134.93 116.37,139.71
DP_VSSR on IN1 (solid shape): outline of 167 points within 111.25,132.18 114.31,139.23
DP_VSSR on IN3 (solid shape): outline of 122 points within 114.29,130.61 117.28,139.23
FP_VCC on TOP (solid shape): 218.61,28.14 218.61,27.08 218.82,26.88 219.34,26.88 219.43,26.79 219.43,26.17 219.39,26.13 218.35,26.13 218.29,26.19 215.44,26.19 215.18,26.46 215.18,28.28 215.35,28.46 218.3,28.46
FP_VCC on BOTTOM (solid shape): 222.39,32.95 222.39,30.49 222.21,30.31 221.67,30.31 221.64,30.34 221.64,32.83 221.92,33.1 222.23,33.1
