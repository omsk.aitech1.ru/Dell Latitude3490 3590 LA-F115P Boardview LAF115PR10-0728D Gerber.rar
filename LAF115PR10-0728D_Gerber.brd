# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EMMC_DATA7: length 61.1
  TOP w0.112: RM23.1 98.97,31.22 99.09,31.11 99.09,29.09 98.97,28.98 v2(96.91,28.98) 96.6,28.98 96.45,28.83 96.45,28.49 96.56,28.38 102.11,28.38 103.87,30.14 105.98,30.14 106.37,30.53 106.37,32.72 106.5,32.86 107.45,32.86 107.56,32.74 107.56,30.41 107.71,30.26 110.42,30.26 111.06,30.9 111.06,31.27 111.51,31.72 112.15,31.72 112.58,32.15 112.58,32.41 111.69,33.31 111.69,33.48 111.88,33.67 112,33.67 112.66,33.01 112.9,33.01 113.02,33.14 113.02,33.36 112.4,33.98 112.4,34.28 112.82,34.7 114.16,34.7 114.42,34.44 114.42,33.37 114.67,33.11 115.27,33.11 118.04,35.88 118.04,37.52 118.74,38.22 118.74,38.85 118.94,39.05 119.36,39.05 119.93,39.62 119.93,41.42 119.95,41.44 v1(119.94,41.44)
  BOTTOM w0.076: 119.11,48.68 119.11,49.04 119.67,49.61 119.78,49.71 UC1.AM1
  BOTTOM w0.112: v1(119.94,41.44) 120.02,41.44 120.51,41.92 120.51,42.71 120.35,42.87 120.2,42.87 119.86,42.53 119.7,42.53 119.54,42.69 119.54,42.84 119.88,43.18 119.88,43.34 119.31,43.91 119.31,46.29 118.96,46.63 118.96,47.59 119.11,47.73 119.11,48.68
EMMC_RCLK: length 60.8
  TOP w0.089: v2(83.42,41.79) 83.03,41.4 v1(83.03,40.57)
  TOP w0.102: v1(83.03,40.57) 83.43,40.17 84.31,40.17 RM24.1
  IN1 w0.102: v1(83.03,40.57) 83.3,40.3 85.11,40.3 85.73,40.91 85.73,41.92 85.83,42.02 86.03,42.02 86.13,41.92 86.13,40.91 86.24,40.81 86.44,40.81 86.54,40.91 86.54,41.92 86.64,42.02 86.84,42.02 86.95,41.92 86.95,40.91 87.05,40.81 87.25,40.81 87.35,40.91 87.35,41.92 87.45,42.02 87.66,42.02 87.76,41.92 87.76,40.91 87.86,40.81 88.06,40.81 88.17,40.91 88.17,41.92 88.27,42.02 88.47,42.02 88.57,41.92 88.57,41.02 88.78,40.81 92.04,40.81 92.56,40.29 92.92,40.29 93.02,40.39 93.02,40.57 93.12,40.67 93.32,40.67 93.43,40.57 93.43,40.39 93.53,40.29 96.28,40.29 96.8,40.81 97.46,40.81 97.51,40.76 100.01,40.76 100.45,41.2 100.45,41.5 102.09,43.14 106.52,43.14 107.5,44.13 108.97,44.13 110.49,45.65 116.24,45.65 117.53,44.37 117.53,43.67 117.96,43.24 v1(118.78,43.24)
  BOTTOM w0.076: 118.8,48.68 118.8,48.96 119.51,49.67 119.51,50.08 119.53,50.1 119.53,50.4 UC1.AM2
  BOTTOM w0.102: v1(118.78,43.24) 119,43.46 119,46.16 118.65,46.5 118.65,47.72 118.8,47.86 118.8,48.68
EMMC_RCLK_R: length 9.6
  TOP w0.089: 84.36,34.97 84.36,33.04 UM1.H5
  TOP w0.112: RM12.2 RM24.2 84.74,38.19 84.85,38.08 85.99,38.08 86.1,37.97 86.1,37.67 85.99,37.56 84.85,37.56 84.74,37.45 84.74,36.92 84.36,36.54 84.36,34.97
EMMC_RCOMP: length 5.1
  BOTTOM w0.076: UC1.AT1 117.79,49.96 117.54,49.71
  BOTTOM w0.112: 117.54,49.71 117.31,49.49 117.07,49.49 116.44,48.86 116.33,48.86 115.95,48.48 115.95,46.92 115.72,46.69 RC8.1
EMMC_RST#: length 5.6
  TOP w0.112: UM2.4 83.17,42.49 v2(82.14,41.46) RM27.2 RM25.1 CM6.1
EMMC_RST#_R: length 6.3
  TOP w0.089: 83.36,35 83.36,33.04 UM1.K5
  TOP w0.112: RM25.2 82.96,38.06 83.36,37.66 83.36,35
EN_0.6VSP: length 2.9
  TOP w0.203: PUM01.7 34.49,29.21 PCM16.1 33.64,30.92 PRM09.2
EN_1.2V: length 2.7
  TOP w0.203: PUM01.8 34.4,28.81 34.08,29.13 PCM15.1 33.63,28.37 PRM08.2
EN_1.8VALW: length 7
  BOTTOM w0.089: v2(168.04,48.48) 168.04,47.82 PR1802.1
  BOTTOM w0.254: PU1801.5 167.36,45.42 167.47,45.53 167.47,46.38 PC1805.1 167.66,47.39 PR1802.1 166.87,47.42 PR1806.2 166.79,47.38 166.29,46.88 PR1801.2 165.68,46.88 165.03,47.53 PR1890.2
EN_2.5V: length 3.7
  TOP w0.254: PU2501.2 72.34,111.69 73.02,111.01 PC2503.1 73.35,111.01 73.83,111.49 73.83,112.09 PR2501.2
EN_3V: length 51.3
  TOP w0.089: v1(19.44,45.45) 19.44,45.84 v2(19.81,46.21)
  IN1 w0.254: v1(19.74,85.39) 19.64,85.29 19.64,78.73 21.14,77.23 21.14,75.79 23.8,73.13 23.8,64.58 21.66,62.44 21.66,57.46 19.26,55.06 19.26,53.98 17.4,52.12 17.4,51.08 17.85,50.64 17.85,46.37 17.32,45.84 17.32,45.17 17.73,44.76 18.75,44.76 v1(19.44,45.45)
  BOTTOM w0.254: v1(19.74,85.39) 19.74,85.43 20.32,86 PR502.1 ; PU301.12 v1(19.44,45.45)
EN_5V: length 2.9
  BOTTOM w0.089: v2(27.62,94.57) 27.12,94.08 PR503.1
  BOTTOM w0.203: PU501.12 26.01,95.03 26.74,94.29 PR503.1
EN_+1.35VGPU: length 5.5
  BOTTOM w0.089: PCW09.1 137.56,111.34 v2(137.45,111.45)
  BOTTOM w0.254: PCW09.1 PRW02.1 PRW01.2 140.06,111.04 141.55,109.56 PUW01.6
EN_+1VALW: length 7
  TOP w0.089: v1(164.04,53.32) v2(163.35,53.32)
  TOP w0.254: PRH02.1 164.93,53.62 PCH09.1 164.4,53.67 v1(164.04,53.32)
  BOTTOM w0.254: 164.04,53.32 163.95,53.41 162.76,53.41 162.56,53.21 PUH01.6 ; 164.04,53.32 v1(164.04,53.32) ; 164.04,53.32 164.79,53.32 PRH01.2 164.91,54.2 PRH13.2 PRH90.2
EN_CPU: length 2
  BOTTOM w0.203: PRZ22.1 179.76,59.3 179.05,58.59 179.05,58.33 178.82,58.1 PUZ01.37
ENABLE_VGA: length 2.3
  TOP w0.203: PUV01.8 v2(70.52,128.7) 70.29,128.7 PRV15.2
ENLDO_3V5V: length 63.5
  TOP w0.089: v2(18.46,45.77) 18.2,45.77 17.79,45.36 v1(17.78,45.36)
  IN1 w0.254: v1(17.78,45.36) 17.78,45.81 18.19,46.23 18.19,46.29 18.2,46.29 18.2,50.77 17.75,51.22 17.75,51.98 19.61,53.83 19.61,54.91 22,57.3 22,62.3 24.15,64.44 24.15,73.28 21.49,75.93 21.49,77.37 20,78.87 20,81.85 20.49,82.34 21.24,82.34 21.66,82.76 21.66,85.92 23.61,87.87 23.61,88.79 24.35,89.54 25.01,89.54 25.38,89.91 25.38,90.53 26.66,91.82 26.66,93.37 27.1,93.81 v1(27.1,94.97)
  BOTTOM w0.203: v1(27.1,94.97) 26.66,94.97 26.46,95.17 PU501.11
  BOTTOM w0.254: PU301.11 18.99,45.04 18.87,45.16 18.87,45.64 19.01,45.78 PR303.1 18.99,46.09 PR302.1 17.78,45.71 v1(17.78,45.36)
EOPIO_RCOMP: length 2
  TOP w0.089: RC122.1 132.31,86.22 v1(132.39,86.14) v2(132.79,85.74)
  BOTTOM w0.076: UC1.H65 131.94,86.53 132.32,86.14 v1(132.39,86.14)
ESPI_ALERT#: length 42.5
  TOP w0.102: 106.22,52.12 v2(106.95,52.85) 107.35,53.25 v1(109.92,53.25)
  TOP w0.112: 106.22,52.12 106.04,51.94 RC14.2
  IN1 w0.114: v1(109.92,53.25) 109.17,54.01 102.93,54.01 99.99,51.08 99.99,49.46
  IN1 w0.119: 99.99,49.46 98.93,48.4 v1(98.93,47.96)
  BOTTOM w0.076: UC1.AY11 115.12,56.18 114.61,55.66 114.61,55.35 114.48,55.22 113.17,55.22 112.24,54.29 111.66,54.29 110.63,53.25 v1(109.92,53.25)
  BOTTOM w0.089: RE84.1 91.8,36.98 90.97,37.82 90.97,39.16 91.27,39.47 92.27,39.47 93.61,40.81 93.61,42.64 v1(98.93,47.96)
ESPI_CLK: length 169.3
  TOP w0.089: 104.64,54.91 105.21,54.91 RC15.2
  TOP w0.112: UE1.57 52.2,79.01 52.39,78.81 53.07,78.81 v1(53.09,78.84) 53.4,78.84 53.96,79.4 RE67.2 ; 104.64,54.91 CC88.1 104.41,55.11 v1(104,55.52)
  IN3 w0.135: v1(53.09,78.84) 53.09,78.3 52.94,78.15 52.17,78.15 52.03,78.01 52.03,77.79 51.57,77.32 51.49,77.14 51.49,76.59 51.36,76.46 50.76,76.46 50.63,76.32 50.63,76.05 50.76,75.92 51.36,75.92 51.49,75.78 51.49,75.52 51.36,75.39 50.33,75.39 50.19,75.25 50.19,74.98 50.33,74.85 51.56,74.85 51.66,74.75 51.66,74.4 51.56,74.31 50.49,74.31 50.35,74.17 50.35,73.9 50.49,73.77 51.56,73.77 51.66,73.68 51.66,73.32 51.56,73.23 50.21,73.23 50.05,73.07 50.05,72.83 50.18,72.69 51.56,72.69 51.66,72.6 51.66,72.25 51.56,72.15 50.16,72.15 50,71.99 50,71.82 50.2,71.62 51.33,71.62 51.47,71.48 51.47,71.21 51.33,71.08 50.74,71.08 50.61,70.94 50.61,70.67 50.74,70.54 51.33,70.54 51.47,70.4 51.47,69.39 51.66,69.2 51.66,69.2 51.95,68.91 51.95,68.01 54.31,65.64 54.31,64.92 54.14,64.74 53.22,64.74 53.07,64.59 53.07,64.27 53.24,64.09 54.18,64.09 54.32,63.96 54.32,63.69 54.18,63.56 53.23,63.56 53.09,63.42 53.09,63.15 53.23,63.02 54.24,63.02 54.38,62.88 54.38,62.61 54.24,62.48 53.31,62.48 53.17,62.34 53.17,61.36 53.01,61.2 52.24,61.2 52.1,61.06 52.1,60.64 52.24,60.51 54.18,60.51 54.32,60.37 54.32,60.1 54.18,59.97 52.24,59.97 52.1,59.83 52.1,59.56 52.24,59.43 52.71,59.43 52.84,59.3 52.84,58.62 53.11,58.35 54.18,58.35 54.32,58.22 54.32,57.95 54.18,57.81 53.43,57.81 53.3,57.68 53.3,57.41 53.43,57.28 54.18,57.28 54.32,57.14 54.32,56.87 54.18,56.74 53.91,56.74 53.78,56.61 53.78,52.66 54.68,51.76 54.68,51.33 55.88,50.14 55.88,49.55 56.37,49.06 56.37,48.75 57.42,47.7 57.42,44.78 57.43,44.78 57.43,44.64 57.88,44.19 57.88,44.02 60.26,41.65 60.68,41.65 61.7,40.63 68.45,40.63 69.16,39.92 72.02,39.92 72.79,39.15 75.85,39.15 76.05,38.95 80.12,38.95 81.47,40.29 81.9,40.29 83.22,41.61 85.12,41.61 85.24,41.73 85.24,42.06 85.4,42.22 85.7,42.22 85.84,42.09 85.84,40.85 85.97,40.71 86.3,40.71 86.43,40.85 86.43,42.08 86.59,42.24 86.92,42.24 87.05,42.1 87.05,41.35 87.19,41.22 87.61,41.22 87.79,41.4 87.79,42.22 88.61,43.04 95.9,43.04 v1(96.93,42.01)
  BOTTOM w0.112: v1(104,55.52) 103.79,55.72 103.79,55.72 103.55,55.97 102.98,55.97 100.58,53.56 100.58,46.94 99.37,45.73 98.73,45.73 97.86,44.87 97.86,44.16 97.75,44.05 97.05,44.05 96.94,43.94 96.94,43.64 97.05,43.53 97.97,43.53 98.08,43.42 98.08,43.15 97.96,43.04 96.55,43.04 96.44,42.92 96.44,42.59 96.51,42.52 98.41,42.52 98.5,42.43 98.5,42.16 98.35,42.01 v1(96.93,42.01) ; v1(53.09,78.84) 53.09,79.51 52.85,79.75 51.76,79.75 50.69,80.82 50.69,81.58 49.32,82.96 49.32,96.75 47.14,98.93 45.32,98.93 45.27,98.87 JESPI1.10
ESPI_CS#: length 174.8
  TOP w0.089: v3(110.28,51.65) 109.05,51.65 v1(107.89,52.81)
  TOP w0.102: 52.61,79.34 v1(52.68,79.27)
  TOP w0.112: 52.61,79.34 52.54,79.41 UE1.58
  IN1 w0.076: v1(107.89,52.81) 106.91,53.79 104.99,53.79
  IN1 w0.119: 104.99,53.79 103.02,53.79 100.92,51.7 100.92,51.69 100.22,50.98 100.22,48.08 98.77,46.63 95.71,46.63 94.7,45.62 83.35,45.62 82.03,44.3 72.5,44.3 69.2,47.6 67.08,47.6 65.85,48.82 59.82,48.82 59.13,49.51 59.13,57.34 58.91,57.56 58.91,58.09 57.25,59.75 56.18,59.75 55.2,60.73 55.2,61.25 56.09,62.15 56.09,62.16 56.51,62.58 56.51,66.27 54.36,68.42 54.36,69.56 55.51,70.71 55.51,70.96 55.63,71.08 56.37,71.08 56.49,71.2 56.49,71.44 56.37,71.55 55.63,71.55 55.51,71.67 55.51,71.91 55.63,72.03 56.37,72.03 56.49,72.15 56.49,72.39 56.37,72.51 55.63,72.51 55.51,72.63 55.51,72.87 55.63,72.99 56.37,72.99 56.49,73.11 56.49,73.35 56.37,73.46 55.63,73.46 55.51,73.58 55.51,73.82 55.63,73.94 56.37,73.94 56.49,74.06 56.49,74.3 56.37,74.42 55.73,74.42 55.61,74.54 55.61,74.78 55.73,74.9 56.46,74.9 56.57,75.02 56.57,75.26 56.46,75.37 55.63,75.37 55.51,75.49 55.51,75.69 55.46,75.74 55.46,75.9 56.26,76.7 56.26,76.87 56.09,77.04 55.92,77.04 55.12,76.24 54.95,76.24 54.78,76.41 54.78,76.58 56.17,77.97 56.17,84.88 56.05,85 55.72,85 55.63,84.91 55.63,84.25 55.51,84.13 54.28,84.13 54.16,84.01 54.16,83.77 54.28,83.65 55.51,83.65 55.63,83.53 55.63,83.28 55.51,83.16 53.32,83.16 53.2,83.04 53.2,82.81 53.32,82.69 55.51,82.69 55.63,82.57 55.63,82.33 55.51,82.21 54.36,82.21 54.24,82.09 54.24,81.85 54.36,81.73 55.51,81.73 55.63,81.61 55.63,81.37 55.51,81.25 54.36,81.25 54.24,81.13 54.24,80.9 54.36,80.78 55.51,80.78 55.63,80.66 55.63,80.41 55.51,80.29 53.56,80.29 53.44,80.17 53.44,79.93 53.56,79.81 55.51,79.81 55.63,79.69 55.63,79.46 55.51,79.34 54.83,79.34 54.71,79.22 54.71,78.98 54.83,78.86 55.51,78.86 55.63,78.74 55.63,78.11 54.45,76.92 54.28,76.92 52.68,78.52 v1(52.68,79.27)
  BOTTOM w0.089: 114.05,56.67 114.82,56.67 UC1.BA12
  BOTTOM w0.102: 114.05,56.67 113.92,56.67 112.36,55.11 111.35,55.11 110.31,54.07 108.8,54.07 107.89,53.16 v1(107.89,52.81)
  BOTTOM w0.112: JESPI1.7 45.22,97.37 45.49,97.65 46.4,97.65 49.11,94.94 49.11,81.98 51.82,79.27 v1(52.68,79.27)
ESPI_IO0: length 140.6
  TOP w0.112: UE1.59 50.39,79.81 v1(49.54,78.96) ; v3(102.4,37.68) 102.24,37.83 101.76,37.83 101.38,38.21 v1(101.38,38.32)
  IN3 w0.135: v1(49.54,78.96) 49.08,79.41 49.08,81.61 49.22,81.75 49.73,81.75 49.86,81.88 49.86,82.27 49.51,82.62 49.51,82.81 49.74,83.04 50.92,83.04 51.05,83.18 51.05,83.54 50.92,83.67 50.04,83.67 49.87,83.84 49.58,83.84 48.37,82.63 48.37,79.26 49.25,78.38 49.25,78.19 48.78,77.71 48.59,77.71 47.77,78.54 47.58,78.54 47.38,78.35 47.38,78.16 48.21,77.33 48.21,77.14 47.09,76.03 47.09,74.86 46.76,74.53 46.76,72.87 46.5,72.62 46.5,69.4 48.78,67.12 48.97,67.12 49.34,67.49 49.53,67.49 49.72,67.3 49.72,67.11 49.35,66.74 49.35,66.55 49.93,65.97 49.93,65.71 49.8,65.58 49.02,65.58 48.88,65.44 48.88,65.17 49.02,65.04 49.28,65.04 49.61,64.71 49.61,57.97 50.21,57.37 50.21,55.45 52,53.65 52,52.23 53.13,51.11 53.13,48.56 53.42,48.27 53.42,45.33 56.54,42.2 57.46,42.2 59.6,40.05 60.03,40.05 61.75,38.33 70.33,38.33 71.39,37.27 74.66,37.27 75.33,36.6 81.33,36.6 82.12,37.4 82.68,37.4 82.82,37.53 82.82,38.02 82.95,38.16 83.22,38.16 83.35,38.02 83.35,37.53 83.49,37.4 84.15,37.4 84.28,37.53 84.28,38.02 84.42,38.16 84.79,38.16 84.93,38.02 84.93,37.66 85.06,37.52 85.33,37.52 85.47,37.66 85.47,38.02 85.6,38.16 85.97,38.16 86.47,38.66 86.73,38.66 86.87,38.53 86.87,37.86 87,37.72 87.27,37.72 87.41,37.86 87.41,38.53 87.54,38.66 88.62,38.66 89.33,39.37 89.59,39.37 89.73,39.24 89.73,39.11 89.86,38.97 90.13,38.97 90.26,39.11 90.26,39.24 90.4,39.37 90.67,39.37 90.8,39.24 90.8,39.11 90.94,38.97 91.21,38.97 91.34,39.11 91.34,39.24 91.48,39.37 91.81,39.37 91.94,39.24 91.94,38.64 92.06,38.53 98.61,38.53 99.32,37.82 100.87,37.82 v1(101.38,38.32)
  BOTTOM w0.112: RPC2.8 102.63,38.98 102.52,38.87 101.99,38.87 101.89,38.77 101.76,38.77 101.38,38.39 v1(101.38,38.32) ; v1(49.54,78.96) 49.22,78.96 48.29,79.89 48.29,92.84 45.75,95.37 JESPI1.3
ESPI_IO1: length 141.3
  TOP w0.089: v2(53.02,80.56) 52.54,80.56 52.18,80.21 UE1.60
  TOP w0.112: v1(49.54,79.55) 49.8,79.55 50.46,80.21 UE1.60
  IN3 w0.135: v1(102.01,38.29) 102.08,38.29 102.24,38.44 102.24,38.66 102.15,38.74 100.68,38.74 100.55,38.62 100.55,38.14 100.46,38.04 99.48,38.04 99.35,38.18 99.35,38.79 99.21,38.92 98.35,38.92 98.19,38.76 93.54,38.76 92.7,39.6 89.23,39.6 88.53,38.89 86.38,38.89 85.87,38.39 82.79,38.39 81.23,36.83 80.97,36.83 80.84,36.96 80.84,37.38 80.7,37.51 80.43,37.51 80.3,37.38 80.3,36.96 80.16,36.83 79.89,36.83 79.76,36.96 79.76,37.38 79.62,37.51 79.35,37.51 79.22,37.38 79.22,36.96 79.09,36.83 76.49,36.83 76.36,36.96 76.36,37.45 76.22,37.59 75.96,37.59 75.82,37.45 75.82,36.96 75.69,36.83 75.42,36.83 74.75,37.5 71.48,37.5 70.43,38.56 67.88,38.56 67.75,38.69 67.75,39.13 67.62,39.27 67.35,39.27 67.21,39.13 67.21,38.69 67.08,38.56 66.81,38.56 66.67,38.69 66.67,39.13 66.54,39.27 66.27,39.27 66.13,39.13 66.13,38.69 66,38.56 65.73,38.56 65.6,38.69 65.6,39.13 65.46,39.27 65.19,39.27 65.06,39.13 65.06,38.69 64.92,38.56 64.65,38.56 64.52,38.69 64.52,39.13 64.38,39.27 64.12,39.27 63.98,39.13 63.98,38.69 63.85,38.56 63.58,38.56 63.44,38.69 63.44,39.13 63.31,39.27 63.04,39.27 62.9,39.13 62.9,38.69 62.77,38.56 62.3,38.56 62.16,38.69 62.16,39.13 62.03,39.27 61.13,39.27 60.12,40.28 59.7,40.28 57.55,42.43 56.64,42.43 55.16,43.9 55.16,44.09 55.71,44.64 55.71,44.83 55.52,45.02 55.33,45.02 54.78,44.47 54.59,44.47 54.4,44.66 54.4,44.85 55.05,45.5 55.05,45.69 54.86,45.88 54.67,45.88 54.02,45.23 53.83,45.23 53.65,45.42 53.65,46.35 53.78,46.48 53.92,46.48 54.06,46.62 54.06,46.89 53.92,47.02 53.78,47.02 53.65,47.16 53.65,47.42 53.78,47.56 53.92,47.56 54.06,47.69 54.06,47.96 53.36,48.66 53.36,51.2 52.23,52.33 52.23,53.75 50.44,55.54 50.44,56.95 50.86,57.37 50.86,58.37 50.42,58.81 49.97,58.81 49.84,58.95 49.84,59.22 49.97,59.35 50.3,59.35 50.44,59.49 50.44,59.76 50.3,59.89 49.97,59.89 49.84,60.03 49.84,60.3 49.97,60.43 50.3,60.43 50.44,60.56 50.44,60.83 50.24,61.02 49.92,61.02 49.84,61.1 49.84,63.86 49.97,63.99 50.28,63.99 50.44,64.15 50.44,64.42 50.3,64.56 49.97,64.56 49.84,64.69 49.84,65.01 49.92,65.1 50.3,65.1 50.47,65.27 50.47,66.86 49.53,67.81 49.34,67.81 48.97,67.45 48.78,67.45 48.49,67.74 48.49,67.93 48.71,68.14 48.71,68.33 48.52,68.52 48.33,68.52 48.11,68.31 47.92,68.31 46.99,69.24 46.73,69.5 46.73,72.52 46.99,72.78 46.99,74.43 48.06,75.5 48.06,75.69 47.66,76.08 47.66,76.27 49.01,77.62 49.2,77.62 49.53,77.29 49.72,77.29 50.9,78.47 50.9,79.32 50.76,79.46 49.64,79.46 49.55,79.55 v1(49.54,79.55)
  BOTTOM w0.112: v1(49.54,79.55) 49.54,79.55 49.54,79.56 49.51,79.53 49.29,79.53 48.49,80.32 48.49,93.22 45.84,95.87 JESPI1.4 ; v1(102.01,38.29) 102.02,38.29 102.02,38.54 102.13,38.66 103.01,38.66 103.13,38.78 RPC2.7
ESPI_IO2: length 143.2
  TOP w0.089: v3(53.02,82.34) 53.02,81.36 52.26,80.61 UE1.61
  TOP w0.112: UE1.61 50.2,80.61 v1(49.7,80.11)
  IN3 w0.135: v1(49.7,80.11) 50.13,79.68 50.42,79.68 50.55,79.82 50.55,80.4 50.42,80.53 50.2,80.53 50.07,80.67 50.07,80.94 50.2,81.07 50.42,81.07 50.55,81.21 50.55,82.17 50.69,82.3 50.99,82.3 51.12,82.17 51.12,78.38 49.72,76.97 49.53,76.97 49.2,77.3 49.01,77.3 48.82,77.11 48.82,76.92 49.21,76.52 49.21,76.33 49.02,76.14 48.83,76.14 48.44,76.53 48.25,76.53 48.05,76.34 48.05,76.02 48.38,75.69 48.38,75.5 47.21,74.34 47.21,72.68 46.96,72.43 46.96,70.89 47.12,70.73 47.53,70.73 47.67,70.59 47.67,70.32 47.53,70.19 47.12,70.19 46.96,70.03 46.96,69.59 47.09,69.47 47.81,68.74 48.25,68.74 48.4,68.88 48.4,70.33 48.53,70.46 49.01,70.46 49.14,70.33 49.14,68.81 49.9,68.05 50.09,68.05 50.2,68.15 50.39,68.15 50.58,67.96 50.58,67.77 50.33,67.52 50.33,67.33 50.7,66.96 50.7,63.47 50.08,62.84 50.08,61.51 50.66,60.92 50.66,58.89 51.33,58.22 51.33,57.25 51.7,56.89 51.7,56.7 50.75,55.75 50.75,55.56 50.94,55.37 51.13,55.37 52.08,56.31 52.27,56.31 52.46,56.12 52.46,55.39 52.33,55.25 51.83,55.25 51.7,55.12 51.7,54.85 51.83,54.71 52.33,54.71 52.46,54.58 52.46,52.42 53.59,51.3 53.59,48.75 54.29,48.05 54.29,46.77 55.94,45.12 55.94,44.54 55.49,44.09 55.49,43.9 56.73,42.65 57.65,42.65 59.79,40.51 60.21,40.51 61.23,39.5 67.98,39.5 68.69,38.79 70.52,38.79 71.58,37.73 74.84,37.73 75.1,37.47 75.52,37.47 75.86,37.82 76.45,37.82 76.59,37.68 76.59,37.19 76.72,37.06 78.66,37.06 78.8,37.19 78.8,37.61 78.93,37.74 81.82,37.74 82.85,38.77 83.04,38.77 83.2,38.62 83.47,38.62 83.6,38.75 83.6,38.99 83.74,39.12 84.01,39.12 84.14,38.99 84.14,38.75 84.28,38.62 84.55,38.62 84.68,38.75 84.68,38.99 84.82,39.12 85.08,39.12 85.22,38.99 85.22,38.75 85.35,38.62 85.62,38.62 85.76,38.75 85.76,38.99 85.89,39.12 88.43,39.12 89.15,39.84 92.79,39.84 93.64,38.98 96.48,38.98 96.61,39.12 96.61,39.43 96.75,39.56 97.02,39.56 97.15,39.43 97.15,39.12 97.29,38.98 98.09,38.98 98.67,39.56 98.97,39.56 99.52,39.02 102.41,39.02 102.6,38.83 v1(102.6,38.27)
  BOTTOM w0.112: v1(49.7,80.11) 48.7,81.12 48.7,93.42 45.74,96.37 JESPI1.5 ; v1(102.6,38.27) 102.84,38.03 103.34,38.03 103.45,38.14 103.45,38.43 103.63,38.61 RPC2.6
ESPI_IO3: length 165.6
  TOP w0.089: v1(106.61,38.6) 106.53,38.68 v3(106.53,39.24)
  TOP w0.112: v1(49.67,80.86) 49.81,81.01 UE1.62
  IN1 w0.119: v1(28.56,76.98) 28.56,75.99 26.79,74.23 26.79,67.51 28.32,65.98 28.32,62.68 29.29,61.7 30.2,61.7 30.84,61.06 32.17,61.06 33.82,59.41 33.82,57.83 34.47,57.19 34.47,53.99 35.85,52.61 36.33,52.61 37.45,51.49 37.45,50.08 37.23,49.86 37.23,47.29 40.91,43.61 43.12,43.61 43.25,43.49 44.56,43.49 44.98,43.9 53.54,43.9 55.54,45.91 57.92,45.91 59.3,44.53 62.59,44.53 63.27,43.85 64.53,43.85 67.19,41.19 70.3,41.19 71.9,39.59 72.9,39.59 73.24,39.25 75.69,39.25 76.22,38.73 83.21,38.73 83.79,39.31 85.52,39.31 86.04,39.82 91.53,39.82 92.15,39.2 96.68,39.2 97.17,38.71 98.51,38.71 99.19,38.03 100.28,38.03 101.26,39.01 106.2,39.01 v1(106.61,38.6) ; v1(30.49,78.13) 30.49,80.08 34.74,84.33 36.04,84.33 37.17,83.19 47.84,83.19 48.62,82.41 48.62,81.34 48.95,81.01 49.52,81.01 v1(49.67,80.86)
  BOTTOM w0.089: v1(30.49,78.13) 29.35,76.98 v1(28.56,76.98)
  BOTTOM w0.112: JESPI1.6 45.29,96.87 45.46,96.71 46.86,96.71 48.9,94.66 48.9,81.61 49.65,80.86 v1(49.67,80.86) ; RPC2.5 104.13,38.73 104.72,38.13 106.16,38.13 106.61,38.59 v1(106.61,38.6)
ESPI_RESET#: length 102.4
  TOP w0.089: v1(108.5,52.89) v2(109.18,52.89)
  TOP w0.112: UE1.53 52.51,77.41 v1(52.83,77.72)
  IN1 w0.119: v1(108.5,52.89) 108.5,52.89 107.63,52.02 107.18,52.02 107.06,52.14 107.06,53.33 106.81,53.58 103.12,53.58 100.43,50.9 100.43,47.99 98.68,46.23 95.63,46.23 94.8,45.41 83.45,45.41 82.13,44.09 72.41,44.09 69.12,47.39 66.99,47.39 65.76,48.61 59.73,48.61 58.92,49.42 58.92,57.25 57.37,58.8 56.36,58.8 54.76,60.39 54.76,61.13 56.29,62.67 56.29,66.18 54.14,68.34 54.14,69.78 54.63,70.28 54.63,71.48 54.64,71.5 54.64,76.04 54.63,76.06 54.63,76.26 53.17,77.72 v1(52.83,77.72)
  BOTTOM w0.076: UC1.BA11 114.36,56.12 114.04,55.79 113.29,55.79 112.38,54.88 111.53,54.88 110.54,53.9 108.93,53.9 108.5,53.47 v1(108.5,52.89)
EXT_PWR_GATE#: length 1.6
  TOP w0.089: v1(119.96,55.04) 120.14,54.86 TP13.1
  BOTTOM w0.076: v1(119.96,55.04) 120.03,55.04 120.29,55.3 UC1.AM10
FAN1_PWM: length 209
  TOP w0.089: v1(130.72,112) 130.54,111.82 123.45,111.82 123.22,112.05 v1(121.43,112.05) ; v1(53.09,96.31) 53.16,96.38 v3(53.16,99.88) 53.35,100.07 53.35,105.27 54.57,106.49 54.57,110.69 52.95,112.3 52.74,112.3 v1(52.19,112.85) ; UE1.47 52.14,75.01 52.78,74.36 53.49,74.36 53.81,74.05 55.03,74.05 v1(55.08,74) ; v1(179.4,69.83) 179.93,69.83 R50.1
  IN1 w0.089: v1(179.4,69.83) 179,70.23 176.82,70.23 176.55,70.49 176.26,70.49 170.7,76.06 170.7,86.78 170.54,87.39 170.5,87.51 170.49,87.52 170.43,87.78 170.37,88.03 170.37,88.05 170.36,88.1 170.36,88.1 169.94,89.68 169.69,93.73 165.22,98.2 163.26,98.2 156.56,104.9 144.16,104.9 141.04,108.02 138.91,108.02 138.34,108.59 135.23,108.59 132.29,111.54 131.17,111.54 v1(130.72,112)
  IN2 w0.089: v1(55.08,74) 55.43,74 55.61,74.18 55.61,86.93 54.69,87.84 54.69,94.71 v1(53.09,96.31) ; v1(121.43,112.05) 119.16,114.32 109.83,114.32 108.5,115.65 106.36,115.65 105.97,116.04 100.04,116.04 99.32,116.76 92.82,116.76 90.45,119.13 85.39,119.13 85.35,119.09 75.13,119.09 73.9,117.87 72.11,117.87 71.32,117.07 67.42,117.07 66.17,115.82 58.57,115.82 55.86,113.11 53.63,113.11 52.97,112.44 52.6,112.44 v1(52.19,112.85)
  BOTTOM w0.508: v1(179.4,69.83) 180.16,69.83 JFAN1.2
FAN1_TACH: length 211
  TOP w0.089: v1(52.78,112.85) 54.83,110.79 54.83,106.36 53.76,105.28 v3(53.76,104.53) 53.76,96.08 v1(53.13,95.46) ; CE28.1 53.52,72.68 RE13.1 52.86,72.69 52.38,72.21 UE1.40 ; v1(131.35,112.02) 130.89,112.48 129.83,112.48 129.52,112.17 126.39,112.17 v1(125.81,112.75)
  TOP w0.102: v1(55.06,71.19) 53.84,71.19 53.52,71.52 CE28.1
  IN1 w0.089: v1(180.18,70.63) 179.62,71.19 177.61,71.19 176.59,72.21 174.81,72.21 170.88,76.13 170.88,86.81 170.71,87.43 170.66,87.63 170.65,87.64 170.61,87.82 170.56,88.01 170.57,88.02 170.54,88.14 170.12,89.71 169.86,93.85 165.25,98.46 163.28,98.46 156.65,105.09 144.84,105.09 140.88,109.05 135.64,109.05 132.67,112.02 v1(131.35,112.02)
  IN2 w0.089: v1(52.78,112.85) 53.4,113.47 55.95,113.47 58.58,116.1 66.19,116.1 67.35,117.26 71.24,117.26 72.06,118.07 73.83,118.07 75.04,119.28 85.25,119.28 85.29,119.31 90.62,119.31 92.52,117.42 99.05,117.42 100.24,116.23 106.17,116.23 106.56,115.83 108.57,115.83 109.83,114.57 119.34,114.57 120.58,113.34 122.22,113.34 122.8,112.75 v1(125.81,112.75) ; v1(53.13,95.46) 54.29,94.3 54.29,87.87 55.11,87.04 55.11,75.66 54.62,75.17 54.62,71.64 v1(55.06,71.19)
  BOTTOM w0.508: JFAN1.3 180.78,70.63 v1(180.18,70.63)
FB_1.2V: length 6.3
  TOP w0.089: PRM10.1 v2(34.04,34.09)
  TOP w0.203: PCM17.1 33.23,32.25 PRM11.1 ; PCM17.1 PRM10.1 ; PCM17.1 34.2,32.09 34.2,31.23 34.12,31.15 34.12,30.23 34.74,29.61 PUM01.6
FB_1.8VALW: length 4.6
  BOTTOM w0.089: PR1807.2 171.57,47.06 v2(172.08,47.06)
  BOTTOM w0.254: PR1805.1 PC1807.2 PR1807.2 171.04,46.22 170.75,45.93 170.75,45.66 170.5,45.42 PU1801.6
FB_2PH_CPU: length 8.3
  TOP w0.089: PRZ24.1 179.22,49.5 v2(179.92,49.5)
  TOP w0.254: PRZ24.1 178.42,50.3 PCZ15.1 179.03,51.07 v1(179.04,51.06)
  BOTTOM w0.203: PCZ13.2 178.68,50.42 PRZ21.2 178.28,50.44 177.54,51.18 177.54,51.72 176.83,52.44 PUZ01.3
  BOTTOM w0.254: PRZ21.2 179.04,50.81 v1(179.04,51.06)
FB_+1VALW: length 3.8
  TOP w0.089: v1(164.31,51.11) 164.31,51.18 v2(163.74,51.75)
  TOP w0.254: v1(164.31,51.11) PRH08.1 164.9,51.15 PRH12.2
  BOTTOM w0.254: PUH01.10 164.27,51.15 v1(164.31,51.11) 164.71,51.11 PRH09.1
FB__+1.35VGPU: length 6.8
  TOP w0.089: v1(143.35,110.86) v2(143.35,111.72)
  BOTTOM w0.254: PUW01.10 v1(143.35,110.86) 143.35,111.38 PRW09.1 142.71,112.24 PRW10.1 142.67,112.68 143.07,113.09 144,113.41 PRW13.2
FB_GND: length 2.3
  TOP w0.381: RV158.1 116.31,138.04 117.26,137.09 v1(117.26,136.91)
  BOTTOM w0.305: v1(117.26,136.91) 117.26,136.88 UV1.AD20
FB_VDDC: length 3.1
  TOP w0.102: v1(117.89,136.98) 117.89,136.38 v2(117.8,136.29)
  TOP w0.381: v1(117.89,136.98) 117.89,137.2 117.21,137.88 RV159.1
  BOTTOM w0.305: v1(117.89,136.98) 117.89,136.95 118.44,136.4 UV1.AC20
FB_VDDCI: length 2.5
  BOTTOM w0.102: UV1.W1 121.07,121.92 TP67.1
FFS_INT1: length 82.5
  TOP w0.089: v1(179.13,29.18) v2(179.84,29.18) 180.54,29.18 181.3,29.94 181.3,31.36 US1.12 ; v1(153.66,26.92) 153.66,26.98 152.54,28.1 152.54,31.06 150.63,32.97 150.63,34.48 147.49,37.62 143.57,37.62 141.95,39.24 141.95,41.26 140.84,42.91 139.63,44.12 139.63,44.58 139.14,45.07 138.85,45.07 v1(138.43,44.65)
  IN1 w0.089: v1(153.66,26.92) 154.27,27.53 155.26,27.53 155.76,28.03 159.14,28.03 161.03,29.92 172.69,29.92 173.5,29.11 177,29.11 177.41,28.7 178.65,28.7 v1(179.13,29.18)
  BOTTOM w0.076: 133.1,49.08 133.05,49.13 132.75,49.13 132.74,49.14 132.7,49.14 132.21,49.62 132.1,49.62 132.03,49.69 131.6,49.69 131.45,49.84 131.45,50.14 131.53,50.22 131.53,50.42 131.45,50.49 131.45,51.8 131.33,51.93 131.32,51.93 131.32,52.06 131.2,52.19 131.1,52.22 130.93,52.22 130.74,52.04 130.74,51.65 UC1.M3
  BOTTOM w0.089: RC35.2 143.1,39.58 143.1,41.11 139.18,45.03 138.81,45.03 v1(138.43,44.65) ; 133.1,49.08 134.28,47.91 134.28,47.51 134.66,47.12 134.66,47.12
  BOTTOM w0.102: 134.66,47.12 134.66,45.85 136.54,43.98 138.14,43.98 138.43,44.27 v1(138.43,44.65)
FFS_INT2: length 110.2
  TOP w0.089: US1.11 181.72,32.34 181.12,31.74 181.12,30.09 180.62,29.6 178.99,29.6 v1(178.51,29.12) v2(178.51,28.44) ; v1(152.44,26.92) 152.09,27.27 152.09,31 150.27,32.82 150.27,34.32 147.35,37.24 143.43,37.24 141.58,39.09 141.58,41.15 140.55,42.68 139.78,43.46 138.34,44.05 135.9,44.05 135.4,43.83 134.14,43.83 133.92,44.05 133.92,44.98 133.04,45.86 129.36,45.86 128.95,45.45 127.55,45.45 127.14,45.87 125.74,45.87 125.09,46.52 124.64,46.52 v1(124.29,46.87) ; QS1.2 195.28,36.65 195.17,36.53 194.87,36.53 194.23,35.9 194.23,33.26 194.46,33.03 195.23,33.03 196.02,32.24 196.02,30.82 195.42,30.22 185.3,30.22 v1(184.68,30.84)
  IN1 w0.089: v1(178.51,29.12) 178.33,29.29 173.58,29.29 172.77,30.11 159.17,30.11 157.89,28.83 156.09,28.83 154.98,27.71 153.23,27.71 v1(152.44,26.92)
  IN2 w0.089: v1(178.51,29.12) 178.95,29.55 179.21,29.55 181.16,31.5 184.02,31.5 v1(184.68,30.84)
  BOTTOM w0.076: 124.49,49.31 124.17,49.64 124.17,50.13 124.16,50.16 124.16,50.39 124.22,50.59 124.42,50.78 UC1.AC2
  BOTTOM w0.102: 124.14,45.33 124.14,44.63 RC36.2 ; 124.16,47.79 124.49,48.11 124.49,49.31
  BOTTOM w0.112: 124.14,45.33 124.14,46.33 124.32,46.5 124.32,46.84 v1(124.29,46.87) 124.16,46.99 124.16,47.79
FFS_INT2_Q: length 38
  TOP w0.089: v1(184.34,34.58) 184.72,34.2 RS4.2 185.34,33.82 185.34,31.4 ; QS1.3 194.63,36.57 194.3,36.23
  TOP w0.102: 185.34,31.4 186.33,30.41 195.19,30.41 v2(195.7,30.92) 195.7,32.29 195.18,32.81 194.36,32.81 194.04,33.13 194.04,35.97 194.3,36.23
  BOTTOM w0.089: v1(184.34,34.58) 185.62,33.29 189.99,33.29 190.71,34.02 190.71,34.84 190.6,34.96 190.6,36.67 190.22,37.05 186.47,37.05 186.2,36.79 JHDD.12
FP_GND: length 4.8
  TOP w0.089: R87.2 v2(221.23,27.34)
  TOP w0.508: R87.2 220.07,28.27 219.49,28.85 v1(219.49,28.98)
  BOTTOM w0.305: v1(219.49,28.98) 219.52,29 JFP.2
FP_VCC: length 10.5
  BOTTOM w0.305: JFP.6 217.52,28.5 v1(218.13,27.88)
  BOTTOM w0.508: v1(218.13,27.88) 218.49,27.53 220.07,27.53 220.43,27.88 220.43,28.7 220.7,28.97 221.71,28.97 222.07,29.32 C37.2
  vias: v3(215.71,26.4)
FP_VCC_R: length 6.5
  TOP w0.089: R86.1 219.64,26.82 219.64,25.66 v2(219.43,25.45)
  TOP w0.254: v1(219.24,28.15) 219.12,28.04 R86.1
  BOTTOM w0.254: v1(219.24,28.15) 218.68,28.15 218.02,28.81 JFP.5
FPR_SCAN#: length 286.1
  TOP w0.089: v3(53.88,86.14) 53.44,86.58 RE85.2 52.97,87.83 52.97,88.04 52.15,88.87 v1(51.28,88.87) ; v1(45.88,73.11) 45.44,73.11 45.44,73.11 40.22,73.11 37.38,70.27 v1(37.38,69.64)
  TOP w0.102: EU4012.3 51.15,88.74 v1(51.28,88.87)
  IN1 w0.089: v1(41.97,42.99) 41.76,43.2 40.78,43.2 36.85,47.13 36.85,50.02 37.04,50.2 37.04,51.37 36.18,52.23 35.63,52.23 34.08,53.78 34.08,56.73 33.32,57.49 33.32,58.72 32.53,59.51 32.53,60.35 32.02,60.86 30.75,60.86 30.1,61.51 28.73,61.51 v1(27.02,63.22)
  IN2 w0.089: v1(222.07,34.6) 221.55,34.6 218.72,31.77 218.25,31.77 217.8,32.22 215.9,32.22 215.37,31.68 215.37,30.16 214.82,29.61 213.76,29.61 213.31,30.07 183.71,30.07 183.28,30.49 181.85,30.49 179.47,28.11 175.89,28.11 175.37,27.59 169.99,27.59 169.64,27.24 166.57,27.24 165.47,28.33 163.85,28.33 162.97,27.45 156.07,27.45 155.84,27.68 148.07,27.68 145.08,30.67 144.29,30.67 143.37,31.59 138.98,31.59 136.75,29.36 129.79,29.36 129.65,29.5 119.14,29.5 v1(117.81,28.18)
  IN3 w0.089: v1(45.88,73.11) 45.88,73.18 45.88,73.19 45.88,74.89 46.5,75.5 46.5,79.15 47.01,79.67 47.01,82.91 50.18,86.07 50.18,88.01 51.04,88.87 v1(51.28,88.87) ; v1(37.38,69.64) 36.81,70.21 34.72,70.21 32.07,67.57 29.65,67.57 29.17,67.09 29.17,64.47 27.91,63.22 v1(27.02,63.22)
  BOTTOM w0.089: v1(117.81,28.18) 117.29,28.7 113.73,28.7 113.4,28.37 113.4,27.41 113.05,27.06 113.05,26.27 112.62,25.84 99.49,25.84 98.91,25.26 77.32,25.26 71.15,31.44 66.44,31.44 65.52,32.36 57.45,32.36 55.69,34.12 55.17,34.12 54,35.29 47.72,35.29 43.24,39.77 43.24,42.5 42.75,42.99 v1(41.97,42.99) ; JFP1.2 220.52,29.79 220.7,29.61 221.18,29.61 221.5,29.93 221.5,32.89 R72.2 222.22,34.45 v1(222.07,34.6)
GPIO19_CTF: length 7.4
  BOTTOM w0.089: RV152.1 126.46,118.74 v2(126.46,117.55)
  BOTTOM w0.102: RV152.1 126.02,119.59 126.78,119.59 126.9,119.47 RV151.2 127.51,119.72 127.51,121.27 127.29,121.49 127.29,122.95 UV1.M2
GPIO28: length 7.3
  BOTTOM w0.102: UV1.R5 125.33,123.81 125.33,121.64 123.73,120.05 123.61,120.05 123.01,119.45 123.01,119.26 v2(123.02,119.25) 123.2,119.25 123.83,118.61 RV21.2
GPP_B23: length 14.8
  TOP w0.102: v2(117.32,47.42) 117.32,48.01 120.12,50.8 120.12,51.48 120.53,51.9 120.93,51.9 121.17,52.14 121.17,53.5 v1(120.75,53.92)
  TOP w0.112: RC39.1 120.7,45.48 118.04,45.48 117.32,46.19 v2(117.32,47.42)
  BOTTOM w0.076: v1(120.75,53.92) 120.64,53.92 UC1.AM7
GPP_C5: length 5.8
  BOTTOM w0.076: UC1.W1 126.4,49.84 126.7,49.54 126.7,49.11
  BOTTOM w0.112: RC38.1 130.06,46.4 129.54,46.92 129.28,46.92 v2(128.81,47.4) 128.63,47.57 127.82,47.57 127,48.4 127,48.82 126.7,49.11
GPU_PWR_LEVEL: length 152.2
  TOP w0.089: UE1.10 40.95,69.65 41.73,70.43 41.73,72.46 41.91,72.64 v1(45.43,72.64)
  TOP w0.102: v1(120.84,112.06) 122.3,113.52 126.53,113.52 v1(128.89,115.88) ; v1(124.92,127.01) 125.48,126.45 125.48,122.18 v1(126.04,121.61)
  IN1 w0.102: v1(126.04,121.61) 126.49,121.61 129.78,118.32 129.78,116.77 v1(128.89,115.88)
  IN2 w0.102: v1(120.84,112.06) 118.77,114.13 109.75,114.13 108.54,115.34 106.41,115.34 105.89,115.85 99.97,115.85 99.45,116.36 92.78,116.36 90.93,118.22 87.65,118.22 86.99,118.88 77.01,118.88 76.4,118.27 74.57,118.27 73.98,117.68 72.19,117.68 71.4,116.88 67.5,116.88 66.18,115.57 58.6,115.57 55.68,112.64 53.98,112.64 52.46,111.12 52.46,106.19 52.69,105.96 52.69,103.23 52.26,102.81 52.26,91.85 v1(52.61,91.5)
  IN3 w0.089: v1(45.43,72.64) 45.41,72.66 45.41,74.67 46.31,75.58 46.31,79.23 46.83,79.75 46.83,82.99 49.98,86.15 49.98,88.23 52.03,90.28 52.03,90.91 v1(52.61,91.5)
  BOTTOM w0.089: v2(129.85,118.42) RV260.1
  BOTTOM w0.102: v1(128.89,115.88) 128.89,116.5 RV260.1 ; UV1.T9 124.53,127.4 v1(124.92,127.01)
H_CATERR#: length 8.8
  BOTTOM w0.076: UC1.D63 134.85,85.73 135.13,85.45 135.42,85.45 135.63,85.36 135.81,85.3 136.09,85.3 136.19,85.33 136.34,85.33 136.35,85.31 136.76,85.31 136.9,85.44 137.69,85.44 138.31,84.83 138.4,84.83 v2(138.8,84.43) 139.15,84.08 139.18,84.08
  BOTTOM w0.112: 139.18,84.08 140.75,84.08 141.02,83.82 141.92,83.82 RC111.2
H_CPU_SVIDALRT#: length 4.1
  BOTTOM w0.076: 139.18,85.81 v2(138.65,85.81) 138.19,85.81 138.02,85.98 136.15,85.98 UC1.B63
  BOTTOM w0.112: RC153.1 139.67,85.81 139.18,85.81
H_CPUPWRGD: length 7.9
  BOTTOM w0.089: CC15.1 140.27,93.45 141.51,93.45 v2(141.63,93.34)
  BOTTOM w0.102: UC1.A68 136.74,88.86 137.56,89.68 137.56,89.84 ; CC15.1 RC95.2
  BOTTOM w0.112: 137.56,89.84 137.56,90.16 139.25,91.86 RC95.2
H_CPUPWRGD_R: length 1
  BOTTOM w0.102: TP7.1 141.11,91.89 141.07,91.86 RC95.1
H_DRAMRST#: length 129
  TOP w0.112: v2(69.09,81.74) v1(69.09,82.26) 69.5,82.26 70.04,82.8 RD8.1 70.08,82.93 RD7.2
  IN1 w0.119: v1(55.83,60.99) 56.46,61.63 58.23,61.63 59.08,60.78 69.2,60.78 70.21,61.79 70.21,69.01 68.56,70.66 68.56,72.96 68.25,73.27 68.25,75.71 68.63,76.1 68.63,81.81 68.67,81.85 68.67,81.85 68.92,82.09 68.92,82.09 v1(69.09,82.26)
  IN3 w0.135: v1(55.83,60.99) 56.58,60.24 56.58,59.02 57.38,58.22 57.38,51.19 58.78,49.79 58.78,45.21 59.9,44.08 60.31,44.08 60.85,43.53 62.93,43.53 63.62,42.84 66.73,42.84 67.37,42.2 70.47,42.2 71.2,41.46 73.7,41.46 74.5,40.66 75.17,40.66 75.17,40.66 75.64,40.66 76.95,41.96 77.3,41.96 77.34,41.92 78.54,41.92 78.64,42.01 79.19,42.01 79.25,41.95 81.29,41.95 82.56,43.22 83.95,43.22 84.68,43.96 87.62,43.96 88.25,44.59 96.26,44.59 97.98,42.88 98.15,42.88 99.01,42.88 99.51,43.38 99.51,46.09 100.22,46.8 103.66,46.8 103.72,46.87 105.46,46.87 106.05,47.46 106.59,47.46 106.72,47.6 106.72,48.7 107.91,49.88 107.91,50.95 108.61,51.65 109.3,51.65 110.31,52.65 110.31,52.85 113.53,56.08 114.04,56.08 114.71,56.76 v1(117.36,56.76)
  BOTTOM w0.102: v1(117.36,56.76) 117.68,57.08 UC1.AT13
H_PECI: length 5.7
  TOP w0.112: RE23.1 35.29,87.09 v2(35.87,86.51) 36.22,86.16 36.22,85.42 36.5,85.13 37.39,85.13 38.15,84.37 UE1.94
H_PROCHOT#: length 312.8
  TOP w0.112: v2(207.37,51.98) 206.97,51.98 v1(206.41,51.42) ; v1(130.46,97.32) 129.5,97.32 129.14,96.96 129.14,95.96 RC113.2 RC117.1 ; UE2.4 40.58,89.82 CE26.1 41.92,91.16 41.92,91.6 v1(42.69,92.38) ; v1(178.3,64.06) 177.82,63.58 176.4,63.58 175.39,62.57 PRZ43.2 ; v1(171.87,31.68) 171.87,30.81 PQ12.3 172.55,30.55 172.82,30.82 174.48,30.82 PQ11.1 ; PQS10.3 64.67,121.19 v1(65.01,120.85)
  IN1 w0.119: v1(143.73,104.45) 144.39,103.79 154.51,103.79 161.1,97.21 164.17,97.21 164.87,97.21 169.33,92.75 169.34,92.73 169.54,89.62 169.96,88.04 169.96,87.97 170.04,87.68 170.13,87.27 170.15,87.26 170.29,86.73 170.29,75.56 174.31,71.54 174.31,69.76 175.96,68.11 175.96,66.7 176.56,66.1 176.56,65.79 v1(178.3,64.06) 178.3,64.06 178.89,64.06 179.87,63.08 179.87,61.12 180.38,60.61 180.38,59.6 181.14,58.83 182.46,58.83 184.39,56.9 184.39,49.69 182.2,47.51 176.28,47.51 v1(175.99,47.21)
  IN2 w0.124: v1(130.46,97.32) 130.58,97.43 130.58,101.13 133.9,104.45 v1(143.73,104.45)
  IN3 w0.135: v1(187.46,61.7) 187.46,62.37 187.73,62.63 190.58,62.63 191.23,61.98 191.23,60.41 194.36,57.28 201.7,57.28 204.03,54.95 204.03,54.39 205.33,53.1 206.6,53.1 206.93,52.76 206.93,51.94 v1(206.41,51.42) ; v1(42.69,92.38) 43.81,92.38 44.79,93.35 44.79,97.24 45.11,97.56 45.11,98.51 46.01,99.41 46.01,101.26 45.93,101.35 v1(45.93,103.5) ; v1(65.01,120.85) 65.13,120.97 67.36,120.97 67.83,120.51 70.35,120.51 70.61,120.77 75.16,120.77 75.65,120.27 78.59,120.27 79.1,120.79 80.96,120.79 82.78,118.97 86.56,118.97 87.29,118.24 90.53,118.24 96.97,111.81 116.64,111.81 116.97,111.49 119.42,111.49 130.2,100.7 130.2,97.57 v1(130.46,97.32)
  BOTTOM w0.112: v1(65.01,120.85) 65.01,121.56 64.02,122.54 60.53,122.54 57.63,119.64 57.63,118.74 53.7,114.81 53.7,105 52.4,103.69 46.12,103.69 v1(45.93,103.5) ; v1(206.41,51.42) 206.27,51.28 PRB19.1 ; v1(171.87,31.68) 171.22,32.33 171.22,35.99 174.21,38.98 174.21,39.96 175.98,41.73 175.98,44.76 175.6,45.14 175.6,46.82 v1(175.99,47.21) ; v1(187.46,61.7) 185.93,61.7 185.21,62.42 183.07,62.42 181.13,64.36 178.6,64.36 v1(178.3,64.06) 177.62,63.38 175.9,63.38 175.15,62.62 PRZ49.2
H_PROCHOT#_R: length 22.1
  TOP w0.102: 139.18,87.68 v1(138.98,87.48)
  TOP w0.112: 139.18,87.68 139.38,87.88 139.38,89.23 139.96,89.8 139.96,91.94 136.61,95.29 133.34,95.29 v2(132.52,96.1) 131.8,96.82 130.5,96.82 130.06,96.38 RC117.2
  BOTTOM w0.076: v1(138.98,87.48) 138.46,88 137.79,88 137.68,87.88 137.68,87.32 137.47,87.11 135.82,87.11 135.76,87.09 135.25,86.86 UC1.C65
H_THERMTRIP#: length 7.8
  BOTTOM w0.076: UC1.C63 135.57,85.59 135.57,85.57 135.69,85.51 135.84,85.46 135.98,85.46 136.17,85.52 136.32,85.52 136.41,85.48 136.7,85.48 136.83,85.61 137.78,85.61 138.27,85.12 138.69,85.12 139.15,84.67 139.18,84.67
  BOTTOM w0.112: 139.18,84.67 TP14.1 141.16,84.67 141.17,84.67 141.89,84.67 RC112.2
H_VCCST_PWRGD: length 19.7
  TOP w0.112: v2(144.18,91.45) 143.65,90.91 v1(143.4,90.91)
  IN1 w0.119: v1(141.42,87.67) 141.42,88.1 141.54,88.21 142.47,88.21 142.59,88.1 142.59,86.89 142.71,86.77 142.95,86.77 143.07,86.89 143.07,88.1 143.19,88.21 143.28,88.21 143.4,88.33 143.4,88.57 143.28,88.69 141.54,88.69 141.42,88.81 141.42,89.05 141.54,89.17 143.28,89.17 143.4,89.29 143.4,89.53 143.28,89.65 141.54,89.65 141.42,89.77 141.42,90.01 142.32,90.91 v1(143.4,90.91)
  BOTTOM w0.112: v1(143.4,90.91) 143.4,91.29 143.78,91.66 UC7.4 ; RC96.1 C36.1 141.04,88.05 v1(141.42,87.67) 141.8,87.67 141.92,87.79 RC104.1
HDA_BIT_CLK: length 7
  BOTTOM w0.076: RC124.2 CC91.1 110.71,60.83 111.19,60.83 111.64,61.29 v2(111.87,61.29) 112,61.41 114.46,61.41 114.57,61.3 115.04,61.3 115.22,61.48 UC1.AY22
HDA_CODEC_BITCLK: length 148.8
  TOP w0.112: RA43.2 v1(33.58,14.73) 33.58,14.52 33.87,14.23 v2(34.68,14.23) 35.33,14.23 35.44,14.12 35.44,13.84 35.33,13.72 34.15,13.72 34.04,13.61 34.04,12.27 33.74,11.97 31.91,11.97 31.35,12.53 31.35,12.89 31.02,13.22 30.65,13.22 30.49,13.05 UA1.6
  IN1 w0.119: v1(41.59,45.42) 43.61,45.42 45.8,47.61 48.66,47.61 48.9,47.85 52.46,47.85 54.14,49.53 v1(54.74,49.53) ; v1(33.58,14.73) 33.53,14.78 33.53,19.06 32.74,19.85 32.74,21.19 31.95,21.98 31.95,22.92 30.47,24.39 30.47,25.53 29.89,26.12 29.89,27.09 28.23,28.74 28.23,31.24 27.44,32.03 26.85,32.03 24.23,34.65 24.23,35.75 27.41,38.94 27.87,38.94 31.52,42.59 v1(35.78,42.59)
  IN3 w0.135: v1(41.59,45.42) 41.09,45.42 38.26,42.59 v1(35.78,42.59)
  BOTTOM w0.112: v1(54.74,49.53) 54.74,47.45 55.96,46.23 55.96,43.65 58.68,40.92 62.14,40.92 62.32,40.74 68.66,40.74 69.09,40.3 71.07,40.3 71.99,39.39 73.11,39.39 73.79,38.71 75.24,38.71 76.96,36.99 79.76,36.99 82.13,39.37 89.1,39.37 89.81,40.08 92.02,40.08 93,41.06 93,42.9 94.06,43.96 94.06,44.49 98.84,49.27 98.84,55.07 101.91,58.14 105.33,58.14 107.59,60.39 RC124.1
HDA_CODEC_RST#: length 1.3
  TOP w0.112: TP74.1 101.57,49.45 RC127.1
HDA_CODEC_SDIN0: length 2.3
  TOP w0.112: UA1.8 30.28,13.85 30.67,14.23 31.1,14.23 RA7.2
HDA_CODEC_SDOUT: length 131.6
  TOP w0.112: UA1.5 30.64,12.65 v1(30.8,12.81) ; v1(55.71,51.16) v2(55.71,50.56) ; RC125.1 102.18,45.82 v1(102.18,45.22)
  IN1 w0.119: v1(36.34,42.12) 31.65,42.12 28.26,38.73 28.04,38.51 27.59,38.51 24.65,35.58 24.65,34.83 27.03,32.46 27.62,32.46 28.66,31.42 28.66,28.92 30.31,27.26 30.31,26.29 30.9,25.71 30.9,24.57 32.37,23.09 32.37,22.15 33.16,21.36 33.16,20.02 33.39,19.79 33.78,19.79 34.01,19.57 34.01,15.92 34.68,15.25 34.68,14.33 34.35,14 33.04,14 32.88,14.17 30.6,14.17 30.35,13.92 30.35,13.26 v1(30.8,12.81) ; v1(55.71,51.16) 55.71,49.88 53.13,47.3 49.23,47.3 48.97,47.04 45.82,47.04 43.59,44.81 v1(41.7,44.81)
  IN3 w0.135: v1(102.18,45.22) 102.18,44.96 101.6,44.39 101.6,43.36 100.28,42.04 99.02,42.04 97.63,42.04 95.92,43.76 88.6,43.76 87.97,43.12 85.21,43.12 84.24,42.15 82.99,42.15 81.72,40.88 81.33,40.88 80.48,40.03 78.48,40.03 78.29,40.22 76.59,40.22 75.96,39.59 73.31,39.59 72.46,40.44 69.37,40.44 68.66,41.15 61.91,41.15 60.9,42.16 60.47,42.16 58.4,44.24 58.4,44.4 57.95,44.85 57.95,44.86 57.94,44.86 57.94,48.91 57.69,49.16 57,49.16 56.4,49.76 56.4,50.47 v1(55.71,51.16) ; v1(41.7,44.81) 41.15,44.81 38.46,42.12 v1(36.34,42.12)
HDA_CODEC_SYNC: length 124.7
  TOP w0.112: RC123.1 98.99,50.53 98.17,49.71 v1(97.58,49.71) ; v1(39,17.64) 39,20.23 36.44,22.79 32.46,22.79 30.98,24.27 30.98,29.67 31.19,29.88 31.19,30.74 30.9,31.03 30.9,35.19 31.4,35.7 31.4,36.84 31.91,37.35 32.44,37.35 32.7,37.09 34.77,37.09 35.82,38.13 39.35,38.13 40.04,37.44 43.26,37.44 45.49,39.67 51.11,39.67 53.97,36.8 58.59,36.8 59.79,35.6 63.26,35.6 63.57,35.91 63.57,35.91 63.78,36.12 63.78,37.18 64.32,37.73 66.05,37.73 v2(68.57,40.25) 69.06,40.74 v1(69.06,41.63) ; v1(30.55,15.22) 30.55,14.98 30.22,14.65 UA1.10
  IN1 w0.119: v1(39,17.64) 38.36,17.64 36.81,16.09 36.81,14.64 35.34,13.17 34.17,13.17 33.5,12.49 31.05,12.49 30.95,12.39 30.56,12.39 29.89,13.06 29.89,14.6 30.52,15.22 v1(30.55,15.22)
  BOTTOM w0.112: v1(97.58,49.71) 97.58,48.88 93.44,44.75 93.44,44.21 92,42.77 92,40.94 91.76,40.7 89.56,40.7 88.85,39.99 81.15,39.99 79.5,38.34 76.58,38.34 74,40.92 69.35,40.92 69.06,41.22 v1(69.06,41.63)
HDA_RST#: length 33.1
  TOP w0.112: RC127.2 100,49.88 98.81,49.88 98.02,49.09 v2(97.74,49.09) v1(96.95,49.09) 96.84,49.2 CC99.1
  BOTTOM w0.076: UC1.AW22 115.6,62.42 113.25,62.42 113.03,62.2 111.38,62.2 110.79,61.6 106.22,61.6
  BOTTOM w0.102: 106.22,61.6 104.58,59.97 102.95,59.97
  BOTTOM w0.112: 102.95,59.97 101.95,59.97 96.89,54.91 96.89,49.46 96.95,49.41 v1(96.95,49.09)
HDA_SDIN0: length 147
  TOP w0.112: v1(54.73,50.2) 54.56,50.2 54.16,49.81 v2(54.16,49.69) ; v1(32.86,15.44) 32.57,15.15 RA7.1 32.57,14.46 CC98.1
  IN1 w0.119: v1(54.73,50.2) 54.18,50.2 52.42,48.44 46.03,48.44 43.43,45.84 41.94,45.84 v1(41.78,46) ; v1(32.86,15.44) 32.8,15.51 32.16,15.51 32.04,15.63 32.04,19.07 30.35,20.75 30.35,23.23 27.81,25.77 27.81,31.07 27.27,31.61 26.67,31.61 23.8,34.48 23.8,35.93 27.23,39.36 27.69,39.36 31.36,43.04 35.38,43.04 v1(35.78,43.44)
  IN3 w0.135: v1(41.78,46) 41.05,46 38.49,43.44 v1(35.78,43.44)
  BOTTOM w0.089: UC1.BA21 111.7,61.58 111.12,61 107.91,61 105.61,58.69
  BOTTOM w0.102: 104.64,58.69 105.61,58.69
  BOTTOM w0.112: 104.64,58.69 101.88,58.69 98.43,55.24 98.43,49.44 93.65,44.67 93.65,44.13 92.21,42.69 92.21,40.85 91.84,40.49 89.64,40.49 88.93,39.78 81.31,39.78 79.67,38.14 76.5,38.14 75.5,39.13 73.96,39.13 73.29,39.8 72.16,39.8 71.25,40.72 69.27,40.72 68.83,41.16 62.49,41.16 62.31,41.34 58.86,41.34 56.38,43.82 56.38,46.48 55.9,46.95 55.9,47.52 55.15,48.27 55.15,49.78 v1(54.73,50.2)
HDA_SDOUT: length 36.6
  TOP w0.112: RC125.2 101.46,46.82 RC129.2 101.46,46.84 RC126.2 101.46,48.41 100.22,49.64 98.87,49.64 97.88,48.65 v1(96.54,48.65) 96.14,48.65 v2(95.95,48.83) CC97.1
  BOTTOM w0.102: UC1.BB22 113.29,62.15 113.16,62.02 111.51,62.02 110.88,61.4 106.28,61.4 104.64,59.76
  BOTTOM w0.112: v1(96.54,48.65) 97.05,48.65 97.33,48.93 97.33,49.25 97.19,49.4 97.19,54.9 101.64,59.36 104.23,59.36 104.64,59.76
HDA_SYNC: length 27.8
  TOP w0.112: RC123.2 99.91,50.58 99.4,51.09 98.12,51.09 v2(97.85,50.81) 97.85,50.26 v1(98,50.11)
  BOTTOM w0.089: UC1.BA22 114.17,61.76 111.56,61.76 111.01,61.21 106.92,61.21 105.49,59.77
  BOTTOM w0.102: 105.49,59.77 104.78,59.07 104.64,59.07
  BOTTOM w0.112: 104.64,59.07 104.63,59.06 101.65,59.06 98,55.41 v1(98,50.11)
HDD_DET#: length 71.4
  TOP w0.089: RS7.1 183.17,34.55 v1(183.14,34.58) ; v1(133.94,46.66) v2(133.53,46.25)
  IN1 w0.089: v1(183.49,38.78) 183.11,39.16 178.13,39.16 177.39,38.41 173.78,38.41 172.75,37.38 164.89,37.38 164.37,37.9 155.69,37.9 155.06,37.27 154.45,37.27 v1(154.05,37.68)
  IN2 w0.089: v1(133.94,46.66) 138.18,46.66 139.79,45.04 139.79,44.1 142.9,40.99 143.2,40.99 144.01,40.18 146.67,40.18 147.7,39.14 151.39,39.14 152.29,38.24 153.49,38.24 v1(154.05,37.68)
  BOTTOM w0.076: 132.64,48.68 132.06,49.26 131.95,49.26 131.93,49.28 131.84,49.37 130.7,49.37 130.38,49.68 UC1.M1
  BOTTOM w0.089: v1(183.14,34.58) 183.14,34.56 182.57,33.99 181.35,33.99 180.41,34.94 180.41,36.22 180.64,36.44 181.96,36.44 183.03,37.51 RS6.1 183.03,38.32 v1(183.49,38.78) ; v1(133.94,46.66) 133.94,46.99 133.67,47.26 133.67,47.65 132.64,48.68
HDD_DEVSLP: length 75.4
  TOP w0.089: v1(137.84,44.64) 138.47,45.27 139.2,45.27 139.81,44.66 139.81,44.2 141.01,43 142.13,41.33 142.13,39.32 143.64,37.8 147.56,37.8 150.81,34.55 150.81,33.05 152.86,31.01 v2(152.86,29.55) 152.86,28.35 v1(154.28,26.92) ; RS1.2 186.45,32.26 v1(186.45,31.85)
  IN1 w0.089: v1(154.28,26.92) 154.71,27.35 155.34,27.35 155.83,27.84 159.21,27.84 161.11,29.74 172.61,29.74 173.43,28.93 176.92,28.93 177.34,28.51 179.22,28.51 179.79,29.09 179.79,30.24 181.85,32.29 181.86,32.29 181.86,32.3 181.88,32.3 181.92,32.34 185.97,32.34 v1(186.45,31.85)
  BOTTOM w0.112: UC1.J1 131.99,49.99 132.18,49.8 132.28,49.8 132.77,49.32 132.82,49.32 132.82,49.31 133.23,49.31 133.94,48.6 133.94,48.59 134.48,48.05 134.48,47.59 134.86,47.21 134.86,45.94 136.62,44.18 137.59,44.18 137.84,44.43 v1(137.84,44.64)
HDD_DEVSLP_R: length 2.4
  TOP w0.102: RS1.1 186.17,34.52 v1(186.21,34.57)
  BOTTOM w0.102: v1(186.21,34.57) 186.23,34.57 186.7,35.04 JHDD.13
HDD_EN_PCH: length 65.8
  TOP w0.089: v1(182.89,38.78) 183.44,39.34 US2.4
  IN2 w0.089: v1(145.58,36.83) 145.93,36.47 146.45,36.47 146.93,36.95 148.96,36.95 149.48,36.43 151.63,36.43 153.21,34.85 155.18,34.85 155.72,35.38 158.52,35.38 160.57,37.44 169.63,37.44 169.97,37.09 174.95,37.09 176.01,38.15 180.35,38.15 180.98,38.78 v1(182.89,38.78)
  BOTTOM w0.076: UC1.J4 131.71,51.87 132.29,51.29 132.63,51.29 132.78,51.14 132.78,50.54 132.82,50.45 132.98,50.29 133.14,50.29 133.29,50.14 133.29,50.05 134.66,48.68 134.71,48.68
  BOTTOM w0.089: RC209.2 182.58,38.78 v1(182.89,38.78) ; v1(145.58,36.83) 145.43,36.97 145.43,38.65 145.35,38.73 145.35,40.98 v2(145.23,41.11) 144.46,41.87 143.34,41.87 142.76,42.45 142.54,42.45 139.41,45.58 138.16,45.58 135.45,48.29 135.45,48.3 135.09,48.3 134.71,48.68
HDMI_CLK: length 157.3
  TOP w0.112: v1(21.37,93.75) 21.37,93.75 21.1,94.02 20.14,94.02 CI2.1
  IN3 w0.076: v1(132.84,82.28) 132.74,82.17 132.74,82.02 132.85,81.91 133.19,81.91 133.28,82 135.05,82 135.44,82.39 135.44,82.93 135.13,83.25 135.13,89.09 133.48,90.74 133.48,92.18 133.44,92.22 133.44,92.24
  IN3 w0.135: v1(21.37,93.75) 21.38,93.75 21.73,94.1 22.33,94.1 22.97,94.74 22.97,95.36 25.66,98.05 25.66,101.7 29.19,105.24 29.19,106.08 31.77,108.66 34.88,108.66 35.59,109.37 40.39,109.37 41.52,110.5 42.22,110.5 44.57,112.85 44.93,112.85 45.49,112.85 46.96,114.32 48.87,114.32 52.05,117.51 53.2,117.51 54.35,118.67 54.85,118.67 55.5,118.01 61.51,118.01 61.82,118.32 65.09,118.32 65.93,119.16 67.49,119.16 68.06,118.58 69.89,118.58 70.38,119.07 72.19,119.07 72.48,118.79 74.42,118.79 75.08,119.46 80.12,119.46 81.37,118.21 86.25,118.21 87.09,117.37 89.42,117.37 95.73,111.06 116.32,111.06 116.91,110.47 117.81,110.47 121.71,106.58 122.36,106.58 125.31,103.63 125.89,103.63 129.45,100.07 129.45,95.4 130.24,94.61 131.07,94.61 133.44,92.24 133.44,92.24
  BOTTOM w0.076: v1(132.84,82.28) 132.84,82 132.75,81.91 UC1.G56
HDMI_CLK#: length 157.3
  TOP w0.112: CI1.1 20.24,94.24 21.28,94.24 v1(21.37,94.34)
  IN3 w0.076: 133.68,92.24 133.68,92.22 133.64,92.18 133.64,90.81 135.29,89.16 135.29,83.32 135.61,83 135.61,82.32 135.11,81.83 133.35,81.83 133.26,81.75 133.04,81.75 v1(132.84,81.55)
  IN3 w0.135: 133.68,92.24 133.68,92.34 131.17,94.85 130.34,94.85 129.69,95.5 129.69,100.17 125.99,103.87 125.41,103.87 122.46,106.82 121.81,106.82 117.91,110.71 117.01,110.71 116.42,111.3 95.83,111.3 89.52,117.61 87.19,117.61 86.35,118.45 81.47,118.45 80.22,119.7 74.98,119.7 74.32,119.03 72.58,119.03 72.29,119.31 70.28,119.31 69.79,118.83 68.16,118.83 67.59,119.4 65.83,119.4 64.99,118.56 61.72,118.56 61.41,118.25 55.6,118.25 54.95,118.91 54.25,118.91 53.1,117.75 51.95,117.75 48.77,114.56 46.86,114.56 45.39,113.09 45.03,113.09 44.47,113.09 42.12,110.74 41.42,110.74 40.29,109.61 35.49,109.61 34.78,108.9 31.67,108.9 28.95,106.18 28.95,105.34 25.41,101.8 25.41,98.15 22.73,95.46 22.73,94.84 22.23,94.34 v1(21.37,94.34)
  BOTTOM w0.076: UC1.F56 132.85,81.59 132.85,81.55 v1(132.84,81.55)
HDMI_CLK#_R: length 4.2
  TOP w0.112: RI2.1 16.98,94.57 LI1.2 17.35,94.4 17.5,94.26 17.74,94.26 v1(17.92,94.44) 18.08,94.29 18.54,94.29 CI1.2
  BOTTOM w0.112: v1(17.92,94.44) 18.06,94.31 18.3,94.31 18.57,94.57 18.98,94.57 19.15,94.74 RPI2.6
HDMI_CLK#_R_C: length 6.8
  TOP w0.112: JHDMI1.12 12.99,97.46 13.32,97.46 13.56,97.22 13.56,95.5 13.79,95.27 v4(13.97,95.09) 14.26,94.8 14.26,94.24 14.37,94.13 14.58,94.13 RI3.1 15.17,94.23 15.49,94.23 15.66,94.4 LI1.1 16.07,94.57 RI2.2
HDMI_CLK_R: length 4.2
  TOP w0.112: CI2.2 18.55,94.07 18.14,94.07 v1(17.92,93.86) 17.75,94.03 17.49,94.03 17.35,93.9 LI1.3 16.98,93.73 RI1.1
  BOTTOM w0.112: v1(17.92,93.86) 18.15,94.08 18.39,94.08 18.66,94.35 19.04,94.35 19.15,94.24 RPI2.5
HDMI_CLK_R_C: length 6.9
  TOP w0.112: RI1.2 16.07,93.73 LI1.4 15.63,93.9 15.52,94.01 15.39,94.01 14.95,93.56 RI3.2 14.58,93.91 14.28,93.91 14.04,94.15 14.04,94.68 13.57,95.14 13.57,95.17 13.34,95.41 13.34,97.13 13.23,97.24 12.99,97.24 JHDMI1.10
HDMI_DATA0: length 155.1
  TOP w0.112: v1(24.29,91.12) 24.05,91.35 23.46,91.35 v4(23.13,91.68) 22.82,91.99 22.29,92.52 22.29,95.19 21.29,96.19 20.63,96.19 20.62,96.21 20.11,96.21 19.83,95.92 CI4.1
  IN3 w0.076: v1(132.69,79.62) 132.87,79.64 132.99,79.78 132.98,79.89 132.87,79.99 132.62,79.99 131.62,80.99 131.62,82.57 127.69,86.49 127.69,90.93 127.69,91.33 126.9,92.13 126.92,92.15 126.92,92.24
  IN3 w0.135: v1(24.29,91.12) 24.31,91.12 24.65,91.46 24.99,91.46 27.82,94.29 27.82,96.5 28.67,97.34 29.59,97.34 34.79,102.55 34.79,103.86 36.38,105.45 41.11,105.45 41.63,105.96 41.63,106.36 42.06,106.79 42.27,106.79 45.96,110.48 48.89,110.48 51.81,113.41 52.85,113.41 54.65,115.2 56.86,115.2 57.37,115.71 66.82,115.71 67.07,115.95 72.01,115.95 72.71,116.65 77.6,116.65 78.34,117.39 79.23,117.39 81.65,114.97 88.49,114.97 95.06,108.4 100.88,108.4 101.32,108.83 104.39,108.83 104.81,108.42 110.85,108.42 111.29,107.98 117.41,107.98 120.97,104.42 121.63,104.42 126.92,99.13 126.92,92.24
  BOTTOM w0.076: v1(132.69,79.62) 132.52,79.79 UC1.G53
HDMI_DATA0#: length 155.1
  TOP w0.112: v1(24.29,91.7) 24.16,91.58 23.57,91.58 23.11,92.04 23.09,92.04 22.51,92.61 22.51,95.28 21.37,96.43 v4(21,96.43) 20.09,96.43 CI3.1
  IN3 w0.076: 127.16,92.24 127.16,92.23 127.11,92.18 127.11,92.14 127.86,91.4 127.86,90.86 127.86,86.56 131.78,82.63 131.78,81.06 132.69,80.16 132.93,80.16 133.14,79.97 133.15,79.77 133.27,79.67 v1(133.47,79.69)
  IN3 w0.135: 127.16,92.24 127.16,99.23 121.73,104.67 121.07,104.67 117.51,108.23 111.39,108.23 110.95,108.66 104.91,108.66 104.49,109.08 101.22,109.08 100.78,108.64 95.16,108.64 88.59,115.22 81.75,115.22 79.33,117.64 78.24,117.64 77.5,116.89 72.61,116.89 71.91,116.19 66.97,116.19 66.72,115.95 57.27,115.95 56.76,115.44 54.54,115.44 52.75,113.65 51.71,113.65 48.79,110.72 45.86,110.72 42.17,107.03 41.96,107.03 41.38,106.46 41.38,106.06 41.01,105.69 36.28,105.69 34.55,103.96 34.55,102.65 29.49,97.58 28.57,97.58 27.58,96.6 27.58,94.39 24.89,91.7 v1(24.29,91.7)
  BOTTOM w0.076: UC1.F53 133.17,79.99 v1(133.47,79.69)
HDMI_DATA0#_R: length 4.4
  TOP w0.112: CI3.2 18.55,96.32 18.07,96.32 v1(17.92,96.47) 17.74,96.29 17.6,96.29 17.47,96.43 LI2.2 16.98,96.6 RI4.1
  BOTTOM w0.112: RPI2.8 19.08,95.74 18.96,95.61 18.87,95.61 18.7,95.79 18.7,95.9 18.32,96.28 18.12,96.28 v1(17.92,96.47)
