# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_MDI0N: length 14.1
  TOP w0.089: UL1.2 23.2,79.75 23,79.55 23,78.68 23.29,78.39 23.29,78.18 23.38,78.09 23.56,78.09 23.65,78 23.65,77.76 v1(23.53,77.65)
  BOTTOM w0.089: v1(23.53,77.65) 23.33,77.85 23.33,77.98 23.48,78.14 24.25,78.14 24.74,77.65 24.74,76.21 27.26,73.68 27.26,72.2 27.17,72.11 27.05,72.11 26.96,72.2 26.96,73.04 26.87,73.13 TL1.9
LAN_MDI0P: length 14.1
  TOP w0.089: UL1.1 22.8,79.71 22.74,79.65 v4(22.74,78.95) 22.74,78.58 23.04,78.29 23.04,77.74 v1(22.95,77.65)
  BOTTOM w0.089: TL1.10 27.36,71.86 27.53,72.03 27.53,73.77 24.99,76.31 24.99,77.76 24.36,78.39 23.38,78.39 23.07,78.09 23.07,77.77 v1(22.95,77.65)
LAN_MDI1N: length 23.5
  TOP w0.089: v1(26.51,76.67) 26.51,76.31 26.6,76.22 26.76,76.22 26.85,76.13 26.85,75.95 26.76,75.86 25.7,75.86 24.25,77.32 v4(24.25,79.07) 24.25,79.62 24.4,79.77 UL1.5
  BOTTOM w0.089: v1(26.51,76.67) 26.45,76.67 26.29,76.51 26.29,76.32 26.38,76.23 26.76,76.23 26.85,76.14 26.85,75.99 29.17,73.67 29.17,68.83 28.37,68.03 28.37,65.97 28.28,65.88 27.58,65.88 27.34,65.65 27.34,65.03 27.25,64.93 27.05,64.93 26.96,65.02 26.96,65.42 26.87,65.51 TL1.15
LAN_MDI1P: length 23.6
  TOP w0.089: v1(27.1,76.67) 27.1,75.85 26.86,75.61 25.6,75.61 24,77.21 UL1.4
  BOTTOM w0.089: TL1.16 26.63,64.24 27.07,64.68 27.35,64.68 27.59,64.92 27.59,65.54 27.68,65.63 28.39,65.63 28.62,65.87 28.62,67.93 29.42,68.73 29.42,73.77 27.1,76.1 v1(27.1,76.67)
LAN_MDI2N: length 20.2
  TOP w0.089: v1(26.16,77.22) 26.11,77.26 26.11,77.7 v4(25.78,78.04) 25.16,78.65 25.16,79.76 25.2,79.79 UL1.7 ; TL2.10 26.74,65.51 26.83,65.42 26.83,65.11 26.92,65.02 27.42,65.02 27.66,64.78 27.66,64.44 v1(27.82,64.28)
  IN3 w0.089: v1(27.82,64.28) 27.7,64.4 27.7,70.13 27.94,70.38 27.94,72.08 27.28,72.75 27.28,75.08 26.11,76.24 26.11,77.17 v1(26.16,77.22)
LAN_MDI2P: length 20.1
  TOP w0.089: v1(27.24,64.28) 27.41,64.45 27.41,64.68 27.32,64.77 26.92,64.77 26.83,64.68 26.83,64.33 26.74,64.24 TL2.9 ; v1(25.58,77.22) 25.6,77.22 25.85,77.46 25.85,77.61 24.91,78.55 24.91,79.73 24.8,79.84 UL1.6
  IN3 w0.089: v1(25.58,77.22) 25.92,76.87 25.92,76.16 27.08,75 27.08,72.67 27.75,72 27.75,70.46 27.51,70.21 27.51,64.55 v1(27.24,64.28)
LAN_MDI3N: length 15.2
  TOP w0.089: v1(27.29,78.77) 27.44,78.62 27.44,78.47 27.3,78.33 27.02,78.33 26.78,78.57 26.78,79.13 27.28,79.62 v4(27.28,79.95) 27.28,80.7 26.72,81.26 UL1.10 ; TL2.16 26.79,73.13 26.88,73.04 26.88,72.45 26.97,72.36 27.18,72.36 27.27,72.45 27.27,73.61 27.5,73.85 27.73,73.85 v1(28.05,74.17)
  IN3 w0.089: v1(27.29,78.77) 27.5,78.56 27.5,78.38 27.3,78.18 27.3,77.11 27.5,76.9 27.5,76.14 28.65,75 28.65,74.2 28.45,74 28.22,74 v1(28.05,74.17)
LAN_MDI3P: length 15.2
  TOP w0.089: v1(28.05,73.59) 28.04,73.59 27.61,73.59 27.52,73.51 27.52,72.28 27.35,72.11 26.8,72.11 26.55,71.86 TL2.15 ; UL1.9 26.76,80.86 27.02,80.6 27.02,79.73 26.53,79.23 26.53,78.47 26.92,78.08 27.41,78.08 27.69,78.36 27.69,78.59 v1(27.87,78.77)
  IN3 w0.089: v1(28.05,73.59) 28.27,73.81 28.53,73.81 28.84,74.12 28.84,75.08 27.69,76.22 27.69,76.98 27.49,77.19 27.49,78.1 27.69,78.3 27.69,78.6 v1(27.87,78.77)
LANWAKE#: length 117.3
  TOP w0.089: v2(63.56,41.21) v1(64.14,41.79) ; RC214.1 120.26,58.01 v1(119.94,57.69) ; v1(49.84,70.14) 51.32,70.14 UE1.35
  IN1 w0.089: v1(64.14,41.79) 64.14,41.54 64.94,40.74 70.47,40.74 71.82,39.39 72.82,39.39 73.16,39.05 75.61,39.05 76.29,38.37 83.14,38.37 83.87,39.11 85.61,39.11 86.12,39.62 91.45,39.62 92.07,39 96.59,39 97.09,38.51 98.43,38.51 99.11,37.83 102.64,37.83 103.51,36.95 v1(103.51,36.86)
  IN2 w0.089: v1(64.14,41.79) 64.04,41.79 63.62,41.37 61.55,41.37 59.43,43.49 59.43,43.81 57.36,45.88 56.14,45.88 55.51,46.52 v1(55.51,47.26)
  IN3 w0.076: v1(119.94,57.69) 120.12,57.87 120.81,57.87 121.14,57.54 121.14,55.39 119.66,53.91 119.66,51.88 117.63,49.86 114.44,49.86 113.86,49.28 112.28,49.28 111.88,48.88 111.88,48.68
  IN3 w0.089: v1(103.51,36.86) 103.51,37.17 103.6,37.26 103.63,37.26 105.62,39.24 107.86,39.24 108.44,39.81 108.44,42.81 109.98,44.36 109.98,45.15 111.54,46.7 111.54,48.34 111.88,48.68 ; v1(49.84,70.14) 49.99,70.14 50.45,69.68 50.45,69.43 51.3,68.59 51.3,62.97 51.52,62.75 51.52,61.2 51.26,60.94 51.26,59.14 52.2,58.2 52.2,57.23 53.06,56.37 53.06,52.67 54.18,51.54 54.18,49.07 55.51,47.75 v1(55.51,47.26)
  BOTTOM w0.102: UC1.AM15 120.29,58.04 v1(119.94,57.69)
LANXIN: length 2.4
  TOP w0.102: UL1.28 21.87,82.46
  TOP w0.112: RL8.2 20.11,82.13 21.12,82.13 21.45,82.46 21.87,82.46
LANXIN_R: length 4.8
  TOP w0.112: CL10.2 19.89,83.14 RL8.1 18.62,81.87 17.15,81.87 YL1.1
LANXOUT: length 2.4
  TOP w0.112: UL1.29 21.43,82.06 21.23,81.86 20.37,81.86 RL9.2
LANXOUT_R: length 2.9
  TOP w0.112: YL1.3 18.41,81.25 18.89,81.25 CL11.2 20,80.63 RL9.1
LCD_BRIGHTNESS: length 58.9
  TOP w0.089: v1(214.45,47.07) 214.76,46.76 v2(215.36,46.76) 215.57,46.97 R80.2 ; RP2.2 176.52,68.93 176.88,68.57 176.88,67.71 v1(176.57,67.4)
  IN1 w0.102: v1(176.57,67.4) 176.86,67.69 176.86,68.3 177.06,68.5 177.41,68.5 179.47,66.44 180.04,66.44 183.52,62.95 190.26,62.95 191.2,62.02 191.2,61.38 192.14,60.45 193.67,60.45 196.65,57.46 202.79,57.46 203.25,57.01 208.71,57.01 209.09,57.38 212.04,57.38 212.06,57.36 214.03,57.36 214.32,57.07 214.32,51.21 214.15,51.04 214.15,48.21 213.61,47.68 213.61,47.29 213.83,47.07 v1(214.45,47.07)
LCD_BRIGHTNESS_R: length 3.3
  TOP w0.089: v2(213.66,47.18) 213.21,47.63 v1(213.21,47.7) 213.64,47.7 213.87,47.93 214.44,47.93 R80.1
  BOTTOM w0.089: JEDP1.27 212.96,47.45 v1(213.21,47.7)
LCD_CBL_DET#: length 130.5
  TOP w0.089: v1(211.39,53.95) v2(211.39,54.52)
  IN2 w0.089: v1(211.39,53.95) 210.89,53.45 210.89,51.33 210.11,50.54 210.11,48.02 209.61,47.53 209.61,44.35 210.95,43.01 210.95,42.38 209.72,41.15 209.72,37.94 207.88,36.1 206.47,36.1 205.73,35.36 201.77,35.36 201.55,35.14 199.24,35.14 197.92,36.46 194.65,36.46 194.21,36.02 192.2,36.02 191.89,36.33 186.57,36.33 185.98,35.73 181.93,35.73 181.19,34.99 179.34,34.99 177.13,32.78 172.54,32.78 172.29,33.03 165.73,33.03 164.89,32.19 164.43,32.19 163.85,31.61 157.51,31.61 157.36,31.76 155.58,31.76 155.35,31.54 151.6,31.54 150.45,32.68 150.45,33.9 150.32,34.03 146.12,34.03 146.04,33.95 144.38,33.95 143.65,34.67 134.54,34.67 133.43,33.56 v1(130.36,33.56)
  BOTTOM w0.076: UC1.W4 126.06,51.6 126.06,50.34 125.99,50.1 125.99,49.69 126.28,49.4 126.28,48.95 126.37,48.85 126.37,48.68
  BOTTOM w0.089: v1(130.36,33.56) 129.71,33.56 127.95,35.33 126.76,35.33 125.05,37.03 125.05,38.43 126.69,40.06 126.69,42.54 126.91,42.76 126.91,43.98 127.11,44.18 127.43,44.18 127.78,44.53 128.33,44.53 128.34,44.55 128.37,44.55 128.58,44.77 128.58,45.32 128.33,45.58 128.33,45.86 127.86,46.33 RC205.1 126.37,47.93 126.37,48.68
  BOTTOM w0.102: v1(211.39,53.95) JEDP1.14
LCD_TST: length 329.7
  TOP w0.089: v1(120.51,24.98) v2(121.07,24.98)
  TOP w0.102: D3.3 175.08,72.84 v1(175.08,71.15) 175.08,71.06 RP2.6 ; v1(45.71,71.3) 45.91,71.3 46.95,70.26 46.95,69.1 47.35,68.71 UE1.26
  IN1 w0.089: v1(45.71,71.3) 43.09,73.92 36.64,73.92 36.29,73.58 36.29,71.12 v1(33.77,68.6) ; v1(120.51,24.98) 120.86,25.33 121.69,25.33 121.8,25.44 130.3,25.44 130.89,24.85 136.04,24.85 140.59,29.41 143.11,29.41 146.17,26.34 148.97,26.34 150.42,27.8 152.36,27.8 152.64,28.08 154.82,28.08 155.94,29.19 157.74,29.19 159.61,31.06 173.57,31.06 174.24,31.73 180.95,31.73 181.73,32.52 187.45,32.52 187.74,32.23 195.34,32.23 196.4,31.18 209.45,31.18 213.44,35.16 214.42,35.16 216.91,37.66 216.91,38.64 219.42,41.15 219.42,46.76 220.09,47.43 220.09,54.92 218.46,56.55 215.65,56.55 214.27,57.93 212.3,57.93 212.27,57.95 208.85,57.95 208.48,57.57 203.49,57.57 203.03,58.03 196.89,58.03 193.9,61.02 192.36,61.02 191.77,61.62 191.77,62.25 190.49,63.52 183.75,63.52 180.26,67.02 179.74,67.02 176.54,70.23 176,70.23 v1(175.08,71.15)
  IN2 w0.089: v1(33.77,68.6) 33.37,68.2 33.37,66.79 34.11,66.05 35.73,66.05 36.02,65.77 36.02,63.35 38.42,60.94 42.25,60.94 43.09,60.1 43.09,57.67 42.2,56.78 42.2,47.25 40.98,46.02 40.98,41.43 v1(41.17,41.23)
  BOTTOM w0.089: v1(120.51,24.98) 120.12,25.37 118.04,25.37 117.52,24.84 115.05,24.84 115.01,24.87 100.38,24.87 99.47,23.97 64.35,23.97 62.79,25.53 58.8,25.53 56.86,27.47 56.86,30.48 53.38,33.96 47.16,33.96 43.2,37.92 41.75,37.92 41.31,38.35 41.31,39.06 41.92,39.67 41.92,41.03 41.6,41.34 41.28,41.34 v1(41.17,41.23)
LCD_TST_C: length 45.1
  TOP w0.102: RP2.3 177.25,68.89 v1(177.25,68.12)
  IN1 w0.102: v1(177.25,68.12) 179.13,66.24 179.95,66.24 183.44,62.76 190.18,62.76 191,61.93 191,61.3 192.06,60.25 193.59,60.25 196.57,57.27 202.71,57.27 203.17,56.81 208.79,56.81 209.17,57.19 211.9,57.19 213.33,55.76 v1(213.33,55.7)
  BOTTOM w0.089: v1(177.25,68.12) 177.25,67.42 v2(177.22,67.39)
  BOTTOM w0.102: JEDP1.10 213.08,55.95 v1(213.33,55.7)
LCD_VCC_TEST_EN: length 187.6
  TOP w0.089: UE1.113 37.67,75.41 v1(38.18,75.91) ; v1(166.44,28.7) 166.44,28.27 166.63,28.08 D4.3 167.86,27.53 v2(168.99,27.53)
  IN1 w0.089: v1(41,64.54) 37.31,64.54 36.9,64.13 36.37,64.13 36.1,64.4 36.1,65.63 35.74,65.99 34.45,65.99 33.37,67.07 33.37,68.78 35.91,71.32 35.91,74.71 37.11,75.91 v1(38.18,75.91)
  IN2 w0.089: v1(166.44,28.7) 163.7,28.7 162.96,27.96 156.1,27.96 156.02,28.04 148.3,28.04 145.31,31.03 144.44,31.03 143.51,31.97 138.84,31.97 136.64,29.77 129.9,29.77 129.8,29.87 117.46,29.87 116.53,28.94 114.34,28.94 113.21,27.8 104.96,27.8 104.2,27.04 99.56,27.04 98.99,26.46 97.86,26.46 97.26,27.06 94.56,27.06 94.05,26.54 76.25,26.54 75.51,27.28 60.27,27.28 59.38,28.16 59.38,30.23 57.4,32.22 57.11,32.22 54.9,34.42 51.77,34.42 45.18,41.02 45.18,42.3 43.47,44.01 43.47,44.96 43.93,45.42 43.93,53.73 45.02,54.83 45.02,59.5 42.36,62.16 41.38,62.16 40.93,62.61 40.93,64.46 v1(41,64.54)
LCDVDD_EN: length 81.4
  TOP w0.089: R10.1 166.61,31.78 166.34,31.52 D4.1 165.49,29.32 164.83,29.32 v2(163.81,28.3)
  TOP w0.102: R10.1 167.19,31.22 167.19,29.72 v1(168.19,28.72)
  IN1 w0.089: v1(168.19,28.72) 168.72,29.24 172.85,29.24 173.35,28.75 176.85,28.75 177.27,28.33 179.29,28.33 179.98,29.02 179.98,30.16 181.94,32.11 181.95,32.11 181.99,32.15 184.66,32.15 185.34,31.47 193.04,31.47 193.51,31 209.88,31 212.26,33.38 v1(213.42,33.38)
  IN2 w0.089: v1(213.42,33.38) 214.5,33.38 214.88,33.76 214.88,39.48 215.23,39.83 215.23,43.97 212.74,46.45 212.74,46.89 212.24,47.39 212.24,49.21 211.66,49.8 v1(210.54,49.8)
  BOTTOM w0.102: U1.4 208.51,50.08 208.79,49.8 v1(210.54,49.8)
LDO1_CAP: length 5.1
  TOP w0.203: CA20.2 21.31,15.15 22.2,15.15 v2(22.54,14.8) 22.69,14.65 UA1.27
  TOP w0.254: CA20.2 20.43,15.86 RA41.2
LDO2_CAP: length 6.5
  TOP w0.203: CA21.2 22.12,8.21 22.26,8.21 22.64,7.83 24.34,7.83 25.13,8.62 v2(25.13,8.9) 25.21,8.98 25.21,9.49 25.34,9.61 UA1.39
LDO3_CAP: length 2.7
  TOP w0.203: UA1.7 30.43,13.45 30.66,13.68 v2(30.9,13.68)
  TOP w0.305: CA22.2 32.03,12.97 31.32,13.68 v2(30.9,13.68)
LED0: length 1.4
  TOP w0.102: UL1.27 21.29,82.86 T47.1
LED1: length 3.1
  TOP w0.089: T45.1 19.76,84.12 20.29,83.59 21.15,83.59 21.23,83.66 UL1.25
LG1_CHG: length 10.4
  TOP w0.089: v2(194.2,48.36) 193.73,47.88 v1(193.4,47.88)
  IN3 w0.762: 200.21,43.77 198.94,43.77 198.69,43.52 196.65,43.52 194.34,45.83 194.34,46.94 v1(193.4,47.88)
  vias: v1(202.03,43.98)
LG1_VGA: length 6.1
  TOP w0.089: v1(84.48,127.94) v2(83.66,127.94)
  IN3 w0.762: 78.6,128.94 80.81,128.94 81.58,128.17 83.52,128.17
  vias: v1(77.88,128.86) v1(84.48,128.52) v1(89.66,128.37) v1(89.66,127.78)
LG2_CHG: length 3.7
  TOP w0.089: v1(198.41,42.41) 197.11,42.41 v2(196.57,42.96)
  IN3 w0.762: 199.87,42.59 201.46,42.59
  vias: v1(198.95,42.65) v1(202.28,42.91) v1(202.87,42.92)
LG2_VGA: length 5.9
  IN3 w0.762: 83.4,131.84 81.59,130.03 78.95,130.03
  BOTTOM w0.089: v1(89.72,131.44) v2(90.45,131.44)
  vias: v1(77.91,129.99) v1(84.57,132.09) v1(84.57,131.5) v1(89.72,132.02)
LG_1.2V: length 3.7
  IN3 w0.635: v1(44.01,24.53) 40.95,24.53 v1(40.5,24.99)
  vias: v2(39.53,25.71)
LG_VCCSA: length 6.8
  TOP w0.089: v1(157.97,57.92) v2(157.97,56.93)
  IN1 w0.508: v1(163.13,57.51) 162.11,58.53 158.58,58.53 v1(157.97,57.92)
LID_CL_SIO#: length 333.7
  TOP w0.089: 215.98,40.36 217.52,40.36 218.19,39.68 v1(220.57,39.68) ; v2(51.95,84.87) 51.95,85.45 51.74,85.66
  TOP w0.102: R22.1 219.92,67.42 v1(219.63,67.71) ; D5.1 215.98,40.36 ; U4.2 v1(42.12,96.04) ; v2(51.95,84.87) 51.81,84.73 49.78,84.73 49.35,84.3 UE1.66 ; v1(52.68,85.59) 52.58,85.69 RE25.2 52.52,86.26 CE19.1 51.74,85.66
  IN1 w0.102: v1(52.68,85.59) 52.73,85.54 52.73,85 50.82,83.09 48.56,83.09 48.04,83.61 37.42,83.61 36.01,85.02 v1(34.86,85.02)
  IN2 w0.089: v1(34.86,85.02) 35.25,84.63 35.25,83.61 34.74,83.1 34.74,78.66 34.1,78.01 34.1,76.69 33.72,76.32 33.72,74.25 34.49,73.48 34.49,67.2 34.91,66.78 36.16,66.78 36.31,66.93 40.03,66.93 40.75,66.21 40.75,65.59 41.39,64.96 41.39,64.08 42.33,63.14 42.33,62.45 45.21,59.57 45.21,54.75 44.84,54.39 44.11,53.66 44.11,45.34 43.65,44.88 43.65,44.08 45.36,42.38 45.36,41.1 51.85,34.61 55.08,34.61 57.25,32.44 57.53,32.44 59.57,30.4 59.57,28.24 60.34,27.46 75.59,27.46 76.33,26.73 93.97,26.73 94.49,27.24 97.35,27.24 97.91,26.68 98.94,26.68 99.48,27.22 104.12,27.22 104.89,27.99 113.14,27.99 114.27,29.12 116.45,29.12 117.38,30.05 129.87,30.05 129.97,29.95 136.56,29.95 138.85,32.24 143.5,32.24 144.52,31.22 145.39,31.22 148.31,28.3 155.31,28.3 155.94,28.94 166.08,28.94 166.29,29.15 168.45,29.15 168.81,28.8 169.85,28.8 170.4,28.25 174.54,28.25 175.32,29.03 177.62,29.03 178.33,29.74 179.14,29.74 181.08,31.68 184.63,31.68 185.63,30.68 213.63,30.68 216.02,33.08 216.02,37.86 217.52,39.37 220.25,39.37 v1(220.57,39.68)
  IN3 w0.102: v1(34.86,85.02) 36.36,85.02 37.33,86 39.15,86 40.59,87.44 40.59,87.96 42.07,89.44 42.07,92.5 42.63,93.06 42.63,95.53 v1(42.12,96.04)
  BOTTOM w0.102: v1(220.57,39.68) 220,40.25 220,53.45 224.7,58.15 224.7,64.15 223.11,65.74 221.6,65.74 v1(219.63,67.71)
LID_CLOSE#: length 7.4
  TOP w0.089: v1(223.24,64.5) 223.94,64.5 224.16,64.73 224.16,65.59 223.72,66.04 v3(222.08,66.04) EC2902.1 R22.2
  BOTTOM w0.089: v1(223.24,64.5) 223.24,63.42 JPWR2.5
LIMT_+1.35VGPU: length 5.6
  TOP w0.089: v2(147.96,112.72) 146.48,111.23 PRW03.2
  TOP w0.254: v1(145.72,110.94) 145.92,111.15 PRW03.2
  BOTTOM w0.254: PUW01.12 144.25,110.36 144.84,110.95 144.84,111.19 145.09,111.45 PRW04.1 145.21,111.45 v1(145.72,110.94)
LINE1-L_C: length 1
  TOP w0.305: RA28.1 21.82,19.94 21.82,19.22 CA32.2
LINE1-L_R: length 1.2
  TOP w0.305: CA33.2 22.61,19.7 RA32.1
LINE1_L: length 4.1
  TOP w0.203: CA32.1 22.31,17.33 22.44,17.33 22.79,16.98 25.09,16.98 25.34,16.73 UA1.22
LINE1_R: length 3.3
  TOP w0.203: UA1.21 25.74,16.76 25.11,17.38 24.62,17.38 v2(24.51,17.5) 24.37,17.63 CA33.1
LM393_P: length 310.9
  TOP w0.127: v1(39.9,100.06) 39.9,99.67 v2(39.43,99.2)
  TOP w0.254: PC21.1 92.72,147.54 92.08,148.17 PR21.1 ; PC21.1 91.73,146.53 v1(90.75,146.53) ; PC21.1 93.37,147.52 93.58,147.73 PU2.5 ; v1(167.72,32.6) 167.72,32.96 166.97,33.71 PUB02.5 166.97,34.43 167.23,34.69 167.44,34.69 167.5,34.75 PCB44.2 168.04,34.76 168.04,35.5 168.04,35.5 PRB37.2 ; PRS43.1 53.64,123.53 53.36,123.25 53.36,121.33 v1(53.62,121.08) 53.69,121 PDS01.1 54.73,120.58 PCS01.2 53.55,119.4 53.55,117.95 54.2,117.31 54.2,116.14 53.97,115.91 PUS01.8
  IN2 w0.089: v1(39.9,100.06) 38.46,98.62 38.46,96.26 37.02,94.82 37.02,92.37 35.9,91.25 35.9,89.23 35.53,88.85 35.53,88.44 35.1,88.01 35.1,86.78 35.81,86.06 35.81,85.19 38.69,82.31 38.69,78.77 38.91,78.54 38.91,77.3 41.19,75.02 41.19,71.89 41.18,71.87 41.18,69.15 44.27,66.06 44.27,62.32 46.49,60.1 46.49,54.22 45.4,53.13 45.4,50.49 45.97,49.91 45.97,48.13 45.56,47.72 45.56,43.99 48.07,41.48 48.07,40.2 52.38,35.89 56.11,35.89 63.05,28.95 66.92,28.95 67.78,29.81 70.15,29.81 70.52,29.43 75.95,29.43 77.01,28.37 92.83,28.37 93.99,29.53 96.6,29.53 97.24,28.89 102.72,28.89 104.24,30.41 107.62,30.41 107.78,30.25 112.36,30.25 112.89,30.78 115.67,30.78 116.58,31.7 131.95,31.7 134.74,34.49 143.58,34.49 145.2,32.86 146.11,32.86 147.84,31.13 155.23,31.13 155.69,31.58 157.28,31.58 157.44,31.42 163.92,31.42 164.5,32.01 166.87,32.01 167.46,32.6 v1(167.72,32.6)
  IN3 w0.254: v1(53.62,121.08) 54.4,120.3 60.34,120.3 61.34,121.29 61.34,122.62 62.48,123.76 62.48,124.63 64.15,126.31 64.84,126.31 65.16,126.62 65.16,127.53 63.84,128.84 63.84,136.03 65.85,138.04 70.14,138.04 73.29,141.18 75.23,141.18 75.93,141.88 75.93,144.32 78.25,146.64 82.94,146.64 83.87,147.58 85.78,147.58 86.53,146.83 87.32,146.83 87.62,146.53 v1(90.75,146.53)
  BOTTOM w0.089: v1(53.62,121.08) 52.56,121.08 52.05,120.57 50.36,120.57 47.15,117.36 46.19,117.36 43.9,115.07 43.9,110.21 43.18,109.49 43.18,103.03 42.66,102.51 42.66,101.56 42.12,101.02 40.23,101.02 39.9,100.69 v1(39.9,100.06)
  BOTTOM w0.254: PR50.1 91.5,146.53 v1(90.75,146.53)
LOM_CABLE_DETECT: length 45.9
  TOP w0.089: v1(19.17,84.36) 18.66,84.87 v2(18.45,84.87) ; UE1.41 50.41,72.61 50.18,72.38 48.79,72.38 48.27,72.89 46.85,72.89 46.08,73.66 37.99,73.66 v1(37.78,73.44)
  IN3 w0.089: v1(37.78,73.44) 36.57,74.65 36.57,75.79 36.18,76.18 34.19,76.18 32.45,77.92 31.47,77.92 29.6,79.79 27.49,79.79 26.39,78.69 26.39,78.51 25.93,78.05 20.95,78.05 19.47,79.53 19.47,84.07 v1(19.17,84.36)
  BOTTOM w0.089: v1(19.17,84.36) 20.04,83.5 20.8,83.5 RL21.2
LOM_TCT: length 14.7
  TOP w0.508: TL2.14 26.89,70.59 v1(28.1,69.38) v2(28.1,68.41) 28.1,67.75 27.13,66.78 TL2.11
  BOTTOM w0.508: TL2.14 26.67,70.59 27,70.26 28.09,70.26 CL12.1 v1(28.1,69.38) 27.31,68.58 27.31,67.28 26.81,66.78 TL2.11
LX1_CHG: length 16.1
  TOP w0.089: PRB17.1 v2(187.04,54.17)
  IN3 w0.762: v1(193.66,50.91) 195.24,52.48 199.03,52.48 199.54,51.98 199.54,45.61 200.31,44.84
  vias: v1(190.25,54.08) v1(201.07,44.62)
LX1_VGA: length 11.3
  IN3 w0.762: 78.61,128.01 80.22,126.4 83.86,126.4 84.89,125.37 88.77,125.37
  vias: v1(77.88,128.2) v1(89.45,127.16) v1(89.45,126.42) v1(89.45,125.81) v1(89.45,125.2) v1(90.06,127.16) v1(90.06,126.42) v1(90.23,124.34) v1(90.65,127.19) v1(90.65,126.45) v1(90.81,124.34) v1(91.4,124.34) v1(91.98,124.34) v1(92.19,124.95) v1(92.57,124.34) v1(92.95,124.95) v1(93.34,125.41) v1(94.74,126.45) v1(94.94,127.02) v1(95.4,126.5) v1(95.53,127.07) v1(95.79,127.8) v1(95.77,125.97) v1(96.12,127.16) v1(96.12,126.55) v1(96.38,127.8) v1(96.35,125.97) v1(96.71,127.16) v1(96.71,126.55) v1(96.94,125.97) v1(96.96,127.8) v1(97.29,127.16) v1(97.29,126.55) v3(93.61,126.22)
LX2_CHG: length 0.9
  TOP w0.089: v1(191.68,43.18) v2(191.68,42.32)
LX2_VGA: length 12.8
  IN3 w0.762: 78.71,130.93 80.5,130.93 82.18,132.61 82.18,133.47 83.31,134.6 89.21,134.6 89.38,134.77
  vias: v1(77.84,130.58) v1(89.43,135.43) v1(89.53,133.45) v1(89.81,132.84) v1(89.89,136.01) v1(90.04,135.43) v1(90.14,133.45) v1(90.42,132.84) v1(90.5,136.01) v1(90.65,135.43) v1(90.75,133.45) v1(91.03,132.84) v1(91.11,136.01) v1(91.26,135.43) v1(91.64,132.84) v1(91.72,136.01) v1(91.87,135.43) v1(92.32,136.01) v1(93.01,136.08) v1(93.44,136.51) v1(93.44,135.65) v1(93.87,136.08) v1(93.87,135.22) v1(94.31,135.65) v3(93.25,133.79)
LX_1.2V: length 6.1
  IN3 w0.635: v1(40.66,25.93) 46.58,25.93 v1(46.72,25.79)
  vias: v1(47.07,28.89) v2(47,29.73)
LX_1.8VALW: length 3.1
  TOP w0.089: v1(162.7,45.32) v2(161.86,45.32)
  TOP w0.508: PR1804.1 163.53,46.16 v1(162.7,45.32)
LX_3V: length 6.4
  TOP w0.089: v2(26.62,45.52) PR305.1
  TOP w0.508: PR305.1 v1(26.62,42.23)
  BOTTOM w0.254: PU301.6 18.79,42.14 18.84,42.18 20.91,42.18 20.96,42.14 PU301.20
LX_5V: length 7.7
  TOP w0.089: v2(20.75,97.9) PR505.1
  TOP w0.508: PR505.1 v1(22.13,99.48)
  BOTTOM w0.203: 24.79,98 26.62,98 26.69,98.07 PU501.6
  BOTTOM w0.508: 22.36,101.82 22.36,102.64 23.19,103.46 PC507.2
LX_+1.35VGPU: length 2.6
  TOP w0.089: v2(148.47,111.44) 147.78,110.75 PRW07.1
  TOP w0.508: PCW12.2 v1(148.73,108.23)
  vias: v1(148.85,110.11) v1(148.85,109.48)
LX_+1VALW: length 3.2
  TOP w0.127: v3(156.6,53) PRH07.1
  TOP w0.508: PRH07.1 159.25,53 v1(159.67,52.57)
  vias: v1(160.34,51.16) v1(160.34,50.52) v1(160.34,49.83)
LX_VCCSA: length 2.7
  TOP w0.089: PRA02.1 v2(155.75,63.05)
  TOP w0.508: v1(163.05,59.14) PCA07.2
  vias: v1(157.48,61.26) v1(157.48,60.62) v1(157.48,59.99)
LX_VCORE1: length 3.2
  TOP w0.089: v1(158.28,66.67) v2(158.28,67.45)
  TOP w0.508: v1(158.28,66.67) 156.9,65.29 PRI03.1
LX_VCORE2:
  vias: v1(155.45,88.56) v1(155.45,87.74) v2(156.07,88.1)
LX_VGT1: length 2.1
  TOP w0.089: v2(151.42,89.8) 152.12,90.5 PRG03.1
  vias: v1(151.8,93.51)
M0_MA0: length 31.4
  TOP w0.102: 147.55,138.35 148.17,138.97 148.17,139.81 148.87,140.51 153.32,140.51 153.83,139.99 153.83,139.28 v1(153.99,139.13)
  TOP w0.127: v1(153.99,139.13) 154.31,138.8 UV12.H4 ; 136.52,135.75 135.96,135.75 135.44,135.23 133.42,135.23 133.16,135.48 132.13,135.48 131.97,135.32 131.04,135.32 130.91,135.44 v1(130.91,135.69)
  TOP w0.14: 147.55,138.35 146.39,138.35 v2(145.99,137.95) 143.79,135.75 136.52,135.75
  BOTTOM w0.127: v1(153.99,139.13) 154.31,138.8 UV12.H4 ; UV1.K17 129.22,134 129.59,134.37 129.93,134.37 130.17,134.6 130.17,135.35 130.51,135.69 v1(130.91,135.69)
M0_MA1: length 30.7
  TOP w0.102: 147.36,138.83 147.97,139.44 147.97,139.9 148.78,140.71 153.63,140.71 v1(154.17,140.18)
  TOP w0.127: v1(154.17,140.18) 154.31,140.04 UV12.H5 ; v1(130.91,136.83) 131.19,136.83 131.32,136.71 131.32,135.78 131.55,135.55 131.87,135.55 132.04,135.71 133.25,135.71 133.51,135.45 135.29,135.45 136.06,136.23 136.51,136.23
  TOP w0.14: 136.51,136.23 v2(141.72,136.23) 143.51,136.23 146.11,138.83 147.36,138.83
  BOTTOM w0.127: v1(130.91,136.83) 130.97,136.77 130.97,136.29 130.72,136.03 130.39,136.03 130.02,136.4 UV1.J20 ; UV12.H5 154.31,140.04 v1(154.17,140.18)
M0_MA2: length 29.9
  TOP w0.102: v1(154.71,143.93) 154.71,142.98 154.07,142.34 148.45,142.34 148.21,142.57
  TOP w0.127: 147.36,143.17 147.61,143.17 148.21,142.57 ; v1(130.34,138.1) 130.34,138.36 131.81,139.83 133.09,139.83 134.7,141.44 135.31,141.44 ; UV12.H11 154.31,144.33 v1(154.71,143.93)
  TOP w0.14: 135.31,141.44 v2(139.3,141.44) 141.74,141.44 143.47,143.17 147.36,143.17
  BOTTOM w0.127: UV12.H11 154.31,144.33 v1(154.71,143.93) ; UV1.H23 130.54,138.54 130.34,138.34 v1(130.34,138.1)
M0_MA3: length 29.4
  TOP w0.102: 147.76,143.5 148.72,142.54 153.64,142.54 v1(154.03,142.93)
  TOP w0.127: v1(154.03,142.93) 154.31,143.21 UV12.H10 ; v1(131.03,139.77) 131.27,139.77 132.37,140.87 133.45,140.87 133.72,141.14 133.72,141.94 133.78,142 133.78,142.42 133.95,142.59 135.03,142.59
  TOP w0.14: 147.76,143.5 147.58,143.68 143.3,143.68 143.28,143.65 143.27,143.65 v2(142.4,142.78) 141.54,141.93 139.04,141.93 138.38,142.59 135.86,142.59 135.78,142.51 135.11,142.51 135.03,142.59
  BOTTOM w0.127: v1(154.03,142.93) 154.31,143.21 UV12.H10 ; v1(131.03,139.77) 130.86,139.59 130.86,139.08 UV1.G23
M0_MA4: length 29.7
  TOP w0.102: v1(156.29,143.93) 156.31,143.91 156.31,142.2 156.04,141.93 148.04,141.93 147.76,142.21 147.36,142.21
  TOP w0.127: UV12.K11 155.91,144.33 156.29,143.95 v1(156.29,143.93) ; v1(131.8,138.94) 131.8,139.17 132,139.38 133.6,139.38 134.65,140.43 135.1,140.43
  TOP w0.14: 147.36,142.21 144.5,142.21 142.71,140.42 v2(141.54,140.42) 137.77,140.42 137.76,140.43 137.41,140.43 137.39,140.42 135.11,140.42 135.1,140.43
  BOTTOM w0.127: UV1.G24 v1(131.8,138.94) ; v1(156.29,143.93) 155.91,144.31 UV12.K11
M0_MA5: length 30.8
  TOP w0.102: v1(155.91,142.96) 155.91,142.81 155.24,142.14 148.12,142.14 147.57,142.69 147.36,142.69
  TOP w0.127: v1(155.91,142.96) 155.91,142.96 UV12.K10 ; 135.17,140.96 134.73,140.96 133.37,139.6 131.91,139.6 131.4,139.1 131.4,138.56 v1(131.74,138.23)
  TOP w0.14: 147.36,142.69 v2(144.84,142.69) 144.31,142.69 142.58,140.96 135.17,140.96
  BOTTOM w0.127: UV12.K10 155.91,142.96 v1(155.91,142.96) ; UV1.H24 130.54,139.16 130.55,139.15 130.55,139.04 130.91,138.67 130.91,138.55 131.23,138.23 v1(131.74,138.23)
M0_MA6: length 31.5
  TOP w0.102: 136.22,137.85 135.2,136.83 133.27,136.83 132.87,137.23 132.28,137.23 131.97,137.54 131.2,137.54 130.88,137.21 130.76,137.21 130.53,136.99 130.53,136.32 v1(130.02,135.82) ; v1(155.9,140.09) 155.9,140.1 154.68,141.32 148.38,141.32 148.23,141.17
  TOP w0.127: UV12.K5 155.91,139.53 155.91,140.08 v1(155.9,140.09) ; 148.23,141.17 147.6,140.54
  TOP w0.14: 136.22,137.85 136.6,138.23 v2(141.54,138.23) 143.01,138.23 145.32,140.54 147.6,140.54
  BOTTOM w0.127: UV12.K5 155.91,140.08 v1(155.9,140.09) ; UV1.J19 129.74,135.53 v1(130.02,135.82)
M0_MA7: length 34
  TOP w0.102: 147.56,140.06 148.62,141.12 154.05,141.12 154.16,141.01 154.39,141.01 155.51,139.89 v1(155.51,139.13)
  TOP w0.127: UV12.K4 155.91,138.73 v1(155.51,139.13) ; v1(131.85,136.59) 132.2,136.93 132.86,136.93 133.88,135.91 134.99,135.91 136.11,137.19 136.38,137.19
  TOP w0.14: 136.38,137.19 136.78,137.6 143.05,137.6 v2(144.89,139.43) 145.52,140.06 147.56,140.06
  BOTTOM w0.102: v1(131.85,136.59) 131.66,136.78 131.51,136.78 131.29,136.99 131.29,136.99 131.28,137 131.2,137.09 131.2,137.09 131.07,137.21 130.76,137.21 130.63,137.09 130.44,137.09 130.23,137.29 129.94,137.29 129.89,137.24 129.87,137.24 129.7,137.07 129.7,136.96 129.34,136.6 129.34,136.29 129.52,136.11 129.52,135.75 129.38,135.62 129.38,135.3 129.28,135.2 UV1.K19
  BOTTOM w0.127: v1(155.51,139.13) 155.91,138.73 UV12.K4
M0_MA8: length 29.9
  TOP w0.102: v1(154.79,140.07) 154.79,140.09 153.97,140.92 148.7,140.92 147.77,139.98 147.77,139.96 147.39,139.58
  TOP w0.127: UV12.J5 155.11,139.75 v1(154.79,140.07) ; 136.38,136.71 136.22,136.71 135.19,135.68 133.6,135.68 133.35,135.94 v1(131.71,135.94)
  TOP w0.14: 147.39,139.58 145.71,139.58 145.22,139.09 145.22,138.89 145.22,138.89 145.22,138.69 145.02,138.49 144.83,138.49 144.82,138.49 144.63,138.49 144.43,138.3 144.43,138.1 144.43,138.1 144.43,137.9 144.23,137.7 144.04,137.7 144.03,137.7 143.84,137.7 143.64,137.51 143.64,137.35 v2(143.64,137.35) 143.64,137.11 143.44,136.91 143.25,136.91 143.24,136.91 143.05,136.91 142.84,136.71 141.94,136.71 141.8,136.85 141.8,136.88 141.66,137.02 141.38,137.02 141.24,136.88 141.24,136.85 141.1,136.71 140.82,136.71 140.68,136.85 140.68,136.88 140.54,137.02 140.26,137.02 140.12,136.88 140.12,136.85 139.98,136.71 139.71,136.71 139.57,136.85 139.57,136.88 139.43,137.02 139.15,137.02 139.01,136.88 139.01,136.85 138.88,136.71 138.6,136.71 138.46,136.85 138.46,136.88 138.32,137.02 138.04,137.02 137.9,136.88 137.9,136.85 137.76,136.71 137.48,136.71 137.34,136.85 137.34,136.88 137.2,137.02 136.92,137.02 136.78,136.88 136.78,136.85 136.64,136.71 136.38,136.71
  BOTTOM w0.127: v1(154.79,140.07) 155.11,139.75 UV12.J5 ; v1(131.71,135.94) 131.54,135.94 131.34,136.14 UV1.G20
M1_MA0: length 35.5
  TOP w0.102: 147.53,124.09 147.83,124.09 148.24,124.51 155.48,124.51 156.64,125.66 156.64,126.04 156.32,126.36 156.32,126.82 v1(156.23,126.91)
  TOP w0.127: v1(129.11,131.09) 129.11,131.13 129.4,131.42 130.53,131.42 130.79,131.16 130.79,130.74 131.02,130.51 131.35,130.51 131.35,130.52 131.69,130.52 132.15,130.06 132.15,129.16 132.45,128.86 135.51,128.86 135.62,128.75 ; v1(156.23,126.91) 155.91,127.23 UV14.H4 ; 147.53,124.09 147.36,124.09
  TOP w0.14: 135.62,128.75 136.28,128.09 142.17,128.09 142.17,128.1 142.57,128.1 146.55,124.13 v2(146.61,124.1) 146.62,124.09 147.36,124.09
  BOTTOM w0.127: UV1.J14 129.62,131.6 129.11,131.1 v1(129.11,131.09) ; v1(156.23,126.91) 155.91,127.23 UV14.H4
M1_MA1: length 33.4
  TOP w0.102: 148.07,124.71 154.91,124.71 v1(156.06,125.85)
  TOP w0.127: 136.58,128.6 136.09,129.09 133.59,129.09 132.98,129.7 132.66,129.7 132.38,129.98 132.38,130.16 131.76,130.78 131.76,131.03 131.49,131.3 131.17,131.3 130.83,131.65 129.4,131.65 129.27,131.78 v1(129.27,132.37) ; UV14.H5 155.91,126 v1(156.06,125.85) ; 147.68,124.71 148.07,124.71
  TOP w0.14: 136.58,128.6 136.59,128.58 142.77,128.58 142.79,128.57 142.98,128.57 v2(144.23,127.32) 146.84,124.71 147.68,124.71
  BOTTOM w0.127: UV1.K14 129.27,131.93 v1(129.27,132.37) ; v1(156.06,125.85) 155.91,126 UV14.H5
M1_MA2: length 33.8
  TOP w0.127: UV14.H11 v1(155.51,122.11) 154.91,122.11 154.73,122.29 154.73,123.62 154.47,123.89 148.67,123.89 147.38,122.6 ; v1(129.5,129.83) 129.86,130.19 130.37,130.19 130.51,130.05 130.51,129.31 130.69,129.12 131.22,129.12 132.17,128.17 134.2,128.17 134.52,127.85 134.52,127.65 135.25,126.92 135.58,126.92
  TOP w0.14: 147.38,122.6 145.8,122.6 v2(144.94,123.45) 142.34,126.05 136.8,126.05 135.93,126.92 135.58,126.92
  BOTTOM w0.127: UV14.H11 v1(155.51,122.11) ; UV1.J11 129.74,129.6 v1(129.5,129.83)
M1_MA3: length 33.4
  TOP w0.102: v1(156.19,123.1) 156.19,123.36 155.46,124.1 148.56,124.1 147.56,123.1
  TOP w0.127: v1(129.71,131.02) 129.71,130.93 130.22,130.42 130.47,130.42 130.86,130.03 131.37,130.03 131.68,129.72 131.68,129.29 131.69,129.28 131.69,128.98 132.26,128.4 134.29,128.4 134.75,127.94 134.75,127.74 135.33,127.16 135.68,127.16 ; 147.36,123.1 147.56,123.1 ; UV14.H10 155.91,122.82 v1(156.19,123.1)
  TOP w0.14: 147.36,123.1 145.99,123.1 142.56,126.53 v2(141.87,126.53) 137,126.53 136.37,127.16 135.68,127.16
  BOTTOM w0.127: UV14.H10 155.91,122.82 v1(156.19,123.1) ; UV1.J13 129.71,130.43 v1(129.71,131.02)
M1_MA4: length 31.8
  TOP w0.102: v1(153.91,122.11) 153.83,122.18 153.83,123.22 153.58,123.47 148.85,123.47 148.18,122.8 148.18,122.35 147.41,121.58
  TOP w0.127: v1(130.08,129.79) 130.08,129.29 130.58,128.8 130.58,128.56 130.88,128.26 131.43,128.26 132.54,127.15 132.91,127.15 134.83,125.23 136.04,125.23 136.58,124.69 ; v1(153.91,122.11) UV14.K11
  TOP w0.14: 147.41,121.58 145.35,121.58 143.65,123.29 v2(140.88,123.29) 137.98,123.29 136.58,124.69
  BOTTOM w0.127: UV14.K11 v1(153.91,122.11) ; UV1.H11 130.08,129.65 v1(130.08,129.79)
M1_MA5: length 29.5
  TOP w0.102: v1(154.31,123.07) 153.71,123.67 148.76,123.67 147.82,122.73 147.82,122.46 147.45,122.09 147.36,122.09
  TOP w0.127: v1(154.31,123.07) UV14.K10 ; v1(130.97,128.73) 131.29,128.73 132.64,127.38 133,127.38 133.69,126.68 133.95,126.68 134.08,126.81 134.08,127.01 134.24,127.17 134.42,127.17 134.58,127.01 134.58,126.81 134.71,126.68 135.49,126.68 136.58,125.6
  TOP w0.14: 147.36,122.09 145.54,122.09 143.38,124.26 v2(142.73,124.26) 137.91,124.26 136.58,125.6
  BOTTOM w0.127: UV14.K10 v1(154.31,123.07) ; v1(130.97,128.73) 130.97,128.83 UV1.G11
M1_MA6: length 31
  TOP w0.102: 148.11,126.28 148.87,125.52 153.7,125.52 154.03,125.85 154.09,125.85
  TOP w0.127: 148.11,126.58 148.11,126.28 ; 136.58,131.46 135.7,131.46 135.5,131.66 134.52,131.66 134.22,131.36 133.34,131.36 132.88,131.82 132.27,131.82 131.87,132.22 131.55,132.22 130.95,132.82 130.86,132.91 130.55,132.91 130.09,133.38 v1(130,133.38) ; UV14.K5 154.31,126.07 v1(154.09,125.85) 154.09,125.85
  TOP w0.14: 148.11,126.58 v2(146.29,128.41) 143.24,131.46 142.22,131.46 142.08,131.32 142.08,131.22 141.94,131.08 141.71,131.08 141.53,131.26 141.53,131.32 141.39,131.46 141.11,131.46 140.97,131.32 140.97,131.18 140.83,131.04 140.55,131.04 140.41,131.18 140.41,131.32 140.27,131.46 137.98,131.46 137.97,131.46 137.62,131.46 137.61,131.46 136.58,131.46
  BOTTOM w0.127: UV1.J16 129.74,132.83 130,133.1 v1(130,133.38) ; v1(154.09,125.85) 154.09,126.29 UV14.K5
M1_MA7: length 34.2
  TOP w0.102: 147.9,126.08 148.02,126.08 148.78,125.32 154.1,125.32 154.54,125.76 154.54,126.28 154.63,126.37 154.63,126.83 v1(154.71,126.91)
  TOP w0.127: v1(128.57,133.4) 128.99,133.82 129.48,133.82 129.61,133.7 129.61,133.08 130.01,132.68 130.76,132.68 131.46,131.99 131.78,131.99 132.18,131.59 132.79,131.59 133.24,131.13 133.88,131.13 134.14,130.88 135.49,130.88 135.56,130.95 136.43,130.95 ; 147.9,126.08 147.84,126.14 147.84,126.18 ; v1(154.71,126.91) UV14.K4
  TOP w0.14: 147.84,126.18 v2(144.43,129.59) 143.46,130.56 139.44,130.56 139.43,130.55 139.08,130.55 139.08,130.56 137.56,130.56 137.17,130.95 136.43,130.95
  BOTTOM w0.127: UV1.L15 128.14,132.28 128.56,132.7 128.56,132.94 128.57,132.95 v1(128.57,133.4) ; UV14.K4 v1(154.71,126.91)
M1_MA8: length 30.3
  TOP w0.102: 148.01,125.62 148.2,125.62 148.7,125.12 154.59,125.12 154.92,125.45 v1(154.92,125.91)
  TOP w0.127: UV14.J5 155.11,126.1 v1(154.92,125.91) ; v1(130.62,132.27) 130.73,132.16 130.96,132.16 131.36,131.76 131.68,131.76 132.09,131.35 132.7,131.35 133.15,130.9 133.79,130.9 134.27,130.42 135.36,130.42 135.36,130.42 136.37,130.42 ; 148.01,125.62 147.73,125.9
  TOP w0.14: 147.73,125.9 147.62,126.01 147.32,126.01 143.32,130.01 v2(142.4,130.01) 137.39,130.01 136.94,130.46 136.41,130.46 136.37,130.42
  BOTTOM w0.127: UV1.G14 131.29,131.6 v1(130.62,132.27) ; UV14.J5 155.11,126.1 v1(154.92,125.91)
M2_SSD_PEDET: length 169.8
  TOP w0.089: v1(67.42,32.37) 67.1,32.69 67.1,34.74 66.7,35.14 66.7,37.28 66.48,37.5 64.37,37.5 63.97,37.1 63.97,36.04 63.64,35.71 63.64,35.71 63.34,35.41 59.48,35.41 v2(59.42,35.47) 58.9,35.99 58.28,36.61 53.89,36.61 51.02,39.48 45.78,39.48 43.54,37.24 39.96,37.24 39.27,37.94 37.45,37.94 36.22,36.71 32.52,36.71 v1(32.37,36.86)
  IN2 w0.089: v1(23.82,37.12) 24.21,36.72 32.23,36.72 v1(32.37,36.86) ; v1(146.16,36.87) 145.79,37.24 144.02,37.24 143.28,37.97 141.43,37.97 140.14,39.26 140.14,40.92 138.48,42.58 136.14,42.58 134.05,40.48 134.05,38.68 131.15,35.79 129.47,35.79 128.87,35.19 116.36,35.19 115.81,34.64 114.73,34.64 114.47,34.9 111.27,34.9 110.62,34.25 107.61,34.25 106.89,33.53 100.3,33.53 99.96,33.86 97.9,33.86 97.35,33.31 87.25,33.31 86.67,33.89 84.9,33.89 83.16,32.15 83.16,31.98 82.92,31.73 82.22,31.73 81.61,31.13 80.03,31.13 79.16,32 74.37,32 73.96,31.59 71.49,31.59 71.11,31.97 67.82,31.97 v1(67.42,32.37)
  BOTTOM w0.076: 134.98,48.68 134.76,48.9 134.67,48.9 133.45,50.12 133.45,50.21 133.44,50.22 133.44,50.47 133.45,50.48 133.45,50.82 133.42,50.85 133.42,51.08 133.42,51.09 133.42,51.56 133.04,51.94 UC1.G4
  BOTTOM w0.089: v1(146.16,36.87) 145.62,37.41 145.62,38.74 146.1,39.23 146.1,41.01 144.29,42.82 142.43,42.82 139.49,45.76 138.25,45.76 135.49,48.52 135.14,48.52 134.98,48.68 ; v1(23.82,37.12) RS2.1
  BOTTOM w0.102: JSSD1.69 22.38,35 23.82,36.44 RS2.1
M_ADBI0: length 32.5
  TOP w0.127: 154.71,136.09 154.73,136.12 154.73,137.22 155.03,137.52 155.18,137.52 155.51,137.85 v1(155.51,138.33) 155.11,138.73 UV12.J4 ; v1(128.95,134.61) 129.97,134.61 130.61,133.96 131.94,133.96 132.19,134.22 132.83,134.22 133.16,133.89 135.53,133.89 135.64,134 136.58,134
  TOP w0.14: 154.71,136.09 154.71,135.93 154.71,135.93 154.71,135.59 154.67,135.55 154.67,134.9 154.45,134.68 153.83,134.68 153.15,134 v2(142.83,134) 136.58,134
  BOTTOM w0.102: UV1.L18 128.76,134.8 v1(128.95,134.61)
  BOTTOM w0.127: v1(155.51,138.33) 155.11,138.73 UV12.J4
M_ADBI1: length 35
  TOP w0.102: 148.39,124.94 148.42,124.91 154.81,124.91 155.57,125.68
  TOP w0.127: 148.39,124.94 147.75,124.94 147.36,125.33 ; v1(129.22,133.43) 129.08,133.3 129.08,133.12 129.66,132.54 129.66,132 129.79,131.87 130.92,131.87 131.27,131.53 131.59,131.53 132.03,131.09 132.03,130.83 132.32,130.54 132.79,130.54 132.92,130.68 133.69,130.68 134.18,130.19 134.48,130.19 134.61,130.06 134.61,130.01 134.73,129.88 134.99,129.88 135.11,130.01 135.11,130.06 135.24,130.19 136.22,130.19 136.55,129.86 ; 155.57,125.68 155.57,125.95 155.39,126.13 155.39,126.31 155.57,126.49 155.57,126.91 v1(155.55,126.93) 155.17,127.31 UV14.J4
  TOP w0.14: 147.36,125.33 147.3,125.39 147.06,125.39 v2(146.36,126.09) 143.37,129.07 143.35,129.07 143.22,129.2 136.85,129.2 136.76,129.29 136.76,129.65 136.55,129.86
  BOTTOM w0.127: v1(155.55,126.93) 155.17,127.31 UV14.J4 ; v1(129.22,133.43) 128.94,133.15 UV1.K16
M_CAS#0: length 33.1
  TOP w0.102: 147.98,141.38 148.12,141.53 155.82,141.53 156.31,141.03 v1(156.31,138.33)
  TOP w0.127: v1(156.31,138.33) 156.71,137.93 UV12.L3 ; 136.58,138.73 135.8,138.73 135.78,138.75 134.84,138.75 134.82,138.73 134.66,138.73 134.53,138.6 134.53,138.15 134.27,137.89 134,137.89 133.41,137.3 v1(133.35,137.3)
  TOP w0.14: 147.98,141.38 147.67,141.08 v2(146.13,141.08) 144.95,141.08 142.6,138.73 136.58,138.73
  BOTTOM w0.102: UV1.G19 131.34,135.21 131.53,135.4 131.71,135.4 132.01,135.7 132.18,135.7 132.42,135.94 132.89,135.94 133.02,136.07 133.02,136.1 133.02,136.1 133.02,136.41 133.02,136.42 133.02,136.49 132.63,136.87 132.63,137.12 132.81,137.3 v1(133.35,137.3)
  BOTTOM w0.127: v1(156.31,138.33) 156.71,137.93 UV12.L3
M_CAS#1: length 32.4
  TOP w0.102: 148.2,127.36 148.34,127.22 148.34,126.34 148.95,125.73 153.27,125.73 153.91,126.37 v1(153.91,127.71)
  TOP w0.127: 136.58,132.36 134.53,132.36 133.98,132.91 133.2,132.91 132.95,132.66 132.95,132.56 132.63,132.25 132.21,132.25 v1(131.85,132.61) ; v1(153.91,127.71) UV14.L3
  TOP w0.14: 148.2,127.36 146.42,129.13 146.42,129.33 146.86,129.77 146.86,129.96 146.66,130.16 146.47,130.16 146.03,129.72 145.83,129.72 145.63,129.92 145.63,130.12 146.1,130.59 146.1,130.79 145.9,130.98 145.71,130.98 145.24,130.52 145.04,130.52 v2(143.66,131.9) 143.19,132.36 136.58,132.36
  BOTTOM w0.127: UV14.L3 v1(153.91,127.71) ; UV1.G16 131.66,132.8 v1(131.85,132.61)
M_CKE0: length 34
  TOP w0.127: 136.58,134.63 135.63,134.63 135.11,134.11 134.27,134.11 134.14,134.24 134.14,134.64 134.01,134.76 133.76,134.76 133.63,134.64 133.63,134.24 133.5,134.11 133.25,134.11 132.69,134.68 132.33,134.68 131.84,134.19 130.71,134.19 129.4,135.5 129.4,136.75 v1(129.12,137.04) ; 153.91,135.75 153.91,137.2 154.3,137.59 154.45,137.59 154.71,137.85 v1(154.71,138.33) 155.11,137.93 UV12.J3
  TOP w0.14: 136.58,134.63 144.13,134.63 144.5,135 144.8,135 145.16,134.63 v2(145.96,134.63) 152.88,134.63 153.91,135.66 153.91,135.75
  BOTTOM w0.127: v1(154.71,138.33) 155.11,137.93 UV12.J3 ; v1(129.12,137.04) 128.94,136.86 UV1.K20
M_CKE1: length 33.5
  TOP w0.127: UV14.J3 155.11,128.02 155.01,127.92 v1(154.72,127.63) 154.72,128.2 154.38,128.54 154.11,128.54 153.91,128.75 153.91,130.4 ; v1(130.56,133.46) 130.64,133.46 131,133.1 132.8,133.1 133.13,133.43 135.98,133.43 136.39,133.02
  TOP w0.14: 153.91,130.4 153.91,130.75 151.85,132.8 146.52,132.8 146.41,132.68 v2(146.41,132.42) 146.41,132.21 146.27,132.08 146.01,132.08 145.85,132.24 145.85,132.68 145.71,132.82 145.44,132.82 145.3,132.68 145.3,131.97 145.16,131.83 144.88,131.83 144.74,131.97 144.74,132.68 144.6,132.82 136.59,132.82 136.39,133.02
  BOTTOM w0.127: v1(130.56,133.46) 130.55,133.46 130.02,134 UV1.J17 ; UV14.J3 155.11,128.02 v1(154.72,127.63)
M_CLK0: length 34.6
  TOP w0.112: v1(154.71,144.73) 155.11,145.12 UV12.J12
  TOP w0.122: RV79.2 155.2,148.49 155.2,148.29 v1(155.04,148.14)
  IN2 w0.13: 155.23,146.17 154.98,145.92 154.98,144.99 v1(154.71,144.73)
  IN2 w0.137: v1(155.04,148.14) 155.23,147.95 155.23,146.17
  IN3 w0.132: v1(154.71,144.73) 154.86,144.73 155.01,144.57 155.01,144.26 155.22,144.05 155.22,142.77 155.3,142.69 155.3,142.33 155.02,142.06 154.03,142.06 153.78,142.31 138.08,142.31 137.4,141.63 136.09,141.63 135.5,141.04 133.03,141.04 132.96,141.11 132.18,141.11 132.12,141.04 131.53,141.04 131.47,141.11 131.2,141.11 v1(130.94,141.37)
  BOTTOM w0.102: v1(130.94,141.37) 130.57,141 UV1.H26
  BOTTOM w0.112: v1(154.71,144.73) 155.11,145.12 UV12.J12
M_CLK1: length 35.2
  TOP w0.112: UV14.J12 v1(155.51,121.31)
  TOP w0.122: v1(155.32,117.52) 155.16,117.36 155.16,116.99 155.49,116.66 RV85.2
  IN3 w0.132: v1(131.74,127) 131.63,126.89 131.63,126.36 131.86,126.13 133.03,126.13 133.81,126.91 136.58,126.91 136.78,126.71 139.69,126.71 139.96,126.44 146.22,126.44 147.02,125.64 148.17,125.64 149.55,124.26 154.23,124.26 155.06,123.43 155.06,121.94 155.16,121.84 155.16,121.65 v1(155.51,121.31) 155.22,121.02 155.22,120.33 155.01,120.12 155.01,118.6 155.14,118.47 155.14,117.7 v1(155.32,117.52)
  BOTTOM w0.102: v1(131.74,127) UV1.G9
  BOTTOM w0.112: UV14.J12 v1(155.51,121.31)
M_CLK#0: length 34.8
  TOP w0.112: UV12.J11 155.11,144.33 v1(155.51,144.73)
  TOP w0.122: RV370.2 155.42,148.94 155.42,148.35 v1(155.63,148.14)
  IN2 w0.13: v1(155.51,144.73) 155.22,145.02 155.22,145.81 155.48,146.07 155.48,146.14 155.48,146.14 155.48,146.17
  IN2 w0.137: 155.48,146.17 155.48,147.99 v1(155.63,148.14)
  IN3 w0.132: v1(130.94,140.65) 131.18,140.88 131.37,140.88 131.44,140.82 132.21,140.82 132.27,140.88 132.87,140.88 132.94,140.82 135.6,140.82 136.18,141.4 137.49,141.4 138.17,142.09 153.69,142.09 153.94,141.84 155.12,141.84 155.52,142.24 155.52,142.78 155.44,142.86 155.44,144.14 155.23,144.35 155.23,144.55 155.41,144.73 v1(155.51,144.73)
  BOTTOM w0.102: v1(130.94,140.65) 130.94,140.6 UV1.H25
  BOTTOM w0.112: v1(155.51,144.73) 155.11,144.33 UV12.J11
M_CLK#1: length 35.3
  TOP w0.112: UV14.J11 v1(154.71,121.31)
  TOP w0.122: RV86.2 154.94,117 154.94,117.31 v1(154.74,117.52)
  IN3 w0.132: v1(154.74,117.52) 154.92,117.7 154.92,118.38 154.79,118.51 154.79,120.22 155,120.42 155,121.02 v1(154.71,121.31) 154.94,121.53 154.94,121.76 154.84,121.85 154.84,123.34 154.14,124.04 149.46,124.04 148.08,125.42 146.93,125.42 146.13,126.22 139.87,126.22 139.6,126.49 136.69,126.49 136.49,126.69 133.9,126.69 133.13,125.91 131.77,125.91 131.41,126.27 131.41,126.53 v1(130.94,127)
  BOTTOM w0.102: v1(130.94,127) UV1.H9
  BOTTOM w0.112: UV14.J11 v1(154.71,121.31)
M_CS0B#0: length 32.3
  TOP w0.102: v1(153.91,144.73) 153.91,143.39 153.27,142.74 148.98,142.74 148.38,143.34 148.38,143.55 148.24,143.7
  TOP w0.127: 135.31,142.99 133.61,142.99 132.91,142.3 132.91,141.94 131.23,140.25 130.96,140.25 130.15,139.45 v1(130.15,138.99) ; v1(153.91,144.73) 153.51,145.13 UV12.G12
  TOP w0.14: 135.31,142.99 135.59,142.99 135.9,143.3 138.88,143.3 139.2,143.62 140.28,143.62 140.29,143.63 140.64,143.63 140.65,143.62 140.94,143.62 141.08,143.48 141.08,143.33 141.22,143.19 141.5,143.19 141.64,143.33 141.64,143.48 141.78,143.62 142.56,143.62 143.07,144.14 143.08,144.14 143.13,144.19 v2(146.24,144.19) 147.75,144.19 148.24,143.7
  BOTTOM w0.127: v1(130.15,138.99) 130.15,138.99 130.15,138.56 129.95,138.36 129.95,137.94 130.29,137.6 UV1.H22 ; UV12.G12 153.51,145.13 v1(153.91,144.73)
M_CS1B#0: length 35.2
  TOP w0.102: 147.64,123.61 148.33,124.3 155.54,124.3 156.57,123.27 156.57,122.93 156.25,122.6
  TOP w0.127: v1(130.31,131.02) 130.31,130.9 130.96,130.25 131.46,130.25 131.92,129.8 131.92,129.07 132.36,128.63 134.39,128.63 135.4,127.62 136.55,127.62 ; 156.25,122.6 156.25,121.37 v1(156.26,121.35) 156.71,120.91 UV14.G12 ; 147.36,123.61 147.64,123.61
  TOP w0.14: 136.55,127.62 136.56,127.61 142.38,127.61 v2(144.58,125.41) 146.38,123.61 147.36,123.61
  BOTTOM w0.127: v1(156.26,121.35) 156.26,121.28 156.63,120.91 UV14.G12 ; v1(130.31,131.02) 130.31,131.02 130.57,130.77 130.69,130.77 131.06,130.4 UV1.G13
M_DA0: length 59.5
  IN3 w0.142: v1(129.26,142.99) 129.26,143.19 128.02,144.43 128.02,144.44 127.87,144.59 127.87,146.31 132.33,150.77 134.87,150.77 137.4,153.31 159.27,153.31 161.76,150.82 161.76,150.46 163.92,148.3 163.92,142.88 163.49,142.46 163.49,138.3 v1(161.91,136.72)
  BOTTOM w0.127: UV1.K27 129.33,142.18 129.33,142.93 129.26,142.99 v1(129.26,142.99) ; UV13.A2 v1(161.91,136.72)
M_DA1: length 56
  IN3 w0.142: v1(129.26,143.82) 128.34,144.74 128.34,145.81 132.61,150.09 135.15,150.09 137.68,152.62 158.98,152.62 160.84,150.77 160.84,150.09 163.23,147.7 163.23,143.17 162.47,142.41 162.47,138.09 v1(161.11,136.72)
  BOTTOM w0.127: v1(129.26,143.82) 129.26,143.82 129.26,143.69 129.74,143.21 UV1.J29 ; UV13.B2 v1(161.11,136.72)
M_DA2: length 49.9
  IN3 w0.142: v1(161.91,139.13) 161.91,142.81 162.33,143.23 162.33,147.82 159.82,150.33 159.82,150.82 158.7,151.94 137.68,151.94 135.35,149.61 135.25,149.61 135.24,149.6 133.16,149.6 132.93,149.36 132.92,149.36 130.19,146.63 130.19,146.63 129.4,145.84 129.4,145.24 v1(129.71,144.93)
  BOTTOM w0.127: UV1.H30 130.54,143.43 130.22,143.75 130.22,144.53 129.96,144.78 ; v1(161.91,139.13) UV13.A4
  BOTTOM w0.14: v1(129.71,144.93) 129.82,144.93 129.96,144.79 129.96,144.78
M_DA3: length 46.4
  IN3 w0.142: v1(161.11,139.13) 161.52,139.53 161.52,147.95 159.46,150.01 158.39,150.01 157.94,150.46 157.94,150.64 157.46,151.13 137.83,151.13 135.58,148.88 133.12,148.88 130.67,146.43 130.67,146.14 130.6,146.06 130.6,145.98 v1(130.09,145.47)
  BOTTOM w0.127: 130.4,145.17 130.54,145.03 UV1.H32 ; UV13.B4 161.11,139.13 v1(161.11,139.13)
  BOTTOM w0.14: 130.4,145.17 v1(130.09,145.47)
M_DA4: length 45.2
  IN3 w0.142: v1(157.11,136.72) 157.5,137.12 157.5,145.7 157.26,145.94 153.7,145.94 153.24,146.4 149.96,146.4 149.84,146.28 148.21,146.28 148.01,146.08 148.01,144.51 147.83,144.33 147.42,144.33 147.24,144.51 147.24,145.82 147.07,146 146.72,146 146.54,145.82 146.54,144.51 146.37,144.33 146.02,144.33 145.84,144.51 145.84,145.82 145.67,146 145.32,146 145.14,145.82 145.14,144.51 144.97,144.33 144.56,144.33 144.39,144.5 144.39,144.88 144.21,145.05 135.45,145.05 133.81,143.41 v1(131.66,143.41)
  BOTTOM w0.127: v1(131.66,143.41) 131.66,143.31 UV1.G29 ; UV13.F2 v1(157.11,136.72)
M_DA5: length 45.8
  IN3 w0.142: v1(157.1,138.33) 156.92,138.33 156.31,138.94 156.31,140.51 156.69,140.89 156.69,144.95 156.52,145.12 155.77,145.12 155.49,145.4 153.39,145.4 152.85,145.94 150.25,145.94 150.07,145.76 149.13,145.76 148.53,145.17 148.53,143.87 148.31,143.65 143.95,143.65 143.77,143.82 143.77,144.2 143.6,144.37 143.25,144.37 143.07,144.2 143.07,143.82 142.9,143.65 142.54,143.65 142.37,143.82 142.37,144.2 142.19,144.37 141.84,144.37 141.67,144.2 141.67,143.17 141.49,143 141.14,143 140.97,143.17 140.97,144.2 140.79,144.37 139.72,144.37 139.54,144.2 139.54,143.17 139.37,143 139.02,143 138.84,143.17 138.84,144.2 138.67,144.37 138.32,144.37 138.14,144.2 138.14,143.31 137.97,143.13 137.4,143.13 137.23,142.96 137.23,142.67 137.03,142.47 136.65,142.47 136.48,142.64 136.48,144.2 136.3,144.37 135.87,144.37 135.67,144.17 135.67,142.79 135.49,142.61 135.31,142.61 135.22,142.7 132.8,142.7 v1(132.5,142.99)
  BOTTOM w0.127: UV1.F28 132.14,142.63 v1(132.5,142.99) ; UV13.F4 157.5,138.73 v1(157.1,138.33)
M_DA6: length 44.6
  IN3 w0.142: v1(132.19,144.89) 133.14,144.89 134.26,146.01 134.55,146.01 134.89,146.35 136.69,146.35 137.71,147.36 143.38,147.36 143.57,147.55 143.57,148.14 143.74,148.32 144.09,148.32 144.27,148.14 144.27,147.55 144.44,147.38 144.79,147.38 144.97,147.55 144.97,148.14 145.14,148.32 145.49,148.32 145.67,148.14 145.67,147.55 145.86,147.36 146.18,147.36 146.36,147.54 146.36,148.14 146.53,148.32 146.94,148.32 147.11,148.14 147.11,147.56 147.29,147.39 147.64,147.39 147.81,147.56 147.81,148.14 147.99,148.32 148.49,148.32 148.66,148.14 148.66,147.83 148.84,147.66 149.19,147.66 149.36,147.83 149.36,148.14 149.54,148.32 149.89,148.32 150.07,148.14 150.07,147.83 150.24,147.66 150.59,147.66 150.6,147.67 153.95,147.67 153.97,147.68 157.22,147.68 157.35,147.54 158.09,147.54 159.11,146.52 159.11,143.33 159.04,143.26 159.04,139.59 159.11,139.53 159.11,138.73 158.7,138.33 v1(158.7,138.33)
  BOTTOM w0.127: UV13.E4 158.7,138.33 158.7,138.33 v1(158.7,138.33) ; v1(132.19,144.89) 132.18,144.89 132.18,144.9 132.14,144.85 UV1.F32
M_DA7: length 46
  IN3 w0.142: v1(131.61,144.26) 133.19,144.26 134.33,145.41 134.84,145.41 135.17,145.74 137.79,145.74 137.97,145.91 137.97,146.5 138.14,146.68 138.49,146.68 138.67,146.5 138.67,145.91 138.84,145.74 139.19,145.74 139.37,145.91 139.37,146.5 139.54,146.68 139.9,146.68 140.07,146.5 140.07,145.91 140.25,145.74 140.6,145.74 140.77,145.91 140.77,146.5 140.95,146.68 141.3,146.68 141.47,146.5 141.47,145.91 141.65,145.74 142,145.74 142.17,145.91 142.17,146.5 142.35,146.68 142.77,146.68 142.94,146.5 142.94,145.91 143.12,145.74 143.47,145.74 143.64,145.91 143.64,146.5 143.82,146.68 149.31,146.68 149.39,146.76 156.82,146.76 156.85,146.72 158.09,146.72 158.3,146.51 158.3,143.66 157.93,143.29 157.93,139.77 158.3,139.4 158.3,137.12 v1(157.91,136.72)
  BOTTOM w0.127: v1(131.61,144.26) 131.61,144.2 132.14,143.67 UV1.F30 ; UV13.E2 v1(157.91,136.72)
M_DA8: length 27.7
  TOP w0.127: UV12.M11 157.51,144.33 157.9,144.72 157.9,144.72 v1(157.9,144.73)
  IN1 w0.102: 148,145.16 148.01,145.14 151.18,145.14 151.68,144.65 151.68,144.3 152.47,143.51 153.27,143.51 153.4,143.37 156.75,143.37 157.91,144.54 157.91,144.72 157.9,144.73 v1(157.9,144.73)
  IN1 w0.147: v1(137.45,143.91) 139.47,145.92 145.51,145.92 146.27,145.16 148,145.16
  BOTTOM w0.102: 135.31,143.91 135.12,143.91 134.99,143.78 134.23,143.78 133.85,143.4 UV1.C30
  BOTTOM w0.14: 135.31,143.91 v1(137.45,143.91)
M_DA9: length 37.6
  TOP w0.127: v1(161.11,146.33) 161.11,146.33 160.71,145.93 UV12.T13
  IN1 w0.145: v1(131.76,142.13) 131.76,142.9 132.06,143.2 132.06,144.11 134.02,146.06 ; v1(161.11,146.33) 161.11,146.33 161.52,146.73 161.52,147.29 161.52,147.29
  IN1 w0.147: 134.02,146.06 136.29,148.34 137.74,149.79 153.77,149.79 154.92,148.64 160.91,148.64 161.52,148.03 161.52,147.29
  BOTTOM w0.127: UV1.F27 131.81,142.13 v1(131.76,142.13)
M_DA10: length 29.4
  TOP w0.127: UV12.N11 158.31,144.33 158.7,144.72 v1(158.7,144.73)
  IN1 w0.102: 148,142.42 154.06,142.42 154.75,143.11 155.13,143.11 155.82,142.42 157.2,142.42 157.98,143.19 157.98,143.99 158.7,144.72 v1(158.7,144.73)
  IN1 w0.145: 148,142.42 147.36,143.06
  IN1 w0.147: 147.36,143.06 145.2,145.22 139.69,145.22 137.29,142.81 137.13,142.81 v1(136.37,142.05)
  BOTTOM w0.127: UV1.A28 134.86,142.28 135.31,142.28
  BOTTOM w0.14: 135.31,142.28 135.56,142.28 135.79,142.05 v1(136.37,142.05)
M_DA11: length 31.6
  TOP w0.127: UV12.T11 160.71,144.33 161.11,143.93 v1(161.11,143.93)
  IN1 w0.145: 147.36,142.13 147.39,142.1 159.93,142.1 160.5,142.67 160.5,143.32 161.11,143.93 v1(161.11,143.93)
  IN1 w0.147: v1(137.21,142.06) 137.64,142.06 140.1,144.52 144.97,144.52 147.36,142.13
  BOTTOM w0.127: UV1.C28 133.76,142.6 134.15,142.99 135.31,142.99
  BOTTOM w0.14: 135.31,142.99 136.28,142.99 v1(137.21,142.06)
M_DA12: length 33
  TOP w0.127: UV12.N13 158.31,145.93 158.7,146.32 v1(158.7,146.33)
  IN1 w0.145: 134.98,146.06 133.39,144.47 v1(133.39,142.17) ; 159.1,147.32 159.1,146.72 158.71,146.33 v1(158.7,146.33)
  IN1 w0.147: 159.1,147.32 158.72,147.7 154.78,147.7 154.34,148.14 154.34,148.25 153.8,148.79 147.34,148.79 147.13,149 137.92,149 135.61,146.69 134.98,146.06
  BOTTOM w0.102: UV1.E27 133.31,142.17 v1(133.39,142.17)
M_DA13: length 41.9
  TOP w0.127: UV12.U13 161.51,145.93 161.91,146.33 v1(161.92,146.33)
  IN1 w0.145: 162.04,147.42 162.04,146.46 161.92,146.33 v1(161.92,146.33) ; v1(131.74,141.47) 130.88,142.33 130.88,144.75 132.2,146.06
  IN1 w0.147: 132.2,146.06 134.63,148.49 134.83,148.49 134.98,148.35 135.19,148.35 135.44,148.6 135.44,148.81 135.3,148.96 135.3,149.17 136.33,150.19 153.93,150.19 154.84,149.28 161.27,149.28 162.04,148.52 162.04,147.42
  BOTTOM w0.102: v1(131.74,141.47) 131.74,141.4 UV1.G26
M_DA14: length 30.7
  TOP w0.127: v1(157.9,146.32) 157.9,146.32 157.51,145.93 UV12.M13
  IN1 w0.102: v1(157.9,146.32) 157.9,146.33 157.9,146.33 157.49,146.74 154.28,146.74 153.96,147.06 153.96,147.42
  IN1 w0.145: 135.31,145.41 135.12,145.22 135.12,144.74 134.88,144.5 134.66,144.5 134.45,144.3 134.45,144.05 134.03,143.63 134.03,142.93 133.96,142.87 133.96,142.46 133.86,142.36 133.86,142 133.62,141.77 133.61,141.77 v1(133.33,141.48)
  IN1 w0.147: 153.96,147.42 153.96,147.44 153.74,147.66 147.14,147.66 146.59,148.2 138.1,148.2 135.31,145.41
  BOTTOM w0.127: UV1.D26 133.38,141.03 133.38,141.42 133.33,141.47 v1(133.33,141.48)
