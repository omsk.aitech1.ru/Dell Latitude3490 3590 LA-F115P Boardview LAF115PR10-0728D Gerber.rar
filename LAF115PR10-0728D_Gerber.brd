# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_CTX_C_DRX_N4: length 2.4
  BOTTOM w0.112: UT2.7 20.56,126.08 20.67,126.19 20.67,126.64 21.17,127.14 21.17,127.41 CT35.1
USB3_CTX_C_DRX_P4: length 2.4
  BOTTOM w0.112: CT34.1 21.4,127.43 21.4,127.03 v4(21.17,126.81) 20.89,126.53 20.89,126.17 20.96,126.1 UT2.8
USB3_CTX_DRX_N1: length 163.4
  TOP w0.112: v1(27.78,57.92) 27.63,58.07 26.84,58.07 26.43,58.48 25.37,58.48 CU2.1
  IN3 w0.135: v1(139.98,52.97) 139.8,53.15 139.63,53.15 139.48,52.99 139.48,52.54 139.09,52.15 138.7,52.15 138.17,51.62 138.17,47.09 136.08,44.99 136.08,43.56 133.9,41.38 133.9,39.5 131.58,37.18 131.58,35.73 129.52,33.66 129.52,32.75 128.87,32.1 128.14,32.1 127.14,31.1 118.88,31.1 117.48,32.51 114.74,32.51 114.05,31.82 111.44,31.82 110.98,31.37 110.98,31.07 110.49,30.58 108.14,30.58 107.65,31.07 101.18,31.07 100.95,30.84 91.82,30.84 90.78,29.81 84.78,29.81 84.26,29.29 77.29,29.29 77.02,29.56 75.6,29.56 73.25,31.91 69.57,31.91 68.06,33.43 60.39,33.43 58.65,35.17 58.44,35.17 56.02,37.6 53.93,37.6 48.01,43.52 48.01,45.09 48.43,45.51 48.43,46.74 45.89,49.28 45.89,50.12 45.39,50.62 45.39,56.01 44.72,56.68 43.08,56.68 42.71,56.31 42.71,54.6 42.31,54.2 40.61,54.2 39.13,55.68 34.35,55.68 33.72,56.32 30.85,56.32 29.07,58.09 27.95,58.09 v1(27.78,57.92)
  BOTTOM w0.076: UC1.C13 135.07,57.12 134.99,57.04 134.99,56.96 135.12,56.83 135.42,56.83 135.57,56.98 135.57,57.27 135.61,57.31 135.84,57.39 135.98,57.39 136.17,57.33 136.32,57.33 136.38,57.36 136.4,57.37 136.7,57.37 136.8,57.27 136.84,57.23 136.84,56.84 137.36,56.33 137.61,56.33 137.65,56.29 137.66,56.29
  BOTTOM w0.112: v1(139.98,52.97) 139.77,53.18 139.43,53.18 139.18,53.43 139.18,55.3 138.18,56.29 137.66,56.29
USB3_CTX_DRX_N1_C: length 10.3
  TOP w0.112: RU4.1 21.96,58.23 LU2.4 21.48,58.4 21.35,58.54 20.98,58.54 20.96,58.53 20.4,58.53 20.38,58.54 20,58.54 19.86,58.4 EU2601.4 EU2601.7 18.3,58.4 18.16,58.54 v4(17.23,58.54) 16.48,58.54 15.32,57.38 15.32,57.19 15.28,57.01 15.21,56.77 15.2,56.74 15.2,56.39 14.85,56.04 14.49,56.04 14.38,55.93 JUSB1.8
USB3_CTX_DRX_N1_R: length 1.6
  TOP w0.112: RU4.2 22.87,58.23 LU2.3 23.27,58.4 23.41,58.54 23.72,58.54 CU2.2
USB3_CTX_DRX_N2: length 116.7
  TOP w0.112: v1(218.01,49.67) 217.8,49.88 217.68,49.88 217.54,49.74 JWWAN.5
  IN1 w0.119: v1(165.73,32.46) 165.92,32.66 165.92,32.92 166.24,33.23 167.95,33.23 168.29,33.57 177.54,33.57 179.16,35.19 181.33,35.19 182.54,33.99 188.05,33.99 188.34,33.7 199.94,33.7 201.01,32.63 208.84,32.63 212.82,36.62 213.81,36.62 215.45,38.26 215.45,39.24 217.97,41.75 217.97,47.48 218.44,47.95 218.44,49.72 218.33,49.84 218.18,49.84 v1(218.01,49.67)
  IN3 w0.135: v1(153.46,35.57) 153.59,35.7 153.59,36.13 152.24,37.48 150.12,37.48 149.45,38.15 147.78,38.15 145.54,40.38 144.4,40.38 142.3,42.48 142.3,46.33 141.84,46.78 141.84,50.5 140.64,51.71 140.64,53.51 140.18,53.97 139.64,53.97 139.59,53.92 138.9,53.92 v1(138.67,53.69)
  BOTTOM w0.094: 137.37,55.74 136.79,56.32 136.44,56.32 136.25,56.51 136.25,56.95 136.08,57.12 UC1.B13
  BOTTOM w0.112: v1(153.46,35.57) 153.67,35.35 153.67,34.74 155.05,33.37 165.58,33.37 165.92,33.03 165.92,32.66 v1(165.73,32.46) ; v1(138.67,53.69) 138.47,53.9 138.23,53.9 137.99,54.14 137.99,54.98 137.52,55.45 137.52,55.48 137.37,55.63 137.37,55.74
USB3_CTX_DRX_N3: length 161.7
  TOP w0.112: CU4.1 18.31,37.65 18.31,38.53 20.48,40.7 v4(23.91,40.7) 27.49,40.7 27.5,40.69 28.06,40.69 28.08,40.7 32.1,40.7 v1(32.68,41.28)
  IN1 w0.076: v1(137.23,58.71) 137.33,58.71 137.52,58.52 137.52,58.32 137.66,58.18
  IN1 w0.119: 137.66,58.18 137.73,58.11 139.29,58.11 139.55,57.84 139.55,54.24 139.25,53.93 139.25,52.55 139.55,52.24 139.55,49.26 139.66,49.15 139.66,46.39 140.74,45.31 140.74,38.3 138.75,36.31 136.02,36.31 134.04,34.32 132.94,34.32 131.85,33.23 130.6,33.23 130.31,32.94 129.71,32.94 129.12,32.35 119.68,32.35 119.3,32.73 114.57,32.73 114.19,32.35 108.55,32.35 107.56,31.36 102.05,31.36 101.75,31.06 91.23,31.06 90.79,30.62 90.13,30.62 88.98,29.47 78.34,29.47 77.42,30.39 75.08,30.39 73.67,31.8 66.88,31.8 65.97,32.71 63.71,32.71 58.2,38.22 46.96,38.22 45.7,36.97 38.06,36.97 36.79,38.23 32.61,38.23 32.31,38.54 32.31,40.91 v1(32.68,41.28)
  BOTTOM w0.076: UC1.B15 135.94,58.43 136.13,58.43 136.2,58.5 136.2,58.63 136.17,58.66 136.17,58.78 136.25,58.85 136.54,58.85 136.69,58.71 v1(137.23,58.71)
USB3_CTX_DRX_N3_C: length 8.6
  TOP w0.089: RU10.1 18.36,34.25 LU5.4 18.36,33.52 18.77,33.11 18.77,32.45 EU2603.4 EU2603.7 17.49,31.17 17.26,31.17 16.97,30.89 16.32,30.89 v4(15.72,31.49) 15.06,32.15 14.47,32.15 14.38,32.07 JUSB2.8
USB3_CTX_DRX_N3_R: length 1.5
  TOP w0.089: RU10.2 18.36,35.43 LU5.3 18.36,35.64 18.21,35.8 18.21,36.11 CU4.2
USB3_CTX_DRX_N4: length 194.7
  IN1 w0.119: v1(21.12,129.61) 21.22,129.72 21.22,130.32 21.56,130.65 22.08,130.65 23.15,131.72 30.35,131.72 35.68,126.39 41.48,126.39 42.2,125.66 43.09,125.66 43.46,126.04 47.09,126.04 49.8,128.75 50.27,128.75 52.13,130.61 57.8,130.61 58.85,129.57 58.85,128.45 60.08,127.21 60.94,127.21 62.01,126.14 62.39,126.14 64.73,123.81 65.19,123.81 67.31,121.68 69.59,121.68 69.66,121.62 75.85,121.62 77.19,120.28 79.72,120.28 80.64,119.36 81.59,119.36 81.59,119.36 81.88,119.36 83,118.25 86.52,118.25 88.33,116.43 94.11,116.43 94.56,116.88 109.24,116.88 110.67,118.31 111.88,118.31 112.16,118.03 112.16,117.76 v1(112.33,117.58)
  IN3 w0.135: v1(138.37,57.69) 138.24,57.82 138.24,58.13 139.2,59.09 139.2,64.08 139.82,64.7 139.82,66.3 139.69,66.44 139.69,68.74 141.76,70.81 141.76,73.28 142.48,74.01 142.48,74.82 142.88,75.21 142.88,79.96 142.21,80.63 142.21,88.5 141.19,89.52 141.19,90.38 139.34,92.24 139.34,97.88 140.81,99.35 140.81,102.23 132.08,110.97 132.08,113.08 130.02,115.13 126.97,115.13 125.7,116.4 120.24,116.4 119.6,117.04 112.34,117.04 112.19,117.19 112.19,117.44 v1(112.33,117.58)
  BOTTOM w0.076: 137.66,58.11 137.64,58.11 137.5,57.97 137.21,57.97 136.99,58.19 136.48,58.19 136.37,58.25 136.07,58.25 136.05,58.22 135.76,58.22 135.73,58.25 135.47,58.25 UC1.C15
  BOTTOM w0.112: 137.66,58.11 137.95,58.11 v1(138.37,57.69) ; CT35.2 21.12,128.96 21.12,129.25 21.23,129.35 21.23,129.5 v1(21.12,129.61)
USB3_CTX_DRX_P1: length 163.3
  TOP w0.112: v1(27.78,58.5) 27.57,58.29 26.93,58.29 26.52,58.7 25.49,58.7 CU1.1
  IN3 w0.135: v1(27.78,58.5) 27.95,58.33 29.17,58.33 30.95,56.56 33.82,56.56 34.45,55.93 39.23,55.93 40.71,54.44 42.21,54.44 42.46,54.7 42.46,56.41 42.98,56.92 44.82,56.92 45.63,56.11 45.63,50.72 46.13,50.22 46.13,49.38 48.67,46.84 48.67,45.41 48.26,44.99 48.26,43.62 54.03,37.84 56.12,37.84 58.54,35.41 58.75,35.41 60.49,33.67 68.16,33.67 69.67,32.15 73.35,32.15 75.7,29.8 77.12,29.8 77.39,29.54 84.16,29.54 84.68,30.05 90.68,30.05 91.72,31.08 100.85,31.08 101.08,31.31 107.75,31.31 108.24,30.82 110.39,30.82 110.74,31.17 110.74,31.47 111.34,32.06 113.95,32.06 114.64,32.75 117.58,32.75 118.98,31.35 127.04,31.35 128.04,32.34 128.77,32.34 129.28,32.85 129.28,33.76 131.34,35.83 131.34,37.28 133.66,39.6 133.66,41.48 135.84,43.66 135.84,45.09 137.93,47.19 137.93,51.72 138.6,52.39 138.99,52.39 139.24,52.64 139.24,53.09 139.53,53.39 139.84,53.39 v1(140,53.55)
  BOTTOM w0.076: UC1.D13 134.68,57.41 134.76,57.48 135.58,57.48 135.81,57.55 136,57.55 136.2,57.49 136.28,57.49 136.33,57.54 136.76,57.54 136.97,57.34 137.01,57.29 137.01,56.91 137.43,56.49 137.63,56.49 137.64,56.51 137.66,56.51
  BOTTOM w0.112: v1(140,53.55) 139.85,53.4 139.52,53.4 139.4,53.52 139.4,55.39 138.27,56.51 137.66,56.51
USB3_CTX_DRX_P1_C: length 10.3
  TOP w0.112: JUSB1.9 14.38,56.37 14.49,56.26 14.76,56.26 14.98,56.48 14.98,56.75 14.99,56.82 15.07,57.07 15.1,57.22 15.1,57.47 16.39,58.76 16.91,58.76 16.93,58.77 17.53,58.77 17.55,58.76 18.22,58.76 18.36,58.9 EU2601.6 EU2601.5 19.84,58.9 19.98,58.76 v4(20.7,58.76) 21.36,58.76 21.5,58.9 LU2.1 21.96,59.07 RU3.1
USB3_CTX_DRX_P1_R: length 1.6
  TOP w0.112: CU1.2 23.72,58.76 23.38,58.76 23.24,58.9 LU2.2 22.87,59.07 RU3.2
USB3_CTX_DRX_P2: length 116.7
  TOP w0.112: v1(218.01,50.25) 217.85,50.1 217.71,50.1 217.57,50.24 JWWAN.6
  IN1 w0.119: v1(166.31,32.46) 166.14,32.63 166.14,32.83 166.33,33.01 168.04,33.01 168.38,33.35 177.63,33.35 179.26,34.97 181.24,34.97 182.45,33.77 187.96,33.77 188.25,33.49 199.85,33.49 200.92,32.41 208.93,32.41 212.92,36.4 213.9,36.4 215.67,38.17 215.67,39.15 218.19,41.66 218.19,47.39 218.66,47.86 218.66,49.81 218.42,50.06 218.21,50.06 v1(218.01,50.25)
  IN3 w0.135: v1(154.04,35.57) 153.83,35.78 153.83,36.23 152.34,37.72 150.22,37.72 149.55,38.39 147.88,38.39 145.64,40.62 144.5,40.62 142.54,42.58 142.54,46.43 142.08,46.88 142.08,50.6 140.88,51.81 140.88,53.61 140.28,54.22 138.74,54.22 v1(138.67,54.28)
  BOTTOM w0.094: 137.57,55.74 137.57,55.76 137.56,55.77 137.56,55.82 137.44,55.93 137.43,55.93 136.87,56.5 136.53,56.5 136.43,56.6 136.43,57.01 UC1.A13
  BOTTOM w0.112: v1(166.31,32.46) 166.15,32.62 166.15,33.12 165.68,33.59 155.14,33.59 153.89,34.83 153.89,35.42 v1(154.04,35.57) ; 137.57,55.74 137.57,55.71 138.21,55.07 138.21,54.23 138.32,54.12 138.52,54.12 v1(138.67,54.28)
USB3_CTX_DRX_P3: length 161.8
  TOP w0.112: v1(32.09,41.28) 32.09,41.03 31.98,40.92 v4(27.75,40.92) 24.27,40.92 24.25,40.93 23.66,40.93 23.65,40.92 20.39,40.92 18.09,38.62 18.09,37.81 CU3.1
  IN1 w0.119: v1(137.82,58.71) 137.71,58.6 137.71,58.43 137.82,58.33 139.38,58.33 139.77,57.93 139.77,54.15 139.47,53.84 139.47,52.64 139.77,52.33 139.77,49.35 139.88,49.24 139.88,46.48 140.96,45.4 140.96,38.21 138.84,36.09 136.11,36.09 134.13,34.1 133.03,34.1 131.94,33.02 130.69,33.02 130.4,32.72 129.8,32.72 129.21,32.13 119.59,32.13 119.21,32.51 114.66,32.51 114.28,32.14 108.64,32.14 107.65,31.14 102.14,31.14 101.84,30.84 91.32,30.84 90.88,30.4 90.22,30.4 89.07,29.25 78.25,29.25 77.33,30.17 74.99,30.17 73.58,31.58 66.79,31.58 65.88,32.49 63.62,32.49 58.11,38 47.05,38 45.79,36.75 37.97,36.75 36.7,38.02 32.52,38.02 32.09,38.45 v1(32.09,41.28)
  BOTTOM w0.076: 137.66,58.55 137.46,58.35 137.06,58.35 136.87,58.54 136.62,58.54 UC1.A15
  BOTTOM w0.112: 137.66,58.55 v1(137.82,58.71)
USB3_CTX_DRX_P3_C: length 8.5
  TOP w0.089: JUSB2.9 14.38,32.43 14.47,32.35 15.13,32.35 15.68,31.8 15.69,31.8 16.04,31.45 16.04,31.44 16.4,31.08 16.89,31.08 17.12,31.3 17.12,31.51 EU2603.6 EU2603.5 18.11,32.51 18.49,32.51 18.58,32.6 18.58,33.02 v4(18.39,33.21) 18.17,33.43 18.17,33.68 18.13,33.71 18.01,33.71 17.86,33.87 LU5.1 17.86,34.25 RU9.1
USB3_CTX_DRX_P3_R: length 1.4
  TOP w0.089: CU3.2 18.02,36.13 18.02,35.82 17.86,35.66 LU5.2 17.86,35.42 RU9.2
USB3_CTX_DRX_P4: length 194.7
  IN1 w0.119: v1(21.7,129.61) 21.44,129.87 21.44,130.23 21.65,130.43 22.17,130.43 23.24,131.5 30.26,131.5 35.59,126.17 41.39,126.17 42.11,125.45 43.18,125.45 43.55,125.82 47.18,125.82 49.89,128.53 50.36,128.53 52.22,130.4 57.71,130.4 58.63,129.48 58.63,128.35 59.99,127 60.85,127 61.92,125.93 62.3,125.93 64.64,123.59 65.1,123.59 67.22,121.47 69.5,121.47 69.57,121.4 75.76,121.4 77.1,120.06 79.63,120.06 80.55,119.14 81.68,119.14 81.79,119.14 82.91,118.03 86.43,118.03 88.24,116.21 94.21,116.21 94.65,116.66 109.33,116.66 110.76,118.09 111.79,118.09 111.94,117.94 111.94,117.77 v1(111.75,117.58)
  IN3 w0.135: v1(137.78,57.69) 138,57.91 138,58.23 138.96,59.19 138.96,64.18 139.58,64.8 139.58,66.2 139.45,66.34 139.45,68.84 141.52,70.91 141.52,73.38 142.24,74.11 142.24,74.92 142.64,75.32 142.64,79.86 141.97,80.53 141.97,88.4 140.95,89.42 140.95,90.28 139.09,92.14 139.09,97.98 140.57,99.45 140.57,102.13 131.83,110.87 131.83,112.98 129.92,114.89 126.87,114.89 125.6,116.16 120.14,116.16 119.5,116.8 112.24,116.8 111.95,117.09 111.95,117.38 v1(111.75,117.58)
  BOTTOM w0.076: 137.66,57.81 137.65,57.8 137.14,57.8 136.92,58.02 136.44,58.02 136.33,58.08 136.14,58.08 136.11,58.05 135.69,58.05 135.67,58.08 135.16,58.08 135.03,58.21 134.92,58.21 134.78,58.08 134.57,58.08 134.49,58.15 134.49,58.37 UC1.D15
  BOTTOM w0.112: v1(21.7,129.61) 21.45,129.36 21.45,129.26 21.34,129.15 21.34,128.91 21.59,128.67 CT34.2 ; 137.66,57.81 137.66,57.81 v1(137.78,57.69)
USB20_VCCB:
  vias: v1(200.71,35.75) v1(201.32,35.75) v1(201.35,38.55) v1(201.96,38.55) v3(200.69,33.61)
USB30_VCCA:
  vias: v1(17.14,55.24) v1(17.17,54.58) v1(17.84,55.24) v1(17.86,54.58) v1(30.51,50.8) v1(30.51,50.16) v1(31.15,50.8) v1(31.15,50.16) v2(30.51,51.42)
USB30_VCCC:
  vias: v1(14.93,38.81) v1(15.24,38.3) v1(15.55,38.81) v1(18.21,51.79) v1(18.8,51.77) v2(17.94,51.21)
USB_CAMERA_EDP: length 2.3
  TOP w0.112: v1(213.38,43.93) 213.58,44.13 213.74,44.13 213.88,43.99 L3.2 214.3,43.86 R17.1
  BOTTOM w0.112: JEDP1.34 212.81,43.95 212.95,44.08 213.23,44.08 v1(213.38,43.93)
USB_CAMERA_EDP#: length 2.3
  TOP w0.112: v1(213.38,44.52) 213.55,44.35 213.7,44.35 213.84,44.49 L3.3 214.3,44.62 R18.1
  BOTTOM w0.112: JEDP1.33 212.81,44.45 212.95,44.31 213.17,44.31 v1(213.38,44.52)
USB_EN#: length 268.6
  TOP w0.089: v1(37.63,62.66) 37.81,62.48 RE17.1 ; UU3.4 204.75,30.78 204.19,30.22 201.11,30.22 v2(200.05,31.29) 199.94,31.39 199.94,34.97 199.86,35.06 v1(199.86,35.72)
  TOP w0.102: v1(42.89,65.95) 42.89,66.17 42.15,66.91 UE1.13
  IN1 w0.102: v1(33.31,41.73) 31.8,41.73 28.35,38.29 27.67,38.29 24.85,35.47 24.85,34.95 26.55,33.26 29.84,33.26 32.1,31 33.98,31 34.73,31.75 39.08,31.75 40.09,30.73 40.38,30.45 46.24,30.45 49.3,33.51 53.84,33.51 54.67,32.68 56.72,32.68 60.77,28.63 60.77,28.63 62.59,26.82 66.62,26.82 67.09,26.35 69.04,26.35 70.93,24.47 100.04,24.47 100.99,25.42 113.69,25.42 114.98,26.7 120.65,26.7 121.12,27.17 136.42,27.17 140.03,30.78 145.67,30.78 146.24,30.21 149.91,30.21 151.09,31.39 153.79,31.39 157.2,34.81 161.96,34.81 162.31,35.16 163.6,35.16 163.83,35.39 168.02,35.39 168.06,35.35 168.95,35.35 173.27,35.35 173.76,35.84 177.24,35.84 178.39,36.99 186.08,36.99 186.46,36.62 192.11,36.62 192.49,36.99 197.09,36.99 197.98,36.1 199.48,36.1 v1(199.86,35.72) ; v1(42.89,65.95) 42.05,65.11 42.05,64.64 41.36,63.95 38.49,63.95 37.63,63.09 v1(37.63,62.66)
  IN2 w0.089: v1(31.81,61.55) 31.97,61.39 31.97,60.23 31.49,59.75 30.74,59.75 28.65,57.65 28.65,56.41 25.4,53.16 25.13,53.16 22.14,50.17 v1(21.59,50.17)
  IN3 w0.102: v1(31.81,61.55) 31.81,61.87 32.47,62.53 37.49,62.53 v1(37.63,62.66)
  BOTTOM w0.089: v1(21.59,50.17) UU1.4 ; v1(31.81,61.55) 32.35,61.01 32.35,59.22 33.08,58.5 33.08,57.16 34.39,55.86 34.39,51.53 35.55,50.37 35.55,47.35 34.2,45.99 34.2,45.26 32.66,43.72 32.66,42.38 v1(33.31,41.73)
USB_OC0#: length 180.6
  TOP w0.102: UU2.13 31.36,49.19 31.21,49.33 v1(30.58,49.33) 30.36,49.33 29.94,49.76 29.94,53.79 29.64,54.1 27.33,54.1 26.76,54.67 v2(23.35,54.67) 22.63,54.67 21.28,53.32 v1(21.28,51.82)
  IN3 w0.089: v1(30.58,49.33) 31.72,49.33 32.65,50.26 33.7,50.26 34.39,50.95 35.48,50.95 37.03,49.4 v1(37.77,49.4)
  IN3 w0.102: v1(37.08,53.13) 42.31,53.13 43.13,53.95 43.13,56.01 43.38,56.26 44.55,56.26 44.97,55.84 44.97,50.44 45.46,49.94 45.46,49.1 46.64,47.93 46.64,43.53 48.56,41.6 48.56,41.25 53.07,36.74 55.69,36.74 58.07,34.36 58.31,34.36 60.06,32.61 65.78,32.61 67.3,31.09 72.76,31.09 75.56,28.29 92.09,28.29 93.74,29.93 95.95,29.93 96.2,29.69 96.88,29.01 102.78,29.01 103.82,30.05 107.45,30.05 108.45,29.05 110.35,29.05 111.75,30.45 112.37,30.45 112.78,30.86 117.97,30.86 118.54,30.29 127.48,30.29 128.45,31.27 130.04,31.27 131.18,32.4 131.18,33.62 132.4,34.85 132.4,36.84 134.71,39.16 134.71,41.02 137.1,43.4 139.08,43.4 139.9,44.23 139.9,46.97 141.05,48.11 141.05,49.6 v1(140.93,49.71)
  BOTTOM w0.076: 137.6,52.96 137.19,53.37 137.19,53.99 UC1.A9
  BOTTOM w0.089: v1(37.08,53.13) 37.47,52.74 37.47,51.8 37.77,51.51 v1(37.77,49.4) ; v1(21.28,51.82) 20.92,52.17 UU1.3
  BOTTOM w0.112: RPC1.3 142.29,49.56 141.08,49.56 v1(140.93,49.71) 140.93,50.75 139.72,51.96 139.24,51.96 139,52.2 138.36,52.2 137.6,52.96
USB_OC1#: length 99.4
  TOP w0.089: UU3.3 203.02,30.78 202.95,30.86 v2(202.37,30.86) 200.92,30.86 200.25,31.53 200.25,38.43 v1(200.4,38.58) ; v1(151.98,33.09) 151.98,33.91 149.43,36.46 149.43,36.88 147.53,38.78 143.04,38.78 142.72,39.1 v1(142.72,39.81)
  IN1 w0.102: v1(200.4,38.58) 199.98,38.15 197.91,38.15 197.32,38.74 192.26,38.74 191.53,38.01 187.03,38.01 186.65,38.4 177.73,38.4 177.44,38.11 173.91,38.11 172.93,37.12 164.88,37.12 164.42,37.58 159.96,37.58 158.64,36.27 156.35,36.27 154.33,34.25 153.14,34.25 v1(151.98,33.09)
  IN3 w0.102: v1(140.46,50.17) 141.2,50.17 141.41,49.96 141.41,49.17 141.25,49.01 141.25,48.03 140.15,46.93 140.15,42.15 142.49,39.81 v1(142.72,39.81)
  BOTTOM w0.076: UC1.C9 135.49,54.64 135.75,54.39 136.42,54.39 137.02,53.79 137.02,53.23
  BOTTOM w0.112: 137.02,53.23 138.27,51.99 138.91,51.99 139.14,51.76 139.14,51.76 139.63,51.76 140.46,50.92 v1(140.46,50.17) 140.53,50.1 140.53,49.57 140.78,49.32 140.83,49.32 141.01,49.14 142.1,49.14 142.15,49.19 RPC1.2
USB_OC2#: length 259.8
  TOP w0.089: v1(48.22,133.27) 47.75,133.74 v2(46.77,133.74) 44.28,133.74 RT120.1
  IN2 w0.102: v1(48.22,133.27) 50.21,133.27 50.88,132.6 50.88,130.26 49.5,128.88 49.5,128.18 47.14,125.82 46.76,125.82 44.42,123.48 44.42,117.53 43.32,116.43 43.32,115.73 42.62,115.03 37.21,115.03 36.42,115.82 34.34,115.82 33.79,115.27 30.51,115.27 29.4,114.16 29.4,113.37 30.11,112.66 30.11,110.5 30.74,109.87 39.18,109.87 40.12,108.93 40.12,104.17 40.33,103.96 40.33,99.58 39.4,98.65 39.4,93.83 40.48,92.76 40.89,92.76 41.26,92.39 41.26,89.64 43.85,87.05 43.85,84.32 44.05,84.12 44.05,82.79 43.29,82.02 43.29,80.78 44.05,80.02 44.05,78.37 44.42,78 44.42,75.8 47.08,73.14 47.08,69.24 49.37,66.95 49.37,61.85 48.68,61.17 48.68,56.01 49.44,55.25 49.44,52.65 49.27,52.47 49.27,47.4 48,46.13 v1(48,45.77)
  IN3 w0.102: v1(48,45.77) 47.5,45.77 47.03,45.3 47.03,43.69 48.95,41.77 48.95,41.41 53.24,37.13 55.89,37.13 58.27,34.75 58.47,34.75 60.22,33 67.88,33 69.41,31.48 72.92,31.48 75.73,28.68 90.25,28.68 91.99,30.42 97.54,30.42 97.91,30.06 99.08,30.06 99.4,29.74 102.96,29.74 103.65,30.44 107.68,30.44 107.98,30.14 110.7,30.14 111.4,30.84 112.21,30.84 112.62,31.25 118.14,31.25 118.7,30.68 127.32,30.68 128.29,31.66 129.87,31.66 130.78,32.57 130.78,33.79 132.01,35.01 132.01,37 134.32,39.32 134.32,41.21 136.93,43.81 138.91,43.81 139.5,44.4 139.5,47.98 140.45,48.93 v1(140.67,48.93)
  BOTTOM w0.076: UC1.D9 134.59,53.92 134.75,53.76 135.09,53.76 135.13,53.79 136.02,53.79 136.25,53.57 136.25,53.41 136.4,53.26 136.43,53.26 137.5,52.19
  BOTTOM w0.112: 137.5,52.19 137.5,51.99 138.27,51.22 139.53,51.22 140.08,50.67 140.08,50.01 140.32,49.77 140.32,49.49 140.67,49.14 v1(140.67,48.93) 141.98,48.93 142.22,48.69 RPC1.1
USB_OC3#: length 9.1
  BOTTOM w0.076: 137.37,53.71 137.37,54.06 136.84,54.59 136.84,54.75 136.7,54.9 136.4,54.9 136.14,54.64 UC1.B9
  BOTTOM w0.102: 137.37,53.71 137.37,53.49
  BOTTOM w0.112: 137.37,53.49 138.45,52.42 139.1,52.42 139.35,52.17 139.99,52.17 v2(140.41,51.75) 140.41,51.57 141.79,50.19 RPC1.4
USB_PN1: length 149.2
  TOP w0.112: RU22.1 33.09,45.68 v1(32.94,45.83) 33.14,46.03 33.14,46.37 33.03,46.48 UU2.2
  IN1 w0.119: v1(31.34,58.36) 31.17,58.2 31.17,58.2 31.16,58.19 30.54,58.19 29.69,57.33 29.69,53.16 31.59,51.25 31.59,48.05 33.2,46.44 33.2,46.09 v1(32.94,45.83)
  IN3 w0.076: v1(125.8,54.43) 125.8,54.54 125.98,54.71 126.1,54.71 126.15,54.71 126.24,54.63 126.24,52.43 126,52.19 125.65,52.19 124.27,50.82 124.27,50.18 124.24,50.15
  IN3 w0.135: v1(31.34,58.36) 31.5,58.2 31.51,58.2 31.7,58.02 34.4,58.02 35.02,57.4 38.92,57.4 40.14,58.62 40.88,58.62 41.37,58.12 42.14,58.12 42.38,58.36 45.42,58.36 47.27,56.51 47.27,53.02 47.57,52.72 47.57,49.98 48.05,49.49 49.2,49.49 50.53,48.17 50.53,47.56 50.87,47.22 50.87,43.39 51.61,42.65 51.61,42.49 54.44,39.65 54.61,39.65 56.4,39.65 59.07,36.98 59.44,36.98 61.31,35.11 68.3,35.11 68.69,35.49 69.54,35.49 70.3,34.73 71.71,34.73 72.15,34.29 73.37,34.29 73.67,33.99 74.72,33.99 76.23,32.48 79.86,32.48 80.39,33.02 82,33.02 82.19,32.82 83.98,32.82 85.16,34.01 86.42,34.01 87.56,32.87 96.64,32.87 96.98,32.52 100.08,32.52 100.74,33.18 105.74,33.18 106.77,34.21 110.06,34.21 111.36,35.52 114.46,35.52 114.96,35.02 116.06,35.02 116.76,35.72 116.76,36.56 118.17,37.97 119.42,37.97 119.48,38.04 119.49,38.04 119.78,38.33 119.78,40.64 120.36,41.23 120.36,41.57 123.24,44.45 123.24,46.27 123.62,46.64 123.62,47.28 124.16,47.82 124.16,48.77 124.18,48.78 124.18,50.09 124.24,50.15
  BOTTOM w0.102: v1(125.8,54.43) 125.47,54.67 UC1.AB9
USB_PN1_R: length 25.8
  TOP w0.112: RU2.2 LU1.4 32.95,53.33 33.1,53.48 33.1,53.66 32.9,53.86 31.92,53.86 31.91,53.85 31.33,53.85 31.32,53.86 30.78,53.86 28.97,55.68 28.74,55.68 28.61,55.54 28.61,55.09 EU2602.3 28.11,55.06 28.11,55.6 28,55.71 v4(26.2,55.71) 23.4,55.71 23.3,55.6 20.19,55.6 19.61,56.18 18.92,56.18 18.75,56.01 18.55,56.01 v1(18.35,55.8)
  IN3 w0.135: v1(18.35,55.8) 18.17,55.98 16.59,55.98 15.17,54.55 15.17,53.65 15.78,53.04 16.2,53.04 16.4,53.25 16.4,53.79 16.05,54.15 JUSB1.2
USB_PN2: length 127
  TOP w0.112: v1(203.7,34.78) 203.54,34.61 203.54,34.23 205.68,32.08 207.18,32.08 207.28,32.18 207.28,32.49 207.14,32.63 LU9.3 207.04,32.99 RU16.1
  IN1 w0.119: v1(203.7,34.78) 203.5,34.98 203.5,35.45 201.75,37.19 197.89,37.19 197.39,37.7 192.19,37.7 191.82,37.33 186.75,37.33 186.36,37.71 178.11,37.71 177.82,37.42 174.34,37.42 173.34,36.42 164.61,36.42 164.49,36.55 159.91,36.55 158.88,35.52 156.91,35.52 154.87,33.48 154.02,33.48 152.67,32.13 150.79,32.13 149.58,30.92 146.53,30.92 145.96,31.49 139.73,31.49 136.21,27.96 134.38,27.96 133.87,28.47 133.41,28.47 133.12,28.18 133.12,28.02 v1(132.93,27.83)
  IN3 w0.076: v1(124.83,52.39) 124.83,52.4 125.11,52.68 125.3,52.68 125.47,52.85 125.47,54.15 125.41,54.22 125.41,55.3 125.56,55.46 126.28,55.46 126.73,55.02 127.04,55.02 127.57,54.49 127.57,52.58 127.56,52.57 127.56,52.14 127.57,52.13 127.57,51.68 126.48,50.58 126.48,48.73 126.44,48.7 126.44,48.68
  IN3 w0.135: 126.44,48.68 126.44,47.69 126.89,47.23 126.89,46.93 125.39,45.43 125.39,43.97 124.23,42.81 124.23,40.93 123.49,40.19 123.49,37.67 124.52,36.65 124.52,35.2 124.28,34.96 124.28,32.99 v1(124.05,32.77)
  BOTTOM w0.076: UC1.AD6 124.5,52.72 v1(124.83,52.39)
  BOTTOM w0.112: v1(132.93,27.83) 133.11,28.02 133.11,28.88 132.39,29.61 131.31,29.61 130.31,30.6 129.09,30.6 128.4,31.3 125.97,31.3 125.45,31.82 124.7,31.82 124.23,32.29 124.23,32.58 v1(124.05,32.77)
USB_PN2_R: length 3.4
  TOP w0.112: v1(207.1,35.34) 207.28,35.16 207.28,34.61 207.14,34.47 LU9.4 207.14,34.03 RU16.2
  BOTTOM w0.112: v1(207.1,35.34) 207.3,35.54 207.3,35.75 207.58,36.04 207.58,36.17 207.24,36.51 JIOB1.7
USB_PN3: length 109.1
  IN1 w0.119: v1(89.33,36.63) 89.33,36.63 89.15,36.46 89.15,35.86 87.92,34.63 81.88,34.63 81.66,34.85 75.34,34.85 74.86,35.32 71.47,35.32 68.84,37.95 62.01,37.95 59.32,40.65 51.42,40.65 50.99,41.08 50.03,41.08 49.6,40.66 45.82,40.66 45.09,39.93 40.79,39.93 39.66,41.05 35.93,41.05 34.95,40.07 34.45,40.07 34.11,40.42 34.11,40.68 33.9,40.89 v1(33.9,40.89)
  IN3 w0.076: 117.89,48.68 117.9,48.69 117.9,48.74 119.66,50.5 121.08,50.5 121.5,50.92 121.5,51.72 121.47,51.77 121.5,51.87 v1(121.88,52.09)
  IN3 w0.135: 117.89,48.68 115.99,46.77 115.99,44.28 115.21,43.51 111.69,43.51 109.5,41.32 109.5,39.84 108.11,38.44 107.42,38.44 106.85,37.87 106.1,37.87 104.4,36.17 101.94,36.17 101.57,36.54 98.72,36.54 98.03,37.23 97.38,37.23 95.96,35.81 92.24,35.81 90.59,37.46 89.45,37.46 89.18,37.19 89.18,36.78 v1(89.33,36.63)
  BOTTOM w0.076: UC1.AH3 121.88,51.74 v1(121.88,52.09)
  BOTTOM w0.112: v1(33.9,40.89) 34.13,40.67 34.13,40.44 33.94,40.25 v4(33.66,40.25) 33.33,40.25 32.98,39.9 32.77,39.9 32.63,40.04 LU4.3 32.26,40.04 32.15,40.15 RU8.1
USB_PN3_R: length 24.9
  BOTTOM w0.112: RU8.2 31.1,40.04 LU4.4 30.75,40.04 30.61,39.9 30.36,39.9 29.56,40.7 28.61,40.7 27.59,39.68 27.21,39.68 27.2,39.67 27.2,39.67 27.04,39.67 26.93,39.78 26.93,39.8 26.91,39.83 EU2604.3 26.31,40.52 26.2,40.41 26.2,39.83 26.01,39.64 25.06,39.64 v4(24.13,38.71) 22.2,36.77 22.17,36.77 21.63,36.23 21.63,36.21 20.86,35.44 19.17,35.44 16.7,32.98 16.7,29.47 16.59,29.36 15.99,29.36 15.88,29.47 JUSB2.2
USB_PN4: length 209.5
  TOP w0.112: v1(49.18,106.1) 49.39,106.31 49.93,106.31 50.81,107.19 50.81,110.15 47.37,113.59 47.37,114.49 46.03,115.83 45.42,115.83 44.92,116.34 44.92,116.75 44.18,117.48 44.18,119.41 43.46,120.13 42.49,120.13 41.95,120.66 41.95,123 41.51,123.44 41.51,125.36 40.57,126.3 39.95,126.3 39.67,126.02 36.82,126.02 36.14,126.7 35.07,126.7 32.27,129.49 32.27,130.74 33.37,131.83 34.29,131.83 34.65,132.19 34.65,132.53 v1(34.8,132.67)
  IN3 w0.135: v1(124.83,54.83) 124.8,54.86 124.47,54.86 124.33,54.72 124.33,54.4 123.22,53.29 123.22,52.41 123.91,51.72 123.91,50.48 122.58,49.14 122.58,48.71 122.34,48.48 120.46,48.48 119.54,47.55 119.54,45.12 119.8,44.86 119.8,42.46 119.25,41.91 119.25,41.58 118.83,41.16 118.41,41.16 117.47,40.22 117.47,39.83 114.33,36.69 110.97,36.69 109.53,35.25 106.26,35.25 105.22,34.21 99.86,34.21 99.67,34.03 97.67,34.03 97.42,34.27 88.35,34.27 86.93,35.69 86.43,35.69 85.77,35.04 84.51,35.04 84.36,34.89 84.35,34.89 84,34.54 74.01,34.54 73.75,34.81 72.51,34.81 72.08,35.24 70.51,35.24 69.74,36.01 68.45,36.01 68.06,35.62 61.59,35.62 59.18,38.02 58.76,38.02 56.61,40.17 54.82,40.17 51.39,43.6 51.39,47.43 51.04,47.78 51.04,48.38 50.62,48.81 50.62,49.27 49.65,50.24 49.65,52.52 49.12,53.05 49.12,53.25 47.78,54.59 47.78,56.73 47.15,57.36 47.15,61.5 47.51,61.86 47.51,64.23 47.1,64.64 47.1,66.1 45.77,67.43 45.29,67.43 43.91,68.8 43.91,73.5 42.54,74.88 42.54,81.77 43.68,82.91 44,82.91 48,86.92 48,90.17 48.56,90.73 48.56,94.14 49.65,95.23 49.65,106.12 49.59,106.18 49.26,106.18 v1(49.18,106.1)
  BOTTOM w0.102: UC1.AD9 124.36,54.75 v1(124.83,54.83)
  BOTTOM w0.112: v1(34.8,132.67) 34.63,132.5 34.63,131.05 34.14,130.56 33.87,130.56 33.73,130.41 LT2.2 33.35,130.24 RT41.1
USB_PN4_R: length 2.2
  BOTTOM w0.112: UT3.2 31.02,130.24 31.11,130.32 31.47,130.32 31.69,130.55 31.89,130.55 32.03,130.41 LT2.1 32.44,130.24 RT41.2
USB_PN5: length 151.9
  TOP w0.112: v1(223.55,40.58) 223.19,40.95 223.19,41.28 222.75,41.71 217.96,41.71 216.18,43.5 216.18,44.11 215.93,44.35 215.82,44.35 215.68,44.49 L3.4 215.36,44.49 215.25,44.6 R18.2
  IN1 w0.119: v1(126.3,39.01) 126.48,39.19 126.48,40.05 124.33,42.19 124.33,44.1 125.26,45.03 125.26,46.07 124.93,46.4 124.93,48.56 123.94,49.55 122.83,49.55 121.82,48.54 121.82,48.52 121.7,48.41 121.4,48.41 121.27,48.28 121.27,48.11 v1(121.45,47.93)
  IN3 w0.135: v1(134.65,30.59) 134.84,30.41 134.84,30.18 135.18,29.84 136.76,29.84 138.11,31.19 141.44,31.19 144.36,28.26 144.36,27.29 145.15,26.49 147.61,26.49 148.51,27.39 150.31,27.39 150.91,27.99 156.06,27.99 156.47,27.57 165.34,27.57 166.43,26.47 174.02,26.47 175.99,28.44 179.34,28.44 180.15,29.26 180.15,29.99 181.43,31.28 184.85,31.28 185.71,30.42 211.58,30.42 211.94,30.79 214.74,30.79 215.52,30 217.85,30 217.85,30 219.53,30 221.49,31.96 221.49,33.02 223.54,35.07 223.54,39.4 223.27,39.67 223.27,40.25 223.55,40.53 v1(223.55,40.58)
  BOTTOM w0.076: 121.27,48.68 121.27,48.73 121.23,48.77 121.23,48.88 121.1,49.01 UC1.AJ1
  BOTTOM w0.112: v1(121.45,47.93) 121.27,48.12 121.27,48.68 ; v1(126.3,39.01) 126.53,38.77 126.53,38.4 126.17,38.03 126.17,36.9 127.06,36.01 128.32,36.01 129.73,34.59 130.17,34.59 130.18,34.58 130.91,34.58 130.92,34.59 v4(133.6,34.59) 135.25,34.59 135.53,34.31 135.84,34.31 136.35,33.8 136.35,32.57 134.9,31.12 134.9,30.84 v1(134.65,30.59)
USB_PN6: length 121.5
  TOP w0.112: v1(209.07,34.66) 208.89,34.49 208.89,32.5 209.41,31.99 210.29,31.99 210.38,32.08 210.38,32.3 210.26,32.43 LU8.3 210.1,32.99 RU14.1
  IN1 w0.114: 124.24,52.75 124.26,52.77 124.26,52.77 124.3,52.81 124.3,52.82 124.4,52.92 124.4,55.51 124.65,55.76 125.72,55.76 126.06,55.42 126.06,55.41 126.09,55.38 ; 123.98,52.69 124.17,52.69 124.21,52.73 124.22,52.73 124.24,52.75 ; v1(123.71,52.46) 123.92,52.67
  IN1 w0.119: 124.24,52.75 124.24,52.75 ; 123.92,52.67 123.97,52.68 123.98,52.69 ; v1(127.68,39.28) 127.73,39.28 127.86,39.41 127.86,39.78 126.08,41.56 126.08,43.84 126.67,44.43 126.67,45.75 128.21,47.29 128.21,48.47 128.56,48.82 128.58,48.82 129.11,49.36 129.11,50.68 128.81,50.98 127.99,50.98 127.41,51.56 127.41,53.57 127.16,53.81 126.63,53.81 126.24,54.2 126.24,55.2 126.14,55.32 126.12,55.33 126.09,55.38
  IN3 w0.135: v1(140.79,37.45) 140.79,37.21 141.1,36.89 142.39,36.89 143.32,37.82 147.27,37.82 147.46,37.63 148.77,37.63 149.87,36.53 151.75,36.53 153.2,35.08 161.92,35.08 162.26,35.43 163.84,35.43 164.92,36.51 168.93,36.51 169.62,35.82 177.47,35.82 178.51,36.86 180.04,36.86 180.99,37.82 186.31,37.82 186.91,37.21 195.3,37.21 195.92,36.58 208.31,36.58 208.9,35.99 208.9,34.83 v1(209.07,34.66)
  BOTTOM w0.089: UC1.AF6 123.49,52.46 v1(123.71,52.46)
  BOTTOM w0.112: v1(140.79,37.45) 140.79,37.18 140.95,37.02 140.95,36.68 140.01,35.74 136.12,35.74 135.83,36.03 130.31,36.03 127.87,38.47 127.87,39.08 127.84,39.11 127.84,39.11 v1(127.68,39.28)
USB_PN6_R: length 3.5
  TOP w0.112: v1(210.2,35.18) 210.38,35.01 210.38,34.44 210.26,34.32 LU8.4 210.08,33.9 RU14.2
  BOTTOM w0.112: v1(210.2,35.18) 210.37,35.35 210.37,35.56 210.63,35.82 210.63,35.93 210.52,36.04 210.41,36.04 210.24,36.21 JIOB1.4
USB_PN7: length 199.6
  IN3 w0.135: v1(121.77,49.71) 121.67,49.61 121.4,49.61 121.07,49.94 120,49.94 118.9,48.84 118.88,48.84 116.92,46.88 116.92,43.82 115.94,42.84 111.75,42.84 110.02,41.1 110.02,38.76 108.13,36.87 106.43,36.87 104.77,35.21 99.33,35.21 99.15,35.02 98.08,35.02 97.84,35.27 92.05,35.27 91.07,36.25 89.77,36.25 89.35,35.83 88.32,35.83 87.47,36.69 86,36.69 85.58,36.27 83.02,36.27 82.28,35.54 74.45,35.54 74.18,35.81 72.95,35.81 72.51,36.24 70.96,36.24 69.9,37.3 61.32,37.3 59.6,39.02 59.17,39.02 57.03,41.17 55.31,41.17 52.39,44.09 52.39,47.85 52.04,48.19 52.04,49.41 50.73,50.72 50.73,52.88 50.12,53.49 50.12,53.66 48.78,55 48.78,57.14 48.17,57.75 48.17,61.11 49.09,62.03 49.09,64.23 48.1,65.22 48.1,66.61 45.98,68.73 45.47,68.73 45.28,68.92 45.28,72.06 44.92,72.42 44.92,74 43.54,75.38 43.54,80.2 44.56,81.22 44.93,81.22 45.42,81.72 45.42,82.93 49,86.5 49,89.73 49.58,90.31 49.58,93.7 50.67,94.79 50.67,106.94 55.27,111.54 55.27,112.4 57.79,114.93 60.29,114.93 62.23,112.98 66.03,112.98 66.44,113.39 70.97,113.39 71.89,114.31 74.99,114.31 76.36,115.68 79.18,115.68 79.4,115.9 79.65,115.9 79.66,115.91 v1(80.07,115.91)
  BOTTOM w0.076: UC1.AH1 121.66,50.32 121.58,50.24 121.58,49.78 121.66,49.71 v1(121.77,49.71)
  BOTTOM w0.112: JWLAN1.5 79.9,121.65 79.98,121.57 79.98,121.47 80.08,121.37 80.83,121.37 81.41,120.79 81.41,117.33 80.75,116.67 80.14,116.67 79.89,116.42 79.89,116.02 80,115.91 v1(80.07,115.91)
USB_PN8: length 113.1
  TOP w0.112: R21.2 208.93,40.75 L4.4 209.34,40.61 209.48,40.47 210.05,40.47 210.06,40.49 210.69,40.49 210.7,40.47 211.22,40.47 v1(211.3,40.56)
  IN3 w0.076: 129.61,55.84 129.6,55.85 129.6,55.89 129.57,55.92 129.57,56.21 129.6,56.24 129.6,56.7 129.51,56.79 126.98,56.79 126.58,56.39 126.58,56.25 126.21,55.88 124.22,55.88 123.64,55.29 123.64,54.45 123.19,54 122.83,54 v1(122.7,53.87)
  IN3 w0.135: v1(211.3,40.56) 211.46,40.39 211.73,40.39 212.01,40.12 212.01,39.1 211.32,38.41 205.15,38.41 204.62,37.88 196.26,37.88 195.55,38.59 190.8,38.59 190.41,38.2 187.5,38.2 186.85,38.85 184.7,38.85 184.23,39.31 181.09,39.31 179.63,37.85 178.1,37.85 177.83,37.58 175.63,37.58 175.02,36.97 169.92,36.97 169.39,37.5 163.91,37.5 163.81,37.4 158.24,37.4 157.4,38.24 150.44,38.24 149.77,38.9 148.09,38.9 145.82,41.17 145.12,41.17 143.79,42.51 143.79,43.03 143.79,44.85 143.28,45.37 143.28,46.44 142.64,47.08 142.64,51.33 142.26,51.71 142.26,53.03 140.32,54.96 138.12,54.96 137.83,54.67 137.52,54.36 131.09,54.36 129.61,55.84
  BOTTOM w0.102: v1(122.7,53.87) 122.88,53.82 UC1.AF8
USB_PN8_TPNL: length 9.4
  TOP w0.112: v1(206.79,40.56) 206.9,40.45 207.43,40.45 207.59,40.61 L4.3 207.85,40.61 R21.1
  BOTTOM w0.112: v1(206.79,40.56) 206.91,40.44 207.19,40.44 207.36,40.62 207.36,41.03 207.6,41.27 DA6.3 208.2,41.27 208.44,41.02 208.44,40.52 208.55,40.41 208.75,40.41 208.85,40.51 208.85,40.67 209.4,41.22 209.88,41.22 v4(211.07,42.41) 211.38,42.72 211.75,42.72 211.98,42.95 JEDP1.36
USB_PN9: length 135.7
  IN1 w0.119: v1(126.81,37.52) 126.98,37.69 126.98,37.96 126.78,38.17 126.15,38.17 123.53,40.79 123.53,47.48 123.26,47.75 123.01,47.75 122.85,47.91 122.46,47.91 v1(122.46,47.91)
  IN3 w0.135: v1(213.41,31.69) 213.41,32.39 213.14,32.66 211.67,32.66 210.6,31.6 196.44,31.6 195.64,32.4 193.19,32.4 192.22,31.43 186.11,31.43 185.27,32.27 180.52,32.27 178.37,30.12 175.8,30.12 173.81,28.13 170.32,28.13 169.8,27.61 166.74,27.61 165.28,29.07 150.58,29.07 150.33,28.83 145.21,28.83 141.67,32.37 136.71,32.37 136.27,31.92 136.27,31.37 v1(136.1,31.2)
  BOTTOM w0.076: 122.41,49.54 122.42,49.55 122.43,49.55 122.45,49.6 122.51,49.63 122.67,49.8 122.67,49.84 122.68,49.84 122.68,50.03 122.6,50.11 122.52,50.11 122.43,50.01 UC1.AG1
  BOTTOM w0.094: 122.34,49.36 122.34,49.38 122.35,49.39 122.35,49.44 122.39,49.49 122.41,49.54
  BOTTOM w0.112: v1(126.81,37.52) 126.99,37.33 126.99,37.08 127.35,36.72 128.61,36.72 130.01,35.32 135.53,35.32 135.82,35.03 136.13,35.03 137.06,34.1 137.06,32.28 136.3,31.51 136.3,31.4 v1(136.1,31.2) ; v1(213.41,31.69) 213.02,32.08 213.02,32.98 212.13,33.87 212.13,34.75 212.78,35.4 214.14,35.4 214.56,35.82 218.87,35.82 219.5,36.46 219.92,36.46 220.59,35.79 220.59,34.82 219.92,34.15 219.92,33.96 219.6,33.64 218.98,33.64 218.84,33.5 EU2701.3 219.05,33.08 219.49,33.08 219.6,32.97 219.6,32.49 219.1,31.99 218.96,31.99 218.66,31.69 218.66,31.5 218.52,31.36 JFP.4 ; v1(122.46,47.91) 122.46,47.91 122.46,48.28 122.32,48.42 122.32,48.68 122.34,48.7 122.34,49.36
USB_PN10: length 127.7
  TOP w0.112: v1(218.65,53.41) 218.47,53.24 JWWAN.12
  IN3 w0.076: v1(121.75,53.7) 121.9,53.86 122.18,53.86 122.35,54.02 122.35,55.12 123.54,56.32 124.54,56.32 125.64,57.41 126.32,57.41 126.53,57.21 129.64,57.21 130.02,56.83 130.02,56.72 130.55,56.19 131.64,56.19 132.15,55.68 136.05,55.68 136.24,55.88 136.94,55.88 137.05,55.76 137.6,55.76 137.64,55.72 137.66,55.72
  IN3 w0.135: v1(218.65,53.41) 219.28,53.41 219.67,53.03 219.67,49.63 214.93,44.89 214.93,43.82 214.18,43.07 212.41,43.07 210.4,41.05 207.73,41.05 207.21,41.58 206.47,41.58 204.88,39.99 204.12,39.99 203.71,39.58 201.94,39.58 201.48,39.12 196.58,39.12 196.1,39.6 185.01,39.6 184.51,40.1 180.81,40.1 179.31,38.61 177.79,38.61 177.54,38.36 174.22,38.36 173.2,39.38 166.22,39.38 165.94,39.1 165.38,39.1 164.53,38.25 163.6,38.25 163.51,38.16 158.55,38.16 157.72,38.99 150.75,38.99 150.08,39.66 148.4,39.66 145.92,42.15 145.22,42.15 144.55,42.82 144.55,47.71 143.87,48.38 143.87,52.6 140.75,55.72 137.66,55.72
  BOTTOM w0.076: v1(121.75,53.7) 121.75,53.65 122.03,53.37 UC1.AH7
USB_POWERSHARE_VBUS_EN: length 68.9
  TOP w0.089: UU2.5 35.56,47.69 v2(35.92,47.33) 35.92,45.96 RU25.1 34.65,44.68 v1(34.52,44.68)
  TOP w0.102: v1(47.61,81.04) 47.11,81.55 47.11,82.29 47.35,82.53 UE1.71
  IN1 w0.102: v1(34.76,83.78) 35.06,84.08 35.91,84.08 37,82.99 47.75,82.99 48.19,82.55 48.19,81.44 47.79,81.04 47.61,81.04 v1(47.61,81.04)
  IN2 w0.089: v1(34.76,83.78) 34.5,83.52 34.5,78.67 33.91,78.08 33.91,76.76 33.54,76.39 33.54,74.18 34.31,73.41 34.31,70.49 32.88,69.06 32.88,66.71 35.51,64.09 35.51,63.01 34.62,62.13 32.98,62.13 v1(32.58,61.73)
  BOTTOM w0.089: v1(32.58,61.73) 32.58,59.26 33.27,58.57 33.27,57.24 34.58,55.93 34.58,51.6 35.74,50.44 35.74,46.32 34.52,45.1 v1(34.52,44.68)
USB_PP1: length 149.4
  TOP w0.112: RU21.1 33.52,45.53 v1(33.52,45.83) 33.36,45.99 33.36,46.34 33.53,46.5 UU2.3
  IN1 w0.119: v1(31.34,57.78) 31.15,57.97 30.63,57.97 29.9,57.24 29.9,53.25 31.81,51.34 31.81,48.14 33.42,46.53 33.42,45.93 v1(33.52,45.83)
  IN3 w0.076: 124.44,50.03 124.44,50.75 125.72,52.03 126.07,52.03 126.4,52.36 126.4,54.69 126.22,54.88 125.91,54.88 125.8,54.99 v1(125.8,55.1)
  IN3 w0.135: v1(31.34,57.78) 34.3,57.78 34.92,57.16 39.02,57.16 40.24,58.38 40.78,58.38 41.27,57.88 42.25,57.88 42.48,58.12 45.32,58.12 47.02,56.41 47.02,52.92 47.32,52.62 47.32,49.87 47.95,49.25 49.1,49.25 50.29,48.07 50.29,47.46 50.63,47.12 50.63,43.29 51.37,42.55 51.37,42.39 54.34,39.41 54.51,39.41 54.51,39.41 55.13,39.41 55.13,39.41 56.3,39.41 58.97,36.74 59.34,36.74 61.21,34.86 68.4,34.86 68.79,35.25 69.44,35.25 70.2,34.49 71.61,34.49 72.05,34.05 73.27,34.05 73.57,33.75 74.62,33.75 76.13,32.24 79.96,32.24 80.49,32.77 81.9,32.77 82.09,32.58 84.08,32.58 85.26,33.76 86.32,33.76 87.46,32.63 96.54,32.63 96.88,32.28 100.18,32.28 100.84,32.94 105.84,32.94 106.87,33.97 110.16,33.97 111.46,35.28 114.36,35.28 114.86,34.78 116.16,34.78 117,35.62 117,36.46 118.27,37.73 119.52,37.73 119.65,37.87 119.66,37.87 120.02,38.23 120.02,40.54 120.6,41.13 120.6,41.47 123.48,44.35 123.48,44.55 123.48,46.17 123.86,46.54 123.86,47.18 124.4,47.72 124.4,48.67 124.4,49.99 124.44,50.03
  BOTTOM w0.094: UC1.AB10 125.52,55.16 125.74,55.16 v1(125.8,55.1)
USB_PP1_R: length 25.5
  TOP w0.112: v1(18.35,56.39) 18.5,56.23 18.66,56.23 18.83,56.4 19.7,56.4 20.28,55.82 23.2,55.82 23.31,55.93 25.92,55.93 25.93,55.94 26.5,55.94 26.51,55.93 28,55.93 28.11,56.03 28.11,56.52 EU2602.2 28.57,56.52 28.57,56.11 28.79,55.9 29.06,55.9 30.87,54.08 v4(31.62,54.08) 32.99,54.08 33.32,53.75 33.32,53.46 33.45,53.33 LU1.1 33.45,53 RU1.2
  IN3 w0.135: JUSB1.3 15.88,52.6 14.93,53.55 14.93,54.65 16.49,56.22 18.18,56.22 v1(18.35,56.39)
USB_PP2: length 127.1
  TOP w0.112: RU15.1 207.75,32.99 LU9.2 207.64,32.63 207.5,32.49 207.5,32.09 207.27,31.86 205.59,31.86 203.31,34.13 203.31,34.58 v1(203.12,34.78)
  IN1 w0.119: v1(203.12,34.78) 203.28,34.94 203.28,35.36 201.66,36.98 197.8,36.98 197.3,37.48 192.28,37.48 191.91,37.11 186.66,37.11 186.27,37.49 178.2,37.49 177.91,37.2 174.43,37.2 173.43,36.2 164.52,36.2 164.4,36.33 160.01,36.33 158.98,35.3 157,35.3 154.96,33.26 154.11,33.26 152.76,31.91 150.88,31.91 149.67,30.7 146.44,30.7 145.87,31.27 139.82,31.27 136.3,27.74 134.29,27.74 133.78,28.25 133.5,28.25 133.34,28.09 133.34,28.01 v1(133.51,27.83)
  IN3 w0.076: 126.68,48.68 126.68,48.7 126.64,48.73 126.64,50.52 127.73,51.61 127.73,52.2 127.73,52.21 127.73,52.5 127.73,52.51 127.73,54.55 127.11,55.18 126.79,55.18 126.35,55.62 125.49,55.62 125.24,55.37 125.24,54.15 125.31,54.08 125.31,52.92 125.23,52.84 125.12,52.84 v1(124.83,53.13)
  IN3 w0.135: v1(124.63,32.77) 124.52,32.88 124.52,34.86 124.76,35.1 124.76,36.75 123.74,37.77 123.74,40.09 124.47,40.83 124.47,42.71 125.63,43.87 125.63,45.33 127.13,46.83 127.13,47.33 126.68,47.79 126.68,48.68
  BOTTOM w0.076: UC1.AD7 124.6,53.37 v1(124.83,53.13)
  BOTTOM w0.112: v1(133.51,27.83) 133.33,28.02 133.33,28.98 132.48,29.83 131.4,29.83 130.4,30.83 129.19,30.83 128.49,31.52 126.06,31.52 125.54,32.04 124.79,32.04 124.45,32.38 124.45,32.58 v1(124.63,32.77)
USB_PP2_R: length 3.4
  TOP w0.112: RU15.2 207.64,34.03 LU9.1 207.64,34.49 207.5,34.63 207.5,35.16 v1(207.68,35.34)
  BOTTOM w0.112: JIOB1.6 208.24,36.55 207.8,36.11 207.8,35.95 207.52,35.66 207.52,35.5 v1(207.68,35.34)
USB_PP3: length 109.8
  TOP w0.089: v2(120.47,50.78) 120.47,51.3 v1(120.68,51.52)
  IN1 w0.119: v1(34.49,40.89) 34.33,40.73 34.33,40.51 34.54,40.29 34.86,40.29 35.84,41.27 39.75,41.27 40.88,40.14 45,40.14 45.73,40.88 49.51,40.88 49.93,41.3 51.08,41.3 51.51,40.87 59.41,40.87 62.11,38.17 68.94,38.17 71.56,35.54 74.95,35.54 75.43,35.07 81.75,35.07 81.97,34.84 87.83,34.84 88.93,35.95 88.93,36.44 v1(88.74,36.63)
  IN3 w0.076: v1(120.68,51.52) 121.18,51.8 121.28,51.77 121.34,51.68 121.34,50.99 121.01,50.67 119.59,50.67 117.79,48.86 117.73,48.86 117.72,48.85
  IN3 w0.135: 117.72,48.85 115.74,46.87 115.74,44.38 115.11,43.75 111.59,43.75 109.26,41.42 109.26,39.94 108.01,38.68 107.32,38.68 106.75,38.11 106,38.11 104.3,36.42 102.04,36.42 101.67,36.78 98.82,36.78 98.13,37.47 97.28,37.47 95.86,36.05 92.34,36.05 90.69,37.7 89.35,37.7 88.94,37.29 88.94,36.83 v1(88.74,36.63)
  BOTTOM w0.076: UC1.AJ3 120.88,51.52 v1(120.68,51.52)
  BOTTOM w0.112: RU7.1 32.28,39.54 LU4.2 32.57,39.54 32.71,39.68 33.07,39.68 33.41,40.01 34.02,40.01 34.35,40.35 34.35,40.75 v1(34.49,40.89)
USB_PP3_R: length 24.8
  BOTTOM w0.112: RU7.2 31.1,39.54 LU4.1 30.78,39.54 30.64,39.68 30.27,39.68 29.47,40.48 28.7,40.48 27.68,39.46 27.42,39.46 27.42,39.45 27.04,39.45 26.93,39.33 26.93,39.31 26.91,39.28 EU2604.2 26.37,38.59 26.26,38.7 26.26,39.24 26.08,39.42 25.15,39.42 24.52,38.78 24.52,38.77 24.08,38.32 24.06,38.32 v4(22.06,36.33) 21.88,36.15 21.79,36.05 20.95,35.22 19.26,35.22 16.93,32.89 16.93,29.38 16.68,29.14 15.99,29.14 15.88,29.03 JUSB2.3
USB_PP4: length 209.1
  TOP w0.112: v1(34.22,132.67) 34.43,132.46 34.43,132.29 34.2,132.06 33.28,132.06 32.05,130.83 32.05,129.4 34.98,126.47 36.05,126.47 36.73,125.8 39.76,125.8 40.05,126.08 40.48,126.08 41.29,125.27 41.29,123.35 41.73,122.91 41.73,120.57 42.39,119.91 43.37,119.91 43.96,119.32 43.96,117.39 44.69,116.66 44.69,116.24 45.33,115.61 45.94,115.61 47.15,114.4 47.15,113.5 50.59,110.06 50.59,107.28 49.84,106.53 49.36,106.53 v1(49.18,106.7)
  IN3 w0.135: v1(124.83,55.39) 124.53,55.08 124.31,55.08 124.11,54.88 124.11,54.5 123,53.39 123,52.31 123.69,51.63 123.69,50.57 122.35,49.24 122.35,48.81 122.25,48.7 120.34,48.7 119.3,47.65 119.3,45.02 119.55,44.76 119.55,42.56 119.01,42.01 119.01,41.68 118.73,41.4 118.31,41.4 117.23,40.32 117.23,39.93 114.23,36.93 110.87,36.93 109.43,35.49 106.16,35.49 105.12,34.45 99.75,34.45 99.57,34.27 97.77,34.27 97.52,34.51 88.45,34.51 87.03,35.94 86.33,35.94 85.67,35.28 84.41,35.28 84.26,35.13 84.25,35.13 83.9,34.78 74.11,34.78 73.85,35.05 72.61,35.05 72.18,35.49 70.61,35.49 69.84,36.25 68.35,36.25 67.96,35.86 61.69,35.86 59.28,38.27 58.86,38.27 56.71,40.41 54.92,40.41 51.63,43.7 51.63,47.53 51.28,47.88 51.28,48.48 50.86,48.91 50.86,49.37 49.89,50.34 49.89,52.62 49.37,53.15 49.37,53.35 48.02,54.69 48.02,56.83 47.39,57.46 47.39,61.4 47.75,61.76 47.75,64.33 47.34,64.74 47.34,66.2 45.87,67.67 45.39,67.67 44.16,68.9 44.16,73.6 42.78,74.98 42.78,81.67 43.78,82.67 44.1,82.67 48.24,86.82 48.24,90.07 48.8,90.63 48.8,94.04 49.89,95.13 49.89,106.22 49.69,106.42 49.46,106.42 v1(49.18,106.7)
  BOTTOM w0.076: UC1.AD10 124.48,55.14 124.59,55.14 v1(124.83,55.39)
  BOTTOM w0.112: RT42.1 33.39,131.04 LT2.3 33.74,130.91 33.87,130.78 34.05,130.78 34.41,131.14 34.41,132.48 v1(34.22,132.67)
USB_PP4_R: length 2.1
  BOTTOM w0.112: UT3.1 30.99,130.64 31.08,130.54 31.37,130.54 31.6,130.77 31.86,130.77 32,130.91 LT2.4 32.31,130.91 RT42.2
USB_PP5: length 151.9
  TOP w0.112: v1(222.97,40.58) 222.97,41.19 222.66,41.49 217.87,41.49 215.95,43.41 215.95,44.02 215.84,44.13 215.76,44.13 215.62,43.99 L3.1 215.38,43.99 R17.2
  IN1 w0.119: v1(120.87,47.91) 121.05,48.09 121.05,48.37 121.31,48.63 121.6,48.63 121.6,48.63 121.8,48.83 121.82,48.83 122.74,49.75 124.02,49.75 124.94,48.83 124.96,48.83 125.14,48.65 125.14,46.49 125.48,46.16 125.48,44.94 124.55,44.01 124.55,42.28 126.69,40.14 126.69,39.19 v1(126.88,39.01)
  IN3 w0.135: v1(135.24,30.59) 135.08,30.43 135.08,30.28 135.28,30.08 136.66,30.08 138.01,31.43 141.54,31.43 144.6,28.36 144.6,27.39 145.25,26.74 147.51,26.74 148.41,27.63 150.21,27.63 150.81,28.23 156.16,28.23 156.57,27.81 165.44,27.81 166.53,26.71 173.92,26.71 175.89,28.68 179.24,28.68 179.91,29.36 179.91,30.09 181.33,31.52 184.95,31.52 185.81,30.67 211.48,30.67 211.84,31.03 214.84,31.03 215.62,30.24 217.75,30.24 217.75,30.25 219.43,30.25 221.25,32.06 221.25,33.12 223.3,35.17 223.3,39.3 223.03,39.57 223.03,40.52 v1(222.97,40.58)
  BOTTOM w0.076: UC1.AJ2 121.1,50.4 120.85,50.14 120.85,49.84 120.94,49.75 120.94,48.94 121.05,48.83 121.05,48.68
  BOTTOM w0.112: v1(126.88,39.01) 126.76,38.88 126.76,38.3 126.39,37.94 126.39,36.99 127.15,36.23 128.41,36.23 129.82,34.81 v4(130.56,34.81) 133.29,34.81 133.3,34.83 133.92,34.83 133.93,34.81 135.34,34.81 135.62,34.53 135.93,34.53 136.57,33.89 136.57,32.48 135.12,31.03 135.12,30.71 v1(135.24,30.59) ; 121.05,48.68 121.05,48.09 v1(120.87,47.91)
USB_PP6: length 121.4
  TOP w0.112: v1(208.48,34.66) 208.67,34.48 208.67,32.41 209.33,31.75 v4(209.81,31.75) 210.37,31.75 210.61,31.99 210.61,32.35 210.76,32.5 LU8.2 210.89,32.95 RU13.1
  IN1 w0.114: 124.09,52.9 124.2,53 124.2,55.59 124.57,55.96 125.8,55.96 126.26,55.51 ; 124.09,52.89 123.92,52.89 v1(123.71,53.1)
  IN1 w0.119: 126.26,55.51 126.27,55.5 126.45,55.27 126.45,54.29 126.72,54.02 127.25,54.02 127.62,53.65 127.62,51.65 128.08,51.19 128.9,51.19 129.32,50.77 129.32,49.27 128.43,48.38 128.43,47.2 126.89,45.66 126.89,44.34 126.3,43.75 126.3,41.65 128.08,39.87 128.08,39.46 v1(128.26,39.28) ; 124.09,52.89 124.09,52.9
  IN3 w0.135: v1(208.48,34.66) 208.66,34.84 208.66,35.89 208.21,36.34 195.82,36.34 195.2,36.97 186.81,36.97 186.21,37.57 181.09,37.57 180.14,36.62 178.61,36.62 177.57,35.58 169.52,35.58 168.83,36.27 165.02,36.27 163.94,35.19 162.36,35.19 162.02,34.84 153.31,34.84 153.26,34.84 153.25,34.84 153.1,34.84 151.65,36.29 149.77,36.29 148.67,37.39 147.36,37.39 147.17,37.58 143.42,37.58 142.49,36.65 141,36.65 140.61,37.04 v1(140.37,37.04)
  BOTTOM w0.089: v1(123.71,53.1) 123.5,53.1 UC1.AF7
  BOTTOM w0.112: v1(140.37,37.04) 140.62,37.04 140.73,36.93 140.73,36.77 139.92,35.96 136.21,35.96 135.92,36.25 130.4,36.25 128.09,38.56 128.09,39.16 128.21,39.28 v1(128.26,39.28)
USB_PP6_R: length 3.5
  TOP w0.112: v1(210.78,35.18) 210.6,35 210.6,34.49 210.76,34.33 LU8.1 210.76,34.03 RU13.2
  BOTTOM w0.112: v1(210.78,35.18) 210.59,35.38 210.59,35.47 210.85,35.73 210.85,35.93 210.96,36.04 211.06,36.04 211.24,36.22 JIOB1.3
USB_PP7: length 199.7
  IN3 w0.135: v1(79.48,116.32) 79.08,115.92 76.26,115.92 74.89,114.55 71.79,114.55 70.87,113.63 66.34,113.63 65.93,113.22 62.33,113.22 60.39,115.17 57.69,115.17 55.03,112.5 55.03,111.64 50.43,107.04 50.43,94.89 49.34,93.8 49.34,90.41 48.76,89.83 48.76,86.6 45.18,83.03 45.18,81.82 44.83,81.47 44.46,81.47 43.29,80.3 43.29,75.28 44.67,73.9 44.67,72.32 45.04,71.96 45.04,68.82 45.37,68.49 45.88,68.49 47.86,66.51 47.86,65.12 48.85,64.13 48.85,62.13 47.93,61.21 47.93,57.65 48.54,57.04 48.54,54.9 49.88,53.56 49.88,53.39 50.49,52.78 50.49,50.62 51.8,49.31 51.8,48.09 52.14,47.75 52.14,43.99 55.21,40.92 56.93,40.92 59.07,38.78 59.5,38.78 61.22,37.06 69.8,37.06 70.86,36 72.41,36 72.85,35.56 74.08,35.56 74.35,35.3 82.38,35.3 83.12,36.03 85.68,36.03 86.1,36.45 87.37,36.45 88.22,35.59 89.45,35.59 89.87,36.01 90.97,36.01 91.95,35.03 97.74,35.03 97.98,34.78 99.25,34.78 99.43,34.97 104.87,34.97 106.53,36.63 108.23,36.63 110.26,38.66 110.26,41 111.85,42.6 116.04,42.6 117.17,43.72 117.17,46.78 120.1,49.72 120.98,49.72 v1(121.47,49.22)
  BOTTOM w0.076: UC1.AH2 121.76,50.92 121.41,50.57 121.41,49.28 v1(121.47,49.22)
  BOTTOM w0.112: v1(79.48,116.32) 80.05,116.89 80.66,116.89 81.19,117.42 81.19,120.7 80.74,121.15 JWLAN1.3
USB_PP8: length 112.8
  TOP w0.112: R20.2 208.94,39.98 L4.1 209.35,40.11 209.49,40.25 v4(210.37,40.25) 211.02,40.25 v1(211.3,39.97)
  IN3 w0.076: 129.76,56 129.76,56.77 129.58,56.95 126.91,56.95 126.41,56.46 126.41,56.32 126.14,56.04 124.15,56.04 123.47,55.36 123.47,54.51 123.12,54.17 122.9,54.17 122.7,54.36 v1(122.7,54.48)
  IN3 w0.135: v1(211.3,39.97) 211.48,40.15 211.63,40.15 211.77,40.02 211.77,39.2 211.22,38.65 205.05,38.65 204.52,38.12 196.36,38.12 195.65,38.83 190.7,38.83 190.31,38.44 187.6,38.44 186.95,39.09 184.8,39.09 184.33,39.56 180.99,39.56 179.53,38.09 178,38.09 177.73,37.82 175.53,37.82 174.92,37.21 170.02,37.21 169.49,37.74 163.81,37.74 163.71,37.64 158.34,37.64 157.5,38.48 150.54,38.48 149.87,39.14 148.19,39.14 145.92,41.42 145.23,41.42 144.03,42.61 144.03,42.93 144.03,44.95 143.52,45.47 143.52,46.54 142.88,47.18 142.88,51.43 142.5,51.81 142.5,53.13 140.42,55.2 138.02,55.2 137.5,54.68 137.5,54.66 137.43,54.58 131.18,54.58 129.76,56
  BOTTOM w0.102: v1(122.7,54.48) 122.83,54.28 122.97,54.26 123.18,54.39 UC1.AF9
USB_PP8_TPNL: length 9.5
  TOP w0.112: v1(206.79,39.97) 206.79,40.04 206.9,40.15 206.97,40.15 207.05,40.23 207.45,40.23 207.57,40.11 L4.2 207.85,40.11 R20.1
  BOTTOM w0.112: JEDP1.37 211.85,42.45 211.79,42.5 211.49,42.5 211.05,42.06 211.03,42.06 209.97,41 209.49,41 209.07,40.58 209.07,40.42 208.84,40.19 208.68,40.19 208.57,40.08 208.57,39.58 208.33,39.34 DA6.2 207.72,39.34 207.48,39.58 207.48,40.09 207.34,40.22 207.04,40.22 206.79,39.98 v1(206.79,39.97)
USB_PP9: length 135.6
  IN1 w0.119: v1(122.94,48.37) 122.94,48.13 123.1,47.97 123.35,47.97 123.75,47.57 123.75,40.88 126.24,38.39 126.87,38.39 127.2,38.05 127.2,37.71 v1(127.39,37.52)
  IN3 w0.135: v1(212.8,31.69) 213.17,32.06 213.17,32.29 213.04,32.42 211.77,32.42 210.7,31.36 196.34,31.36 195.54,32.16 193.29,32.16 192.32,31.19 186.01,31.19 185.17,32.03 180.62,32.03 178.47,29.88 175.9,29.88 173.91,27.88 170.42,27.88 169.9,27.37 166.64,27.37 165.18,28.83 150.68,28.83 150.43,28.59 145.11,28.59 141.57,32.13 136.81,32.13 136.51,31.82 136.51,31.37 v1(136.68,31.2)
  BOTTOM w0.076: 122.58,49.47 122.59,49.48 122.6,49.49 122.84,49.73 122.84,49.77 122.85,49.77 122.85,50.1 122.84,50.1 122.84,50.16 122.84,50.17 122.84,50.3 122.63,50.6 UC1.AG2
  BOTTOM w0.094: 122.54,49.36 122.58,49.41 122.58,49.47
  BOTTOM w0.112: v1(122.94,48.37) 122.68,48.37 122.54,48.51 122.54,49.36 ; v1(212.8,31.69) 212.8,32.89 211.91,33.78 211.91,34.84 212.3,35.23 212.69,35.62 214.05,35.62 214.47,36.04 218.77,36.04 219.41,36.68 220.01,36.68 220.81,35.88 220.81,34.73 220.14,34.06 220.14,33.92 EU2701.2 220.51,33.03 220,33.03 219.82,32.85 219.82,32.4 219.19,31.77 219.05,31.77 218.88,31.6 218.88,31.52 219.02,31.38 JFP.3 ; v1(136.68,31.2) 136.61,31.2 136.52,31.29 136.52,31.42 137.28,32.18 137.28,34.19 136.23,35.25 135.91,35.25 135.62,35.54 130.1,35.54 128.7,36.94 127.45,36.94 127.21,37.17 127.21,37.34 v1(127.39,37.52)
USB_PP10: length 127.5
  TOP w0.112: v1(218.65,52.82) 218.45,53.02 217.89,53.02 217.61,52.74 JWWAN.11
  IN3 w0.076: v1(121.75,54.34) 121.75,54.18 121.91,54.02 122.12,54.02 122.18,54.09 122.18,55.19 123.47,56.49 124.48,56.49 125.57,57.58 126.39,57.58 126.59,57.37 129.71,57.37 130.18,56.9 130.18,56.79 130.62,56.36 131.71,56.36 132.22,55.85 135.98,55.85 136.17,56.04 137.01,56.04 137.12,55.93 137.6,55.93 137.64,55.96 137.66,55.96
  IN3 w0.135: v1(218.65,52.82) 218.84,52.82 218.94,52.92 218.94,53.11 219.01,53.17 219.18,53.17 219.43,52.93 219.43,49.73 214.69,44.99 214.69,43.92 214.08,43.32 212.31,43.32 210.3,41.3 207.83,41.3 207.31,41.82 206.37,41.82 204.78,40.23 204.02,40.23 203.61,39.82 201.84,39.82 201.38,39.37 196.68,39.37 196.2,39.85 185.11,39.85 184.61,40.34 180.71,40.34 179.21,38.85 177.69,38.85 177.44,38.6 174.32,38.6 173.3,39.62 166.12,39.62 165.84,39.34 165.28,39.34 164.43,38.5 163.5,38.5 163.41,38.4 158.65,38.4 157.82,39.23 150.85,39.23 150.18,39.9 148.5,39.9 146.02,42.39 145.32,42.39 144.79,42.92 144.79,47.81 144.12,48.48 144.12,52.7 140.85,55.96 137.66,55.96
  BOTTOM w0.076: v1(121.75,54.34) 121.75,54.18 121.91,54.02 UC1.AH8
