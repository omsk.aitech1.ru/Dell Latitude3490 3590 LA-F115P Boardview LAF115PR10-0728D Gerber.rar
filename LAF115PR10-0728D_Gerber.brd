# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.0V_SRAM: length 51.5
  TOP w0.089: v1(147.47,42.36) v2(147.47,43.33)
  TOP w0.508: v1(147.47,42.36) 146.94,42.36 146.38,42.92 CC62.1 146.18,43.54 RC161.2
  IN2 w0.254: v1(147.47,42.36) 148.02,42.36 148.54,42.87 148.54,46.48 147.32,47.7 145.5,47.7 144.52,46.72 144.52,45.93 144.24,45.65 143.43,45.65 142.89,46.19 142.89,47.41 145.36,49.88 145.36,50.64 145.03,50.97 143.27,50.97 142.76,51.48 142.76,51.99 142.27,52.49 141.34,52.49 140.7,51.84 139.63,51.84 138.76,50.97 132.51,50.97 130.77,52.7 130.77,54.43 129.73,55.47 129.73,56.42 128.81,57.34 128.41,57.34 127.77,57.97 127.77,59.66 127.35,60.08 v1(127.35,61.68)
  BOTTOM w0.254: UC1.AF20 123.89,61.7 v1(123.98,61.7) 123.66,62.02 UC1.AF21 ; UC1.T19 UC1.T20 127.65,61.37 v1(127.35,61.68)
+1.0V_VCCST: length 199.7
  TOP w0.254: v1(132.17,95.29) 131.99,95.47 RC138.2
  TOP w0.508: CC44.1 v3(103.94,106.41) 103.94,107.76 v1(103.29,108.41) ; 134.92,60.87 135.52,60.87 136.01,60.38 v1(137.52,60.38) ; PCZ24.1 PRZ40.1 PRZ41.1 PRZ42.1 PRZ43.1 175.44,61.07 175.44,60.8 v1(175.9,60.33)
  IN2 w0.381: v1(132.17,95.29) 132.17,95.24 130.84,93.9 126.97,93.9 123.61,90.53 123.61,85.45 122.67,84.51 122.67,83.72 122.14,83.2 122.14,82.16 120.55,80.57 120.55,72.95 120.02,72.42 120.02,68.51 120.49,68.05 120.49,63.85 121.23,63.12 121.6,63.12 121.6,63.11 122.3,63.11 122.3,63.1 130.15,63.1 130.61,62.65 131.27,62.65 131.5,62.42 131.5,61.51 v1(131.63,61.37)
  IN2 w0.508: v1(175.9,60.33) 174.18,62.06 174.18,64.63 v1(173.75,65.06) ; v1(137.52,60.38) 138.35,60.38 139.23,61.25 141.41,61.25 142.53,60.14 142.53,55.55 145.01,53.07 146.16,53.07 146.71,53.62 148.25,53.62 149.47,52.4 149.47,48.62 151.04,47.05 156.36,47.05 156.44,46.96 ; 156.44,46.96 156.44,38.87 158,37.32 v1(158,36.76) ; 156.44,46.96 157.76,48.28 159.69,48.28 162.02,50.61 162.02,54.81 163.74,56.52 164.14,56.52 v1(164.75,57.13) ; v1(103.29,108.41) 103.63,108.08 118.02,108.08 118.3,107.8 122.53,107.8 127.5,102.83 127.5,98.69 129.9,96.29 131.17,96.29 v1(132.17,95.29)
  BOTTOM w0.203: v1(137.52,60.38) 137.41,60.27 UC1.A18
  BOTTOM w0.508: v1(173.75,65.06) 172.78,65.06 168.36,60.64 168.36,58.13 167.93,57.7 165.16,57.7 164.75,57.3 v1(164.75,57.13) ; v1(132.17,95.29) 132.89,96 134.45,96 135.12,95.33 140.71,95.33 141.35,94.7 141.35,94.5 142.24,93.61 142.24,90.42 143.13,89.52 RC104.2 RC154.1 143.13,86.14 RC152.1 RC112.1 RC111.1
+1.0V_VCCSTG: length 107.8
  TOP w0.254: CC42.1 137.77,62.08 v1(137.1,62.76)
  TOP w0.508: RC142.2 RC141.2 RC140.2 ; RC140.2 127.76,97.33 v1(127.62,97.47) ; RC140.2 RC113.1
  IN1 w0.254: 131.62,62.21 131.62,62.04 131.87,61.78 132.41,61.78 132.81,61.38 ; v1(137.1,62.76) 136.17,61.83 133.26,61.83 132.81,61.38 ; 132.81,61.38 v1(132.81,61.31) ; 133.99,70.6 133.41,70.02 133.26,70.18 133.26,70.97 133.36,71.08 133.36,71.52 133.02,71.86 132.57,71.86 132.19,72.25 132.19,72.78 132.98,72.78 133.99,71.76 133.99,70.6 ; 131.68,73.67 130.77,74.58 130.77,77.3 130.87,77.4 130.87,78.2 131.2,78.53 131.57,78.53 131.57,78.1 131.68,77.99 131.68,73.67
  IN1 w0.508: 131.57,78.53 131.59,78.56 131.59,80.12 131.79,80.32 131.79,81.7 131.49,82 131.49,83.91 130.24,85.16 130.24,90.15 127.62,92.76 v1(127.62,97.47) ; 131.68,73.67 132.19,73.16 132.19,72.78 ; 133.41,70.02 133.41,69.25 132.5,68.34 132.5,68.33 131.62,67.45 131.62,62.21
  IN2 w0.508: 136.59,60.07 137.12,59.54 138.36,59.54 139.47,60.65 141.16,60.65 141.92,59.89 141.92,55.3 144.76,52.46 146.43,52.46 146.98,53.01 147.85,53.01 148.87,51.99 148.87,48.26 150.68,46.44 155.29,46.44 155.8,45.93 155.8,37.84
  BOTTOM w0.229: UC1.A22 137.09,62.75 v1(137.1,62.76)
  BOTTOM w0.254: v1(132.81,61.31) 132.81,61.17 UC1.G20
  vias: v1(155.42,36.73) v1(156,36.73) v1(156.61,36.73) v3(156.52,35.19)
+1.0V_XDP: length 4.2
  TOP w0.089: RC143.1 129.16,50.45 v3(131.01,52.29)
  TOP w0.508: RC143.1 129.16,49.85 129.29,49.72 RC149.2
+1.0VS_VCCIO: length 39
  TOP w0.254: RC4.1 142.01,82.51 v1(141.55,82.97)
  TOP w1.524: 155.1,39.18 154.59,39.69 154.59,41.84 155.48,42.73 155.48,47.4
  IN2 w0.305: v1(141.55,82.97) 142.25,82.27 142.25,79.46 139.67,76.89 139.17,76.89 139.11,76.95 136.75,76.95 136.73,76.96 135.7,76.96 135.13,76.39 135.13,75.93
  IN2 w0.381: 132.22,75.37 131.45,74.61 129.96,74.61 128.76,75.8 124.52,75.8 124.06,76.26 121.32,76.26 121.02,75.96 121.02,73.74
  vias: v1(120.04,74.13) v1(119.95,67.74) v1(121.4,66.82) v1(121.47,73.23) v1(121.81,67.26) v1(121.81,66.39) v1(149.62,57.79) v1(149.62,57.15) v1(149.85,56.26) v1(149.85,55.63) v1(149.85,54.99) v1(150.25,57.77) v1(155.18,49.31) v1(155.46,49.89) v1(155.79,49.33) v1(155.94,50.27) v1(156.27,49.72) v3(148.88,56.37)
+1.2V_DDR: length 89.1
  TOP w0.381: 97.43,101.98 97.87,102.42 102.92,102.42 CC1.1 104.11,102.29 104.2,102.21 UC2.5
  BOTTOM w0.152: UC1.BB23 114.1,62.84 114.08,62.83 112.95,62.83 112.84,62.72 v1(112.82,62.72) ; UC1.BB41 112.96,72.78
  BOTTOM w0.178: UC1.BB47 113.72,76.43 113.37,76.43 v1(113.31,76.39) ; v1(113.35,67.84) 113.38,67.81 114.11,67.81 114.13,67.82 UC1.BB32
  BOTTOM w0.203: UC1.BB51 v1(113.37,78.89)
  BOTTOM w0.254: v1(116.66,74.15) 117.03,73.77 UC1.AU42 ; v1(117.33,70.48) 117.32,70.48 117.03,70.19 UC1.AU35 ; UC1.AU23 117.07,63.63 v1(117.4,64.12) ; UC1.AU28 117.06,66.37 v1(117.51,66.83) ; UC1.AM40 120.29,72.94 v1(120.03,73.19) ; v1(112.46,72.79) 112.48,72.78 112.96,72.78
  BOTTOM w0.305: JDIMM2.96 57.43,86.24 57.39,86.27 v1(56.33,86.27) ; JDIMM2.220 59.39,53.24 v1(59.52,53.37) ; JDIMM2.199 66.45,58.49 v1(67.78,58.49) ; JDIMM1.112 69.93,82.24 69.57,81.87 v1(69.57,80.88) 69.7,80.74 JDIMM1.118 ; JDIMM2.159 67.45,68.49 67.68,68.25 v1(67.68,67.86) 67.68,67.71 67.47,67.49 66.45,67.49 JDIMM2.163 ; v1(59.59,63.74) JDIMM2.178 ; v1(72.23,96.74) JDIMM1.54 ; v1(80.44,91.76) 80.17,91.49 79.15,91.49 JDIMM1.75 ; JDIMM1.153 80.41,69.99 v1(80.48,70.06) ; JDIMM1.163 80.27,67.49 v1(80.48,67.7) 80.48,68.21 80.2,68.49 JDIMM1.159 ; v1(69.01,62.85) 69.89,63.74 JDIMM1.178 ; JDIMM1.12 69.83,107.24 69.49,106.9 v1(69.49,106.5) ; JDIMM1.154 70.95,69.74 70.02,69.74 69.7,70.06 v1(69.7,70.63) ; v1(68.04,78.07) 67.96,77.99 66.45,77.99 JDIMM2.129 ; v1(56.91,106.82) 57.32,107.24 JDIMM2.12 ; v1(77.65,58.34) 77.99,58.34 78.13,58.49 JDIMM1.199 ; JDIMM1.124 70.06,79.24 69.58,78.76 v1(69.58,78.13) 69.58,78.02 69.86,77.74 70.95,77.74 JDIMM1.130 ; JDIMM2.75 68.01,91.49 v1(68.06,91.54) ; JDIMM2.111 67.59,82.49 67.94,82.15 67.94,81.82 v1(67.88,81.76) ; JDIMM2.141 66.45,74.99 67.45,74.99 67.81,75.35 v1(67.81,76.67) 67.62,76.49 JDIMM2.135 ; JDIMM2.241 v1(67.74,47.99) ; 56.92,82.24 v1(56.92,82.24) 58.25,82.24 JDIMM2.112 ; v1(80.75,82.53) 80.7,82.49 79.15,82.49 JDIMM1.111 ; JDIMM2.123 67.57,79.49 v1(68.02,79.93) 68.02,80.61 67.63,80.99 JDIMM2.117 ; JDIMM1.160 69.96,68.24 v1(69.65,67.93) ; v1(80.58,102) 80.57,101.99 JDIMM1.33 ; JDIMM2.33 66.45,101.99 v1(67.94,101.99) ; JDIMM1.220 69.92,53.24 v1(69.67,52.98) ; JDIMM2.147 67.63,71.49 68.03,71.09 v1(68.03,70.63) 68.03,70.56 67.46,69.99 JDIMM2.153 ; JDIMM1.241 80.25,47.99 v1(80.45,47.79) ; JDIMM1.136 69.9,76.24 69.52,75.86 69.52,74.82 v1(69.59,74.76) ; JDIMM1.117 80.23,80.99 80.49,80.73 v1(80.49,79.69) ; JDIMM2.54 v1(59.58,96.74) ; v1(68.83,85.25) 68.83,85.93 69.13,86.24 JDIMM1.96
  vias: v1(42.92,33.7) v1(43.23,33.17) v1(43.56,33.7) v1(43.86,33.17) v1(44.19,33.7) v1(44.5,33.17) v1(44.8,33.7) v1(45.11,33.17) v1(45.44,33.7) v1(45.74,33.17) v1(46.08,33.71) v1(48.24,52.62) v1(48.26,52.03) v1(48.26,51.44) v1(48.26,50.86) v1(48.26,50.27) v1(48.54,53.13) v1(48.84,52.62) v1(48.84,52.04) v1(48.84,51.46) v1(48.84,50.87) v1(48.84,50.29) v1(56.92,80.74) v1(56.88,78.03) v1(56.98,76.1) v1(56.98,71.24) v1(56.98,69.74) v1(57.02,68.3) v1(80.52,76.37) v1(80.7,78.38) v1(80.96,73.92) v3(88.11,67.05)
+1.2V_VCCSFR_OC: length 87.5
  TOP w0.508: RZ16.2 95.27,110.63 97.49,108.41 v3(98.43,108.41) v1(102.55,108.41) ; v1(119.95,79.66) 120.46,79.15 CC43.1
  IN2 w0.508: v1(125.92,97.62) 125.92,99.58 121.56,103.94 120.9,103.94 117.37,107.48 103.36,107.48 102.55,108.29 v1(102.55,108.41)
  IN3 w0.508: v1(125.92,97.62) 126.21,97.33 126.21,96.73 125.58,96.1 125.58,92.28 123.88,90.58 123.88,86.22 122.81,85.15 122.44,85.15 122.38,85.21 121.9,85.21 121.89,85.2 121.55,85.2 120.86,84.51 120.86,82.59 120.81,82.52 120.81,80.55 119.95,79.69 v1(119.95,79.66) 119.95,79.36 120.71,78.6 120.71,63.41 120.42,63.11 v1(119.99,63.11)
  BOTTOM w0.254: UC1.AL23 120.1,63.17 120.05,63.11 v1(119.99,63.11)
+1.2VP: length 14.7
  TOP w0.203: PUM01.19 38.78,29.21 39.14,29.56
  TOP w0.381: 39.53,31.22 39.14,30.83 39.14,29.56
  TOP w0.508: 39.53,31.22 43.56,31.22
  BOTTOM w0.254: 43.54,30.62 43.52,30.59 36.55,30.59 v1(35.9,31.24)
  vias: v1(52.64,30.32) v1(52.64,29.74) v1(52.84,32.3) v1(53.22,30.32) v1(53.22,29.74) v1(53.45,32.3) v1(53.81,30.32) v1(53.81,29.74) v1(54.09,32.3) v1(54.39,30.32) v1(54.39,29.74) v1(54.97,30.32) v1(54.97,29.74) v2(45.09,31.28)
+1.8V_AVDD: length 6.7
  TOP w0.203: RA5.2 22.11,7.53 24.55,7.53 v2(24.65,7.63) 25.51,8.5 25.51,9.36 25.74,9.58 UA1.40
  TOP w0.381: CA12.2 21.52,7.61 RA5.2
+1.8V_CPVDD: length 13.6
  TOP w0.127: v2(22.3,8.76) 22.56,8.49 CA50.1
  TOP w0.203: UA1.36 23.33,11.05 23.18,10.9 23.18,10.71 v1(23.31,10.58)
  TOP w0.381: 23.14,8.99 CA50.1 ; 23.14,8.99 CA46.1 ; 23.14,8.99 23.12,9.01 23.12,10.39 v1(23.31,10.58) ; v1(23.62,6.33) 23.56,6.26 CA13.2 22.93,6 22.36,5.43 20.73,5.43 20.37,5.79 RA6.2 CA14.1
  IN1 w0.381: v1(23.31,10.58) 23.15,10.42 23.15,6.8 v1(23.62,6.33)
+1.8V_EMMC: length 42.6
  TOP w0.203: v1(82.58,33.29) UM1.M4 UM1.N4 ; UM1.N4 UM1.P5 ; UM1.N4 UM1.P3 81,33.79 80.52,34.27
  TOP w0.229: v1(86.14,32.17) 86.26,32.29 UM1.C6
  TOP w0.356: 80.88,38.57 80.78,38.67 CM10.1 80.59,39.24 80.08,39.75 RM3.1
  TOP w0.508: 80.52,34.27 80.52,37.16 80.88,37.52 80.88,38.57
  IN2 w0.508: v1(86.14,32.17) 87.06,32.17 87.49,32.6 94.29,32.6 v1(94.69,32.2)
  BOTTOM w0.508: v1(94.17,36.93) 93.68,36.44 93.68,36.1 92.94,35.36 91.33,35.36 90.52,36.17 90.26,36.17 89.94,36.5 89.94,37.04 89.38,37.6 85.29,37.6 84.5,36.81 84.5,33.11 ; v1(94.37,28.61) 94.37,31.88 v1(94.69,32.2) ; 84.5,33.11 84.18,32.8 82.94,32.8 82.58,33.16 v1(82.58,33.29) ; 84.5,33.11 84.95,32.66 85.45,32.66 85.94,32.17 v1(86.14,32.17)
  vias: v3(95.08,28.99)
+1.8V_PRIM: length 281.2
  TOP w0.508: v1(51.41,50.69) v3(52.41,51.7) 53.03,52.32 53.03,52.9 53.59,53.46 55.39,53.46 v1(55.71,53.78) ; v1(77.78,37.52) 78.29,37.01 78.29,32.76 78.25,32.73 v1(78.25,30.89) ; v1(103.95,50.96) 103.95,51.43 104.45,51.94 RC14.1 ; RM27.1 81.68,38.83 v1(81.35,39.16) ; v1(36.7,21.5) QA1.1 ; R23.1 55.51,78.79 RE66.1
  TOP w0.635: RE66.1 54.8,78.72 54.76,78.76 54.28,78.76 v1(54.26,78.77)
  IN1 w0.508: v1(51.41,50.69) 49.74,49.03 46.77,49.03 45.83,49.97 42.44,49.97 41.09,48.63 v1(41.09,47.84) ; v1(103.95,50.96) 103.95,50.4 104.31,50.04 106.74,50.04 107.32,49.46 v1(107.32,48.65)
  IN2 w0.508: v1(41.21,35.67) 41.21,34.78 40.9,34.48 40.9,31.66 41.94,30.62 43.18,30.62 43.69,30.11 v1(43.69,29.89) ; v1(122.85,42.33) 122.45,42.73 121.45,42.73 120.7,43.48 v1(120.7,44.89) 120.95,44.89 121.53,45.46 124.13,45.46 125.1,46.44 125.8,46.44 v1(126.44,47.08) ; v1(89.77,41.26) 89.32,40.8 85.84,40.8 85.37,41.26 82.89,41.26 82.38,40.75 82.38,40.2 v1(81.35,39.16) 79.71,37.52 v1(77.78,37.52) 73.76,37.52 73.26,37.03 70.81,37.03 70.37,37.46 61.36,37.46 58.1,40.72 55.2,40.72 52.6,43.32 52.6,47.78 51.98,48.39 51.98,50.12 v1(51.41,50.69)
  IN3 w0.254: v1(124.04,58.43) 123.93,58.43 123.34,59.03 122.1,59.03 v1(121.47,58.39)
  IN3 w0.508: v1(41.09,47.84) 41.61,47.84 42.78,46.66 42.78,45.83 42.54,45.59 42.54,43.38 43.52,42.4 43.52,37.98 v1(41.21,35.67) ; v1(55.71,53.78) 56.14,54.2 56.14,58.29 55.22,59.21 55.22,65.85 53.48,67.58 53.48,73.98 54.91,75.41 54.91,78.27 54.4,78.77 v1(54.26,78.77) ; v1(43.69,29.89) 43.69,30.33 43.37,30.65 40.28,30.65 38.67,29.04 38.67,28.08 37.78,27.19 37.78,22.13 37.15,21.5 v1(36.7,21.5)
  BOTTOM w0.203: UC1.AA1 125.74,49.61 126.05,49.3 126.05,48.67 125.92,48.54 125.92,48.14 v1(125.95,48.1)
  BOTTOM w0.254: v1(121.47,58.39) 121.19,58.12 UC1.AK15 ; UC1.AF16 123.99,58.43 v1(124.04,58.43)
  BOTTOM w0.508: RC53.1 120.65,44.93 v1(120.7,44.89) ; v1(122.85,42.33) 123.29,42.78 RC51.1 ; v1(91.54,29.28) 90.96,28.7 79.29,28.7 78.25,29.74 v1(78.25,30.89)
  BOTTOM w1.016: 127.32,107.67 127.32,106.15 126.3,105.14 115.71,105.14 115.26,105.58 103.37,105.58 102.11,104.32 102.11,61.13 95.64,54.66 95.64,48.09 92.72,45.17 92.72,44.6 91.92,43.8 90.98,43.8 90.29,43.11
  vias: v1(90.38,41.26) v1(153.07,45.27) v1(153.67,45.26) v1(154.25,45.83) v1(154.25,45.25)
+1.8VALW_EC: length 7.2
  TOP w0.089: RE66.2 55.46,77.32 55.81,76.97 v2(55.81,76.23)
  TOP w0.203: UE1.54 52.3,77.81 52.69,78.19 53.06,78.19 53.41,77.85 53.41,77.36 CE15.1
  TOP w0.381: RE66.2 55.13,77.01 55.13,76.73 CE38.1 CE39.1 53.89,76.47 53.51,76.85 CE15.1
+1.8VALWP: length 17.7
  TOP w0.127: 157.56,44.05 v3(157.56,44.99)
  BOTTOM w0.254: PR1807.1 PC1807.1 170.23,47.46 170.23,48.05 170.24,48.06 170.24,48.78 169.91,49.11 169.07,49.11 168.94,49.23 168.29,49.23 168.14,49.08 167.99,49.08 167.23,48.32 162.58,48.32 161.25,47 159.93,47 159.14,46.21 158.07,46.21 157.51,45.64 PC1803.1
  vias: v1(158.38,43.8) v1(158.38,43.16)
+1.8VGS: length 100.7
  TOP w0.203: v1(67.84,131.69) PRV12.1
  TOP w0.381: 111.88,135.6 110.44,135.6 110.11,135.28 LV2.1 ; 111.88,135.6 112.36,136.09 113.11,136.09 113.63,136.61 RV11.1 ; 111.88,135.6 112.67,134.81 RV28.1
  TOP w0.508: LV7.1 131.22,118.91 130.36,118.06 v1(129.35,118.06) ; v1(126.04,122.36) 126.46,122.77 LV6.1 ; v1(115.81,133.54) 115.81,134.15 RV8.1
  IN1 w0.203: v1(67.84,131.69) 68.35,131.69 68.87,131.17 68.87,126.24 69.36,125.75 70.82,125.75 71.54,125.04 75.71,125.04 76.43,125.76 77.24,125.76 78.88,124.12 79.45,124.12 80.41,123.15 81.4,123.15 83.96,120.59 87.63,120.59 87.89,120.32 89.78,120.32 90.54,121.08 91.81,121.08 92.37,120.52 102.36,120.52 103.46,121.62 103.46,125.46 104.66,126.65 106.5,126.65 106.69,126.46 107.17,126.46 107.51,126.8 107.51,127.45 v1(107.31,127.66)
  IN2 w0.508: v1(125.12,117.51) 126.57,118.96 126.96,118.96 127.68,119.68 127.7,119.68 ; v1(129.35,118.06) 129.32,118.06 127.7,119.68 ; 127.7,119.68 127.7,121.77 127.12,122.36 v1(126.04,122.36)
  BOTTOM w0.254: v1(115.81,133.54) 115.68,133.41 112.48,133.41 111.62,132.55 v1(109.16,132.55) ; UV1.AM30 113.33,143.01 v1(113.33,142.98)
  BOTTOM w0.508: RV84.2 108.04,127.99 RV87.2 107.67,128.01 v1(107.31,127.66) ; RV81.2 120.99,118.45 121.77,118.45 121.8,118.42 121.8,117.79 v1(121.57,117.56) ; RV152.2 125.81,118.21 v1(125.12,117.51)
  BOTTOM w1.016: 113.32,116.42 113.32,110.44 115.2,108.56 118.94,108.56
  vias: v1(113.03,117.58) v1(113.67,117.58) v3(110.45,141.79)
+1.8VGS_GPU_ON: length 5.3
  BOTTOM w0.089: CZ16.2 128.56,106.57 v2(128.81,106.33)
  BOTTOM w0.203: 127.86,110.39 127.56,110.7 UZ5.5
  BOTTOM w0.508: 127.86,110.39 128.51,109.75 128.51,108.62 RZ8.2 CZ16.2
+1.8VGS_OUT:
  vias: v2(124.04,108.62)
+1.35V_MEM_GFX: length 46.1
  TOP w0.254: UV14.L11 v1(153.91,121.31) UV14.K12 ; UV12.K12 155.91,145.13 156.29,144.75 v1(156.29,144.72) 156.29,144.73 156.31,144.73 156.71,144.33 UV12.L11 ; v1(152.31,128.51) 152.71,128.11 UV14.M3 ; v1(152.69,130.29) 152.71,130.28 UV14.M1 ; UV12.D3 151.11,137.93 v1(151.51,137.52) ; UV12.F12 v1(152.31,144.73) ; UV12.G2 153.51,137.13 v1(153.11,137.52) 152.71,137.93 UV12.F3 ; UV14.K3 154.22,128.2 154.03,128.2 153.51,128.72 UV14.L2 UV14.L1 153.51,130.23 v1(153.51,130.23) ; UV12.B1 149.51,136.32 v1(149.51,135.39) ; UV12.G1 153.51,136.32 v1(153.11,135.92) 152.71,136.32 UV12.F1 ; UV12.E5 151.91,139.53 v1(151.51,139.93) ; v1(149.91,137.52) 149.51,137.93 UV12.B3 ; UV14.P11 v1(150.71,122.11) ; UV12.C10 150.31,143.52 v1(149.91,143.13) ; UV14.N5 v1(152.31,126.91) ; v1(156.31,137.52) 155.91,137.93 UV12.K3 ; UV12.D11 151.11,144.33 v1(151.49,143.95) 151.91,143.53 UV12.E10 ; v1(150.71,128.51) 151.1,128.91 UV14.P2 UV14.P1 151.11,130.24 v1(151,130.34) ; UV14.T12 v1(149.11,121.31) ; UV14.T1 v1(149.05,130.17) ; v1(150.71,135.87) 151.11,136.27 UV12.D1 ; UV14.R5 v1(149.91,126.91) ; UV14.P12 v1(150.71,121.31) ; v1(149.91,128.51) 149.51,128.11 UV14.T3 ; UV12.G4 v1(153.93,138.31) UV12.H3 ; UV12.C5 150.4,139.53 v1(150.73,139.86) ; UV14.L4 v1(153.11,126.91) ; v1(150.71,127.71) UV14.P3
  TOP w0.33: UV14.R10 150.4,122.51 v1(150.71,122.81) ; UV14.D3 158.71,128.51 v1(158.61,128.51) ; UV14.B12 160.71,120.85 161.04,120.52 v1(161.19,120.52) ; v1(151.51,122.82) 151.82,122.51 UV14.N10
  TOP w0.508: CV53.1 129.51,126.9 v1(129.36,127.05) 129.32,127.09 CV174.1 ; CV176.1 128.43,130.25 v1(128.92,129.76) 128.92,129.37 CV175.1 ; CV48.1 CV177.1 127.75,131.25 v1(127.75,131.51) 127.41,131.85 CV47.1
  BOTTOM w0.254: v1(149.88,144.75) 149.51,145.13 UV12.B12 ; UV12.B14 149.51,146.73 v1(149.14,147.1) ; UV12.D14 151.11,147.24 v1(151.11,147.24) ; UV14.T1 v1(149.05,130.17) ; UV14.L1 153.51,130.23 v1(153.51,130.23) ; UV12.F14 152.71,147.22 v1(152.7,147.23) ; v1(150.71,128.51) 151.11,128.11 UV14.P3 v1(150.71,127.71) ; UV14.M3 152.71,128.11 v1(152.31,128.51) ; v1(150.71,145.53) 151.11,145.13 UV12.D12 ; v1(131.17,133.49) 131.17,133.42 UV1.H16 ; v1(130.77,134.69) 130.54,134.92 UV1.H19 ; v1(151,130.34) 151.11,130.24 UV14.P1 ; UV14.M1 152.71,130.28 v1(152.69,130.29) ; v1(149.91,128.51) 149.51,128.11 UV14.T3 ; UV14.L2 UV14.K3 ; UV1.H13 130.54,129.95 v1(130.93,129.57) ; UV12.F12 v1(152.31,144.73)
  BOTTOM w0.508: RV33.1 131.73,146.36 132.24,146.87 132.24,147.2 RV32.1 132.69,147.11 v1(132.69,145.89)
  vias: v1(128.6,139) v1(128.6,138.2) v1(128.84,135.84) v1(129.31,139.04) v1(129.33,127.77) v1(149.91,118.91) v1(150.71,118.91) v1(151.93,117.45) v1(153.13,143.95) v1(153.11,120.51) v1(153.11,118.91) v1(153.51,147.23) v1(153.62,148.36) v1(153.91,146.35) v1(155.81,114.07) v1(155.81,113.49) v1(156.31,135.92) v1(156.31,119.71) v1(156.39,114.07) v1(156.39,113.49) v1(156.71,118.74) v1(157.03,130.18) v1(156.97,114.07) v1(156.97,113.49) v1(157.11,147.13) v1(157.1,145.53) v1(157.1,139.13) v1(157.11,128.51) v1(157.09,127.71) v1(157.11,122.11) v1(157.1,121.3) v1(157.53,135.79) v1(157.52,134.8) v1(157.49,118.73) v1(157.49,117.33) v1(157.56,114.07) v1(157.56,113.49) v1(157.9,137.52) v1(157.9,126.1) v1(158.14,114.07) v1(158.14,113.49) v1(158.45,140.01) v1(158.54,117.33) v1(158.61,142.99) v1(158.73,122.09) v1(159.13,135.76) v1(159.14,130.3) v1(159.11,118.79) v1(159.42,120.51) v1(159.51,147.13) v1(159.51,144.73) v1(159.51,143.93) v1(159.51,137.52) v1(159.56,143.13) v1(159.59,126.12) v1(159.62,117.39) v1(160.31,147.13) v1(160.31,139.13) v1(160.31,137.52) v1(160.31,122.91) v1(160.4,128.5) v1(160.44,117.66) v1(161.11,144.73) v1(161.11,135.93) v1(161.08,130.79) v1(161.08,118.93) v1(162.79,147.25) v1(162.8,136.15) v1(163.05,140.32) v1(163.18,148.4) v1(163.23,137.22) v1(163.53,129.02) v1(163.48,121.85) v1(163.48,120.77) v1(163.63,130.1) v1(163.63,127.94) v1(163.63,126.86) v1(163.63,125.78) v1(163.63,124.7) v3(142.12,147.15)
+1.35VGPUP: length 15
  TOP w0.089: v2(155.62,111.67) 154.89,111.67
  BOTTOM w0.254: 154.97,111.77 154.95,111.79 154.95,113.03 154.94,113.04 154.94,113.68 154.47,114.16 147.48,114.16 PCW14.1 146.09,113.74 145.49,113.14 144.69,113.14 144.42,113.09 143.99,112.91 PRW09.2
  vias: v1(154.02,110.56) v1(154.02,109.93) v1(154.61,110.56) v1(154.61,109.93)
+1VALWP: length 21
  TOP w0.254: v1(167.8,49.53) 167.8,49.97 v2(167.66,50.11) 167.57,50.11 PCH14.1 166.57,51.11 PRH08.2
  BOTTOM w0.254: v1(167.8,49.53) 167.8,49.41 167.08,48.69 162.45,48.69 161.17,47.4 154.68,47.4 153.21,48.88 151.2,48.88
  vias: v1(151.29,49.41) v1(151.88,49.41) v1(153.58,53.7) v1(153.58,53.12) v1(153.58,52.54) v1(153.58,51.95) v1(153.58,51.37) v1(153.58,50.78) v1(154.16,53.7) v1(154.16,53.12) v1(154.16,52.54) v1(154.16,51.95) v1(154.16,51.37) v1(154.16,50.78)
+2.5V_MEM: length 75.6
  TOP w1.524: 54.02,51.47 52.93,50.38 52.93,47.48 52.05,46.6 52.05,40.82 53.57,39.3 55.61,39.3
  BOTTOM w1.016: 54.53,54.06 53.07,55.52 53.07,61.11 53.88,61.92 53.88,75.19 55.1,76.41 55.1,83.56 54.69,83.97 54.69,89.76 53.98,90.48 53.98,91.92 54.83,92.78 54.83,110.8 55.53,111.5
  vias: v1(54.52,52.73) v1(54.94,52.27) v1(58.76,111.39) v1(59.34,111.39) v1(67.53,43.08) v1(68.16,43.08) v1(79.67,42.96) v1(80.28,42.96) v1(80.87,42.96) v3(60.11,39.07)
+2.5VP:
  vias: v3(62.42,113.37)
+3.3V_ADP_DCIN: length 147.1
  TOP w0.127: v2(27.99,123.83) 28.15,123.67 30.58,123.67 DT1.2
  TOP w0.254: PR22.1 88.38,149.82 88.59,149.82 89.32,150.54 PR14.1 89.92,150.5 89.92,148.07 90.24,147.75 v1(91.12,147.75)
  TOP w0.508: DT1.2 31.15,124.23 v1(31.15,124.44) ; v1(45.98,119.35) 45.7,119.07 PRS32.1 45.75,117.86 PRS04.1 ; v1(61.6,123.95) 62.09,124.44 PRS34.1 ; PD11.2 83.84,140.72 PU1.5 83.13,141.57 v1(82.36,142.35) ; PC9.1 81.62,147.94 81.23,147.54 v1(81.23,147.32) ; PRS44.2 55.36,123.99 v1(54.99,123.62) 55.38,123.22 PDS01.2
  IN1 w0.508: 80.77,135.39 82.36,136.98 v1(82.36,142.35) 81.23,143.48 v1(81.23,147.32) ; 80.77,135.39 81.75,134.41 95.36,134.41 96.52,135.57 96.52,138.67 92.39,142.79 v1(91.52,142.79) ; 80.77,135.39 74.79,135.39 73.44,134.04 71.12,134.04 69.76,132.69 59.85,132.69 59.63,132.91 v1(58.49,132.91)
  IN2 w0.508: v1(82.36,142.35) 83.73,143.72 88.24,143.72 89.75,145.23 90.66,145.23 91.54,146.11 91.54,147.33 v1(91.12,147.75) ; v1(58.49,132.91) 58.16,132.58 58.16,128.78 56.71,127.34 56.71,125.03 55.3,123.62 v1(54.99,123.62)
  IN3 w0.508: v1(61.6,123.95) 59.28,123.95 57.6,122.27 56.33,122.27 v1(54.99,123.62) ; v1(45.98,119.35) 44.52,117.89 41.83,117.89 41.28,118.44 34.55,118.44 33.97,119.02 33.97,120.04 33.4,120.61 32.34,120.61 31.15,121.8 v1(31.15,124.44)
  BOTTOM w0.508: PR60.1 91.98,142.79 v1(91.52,142.79) ; v1(45.98,119.35) 45.98,118.89 46.24,118.64 47.39,118.64 47.81,119.06 47.81,120.05 49.48,121.71 53.08,121.71 v1(54.99,123.62)
+3.3V_ALW_DSW: length 91.1
  TOP w0.254: RC214.2 121.31,59.67 v1(121.47,59.67)
  TOP w0.381: 105.32,57.11 105.37,57.16 107.74,57.16 108.22,57.64 111.38,57.64 111.76,57.26 111.76,56.07 111.38,55.69 v1(110,55.69)
  TOP w0.508: R84.1 62.62,26.31 61.62,26.31 v1(61.39,26.54) 60.71,27.21 Q15.1 ; RC163.2 101.79,39.59 101.3,40.08 101.3,41.78 v1(101.29,41.79) ; v1(71.27,26.35) 71.27,26.83 71.81,27.38 71.81,33.13 72.54,33.85 72.54,34.29 73.33,35.09 v1(73.33,36.23) 73.24,36.32 73.24,36.91 RE12.2
  TOP w0.635: v1(97.18,40.4) 97.18,40.64 96.24,41.59 96.24,44.08 95.56,44.76 95.56,48.41 95.21,48.76 95.21,51.66 95.87,52.32 100.45,52.32
  IN2 w0.508: v1(73.33,36.23) 73.81,36.23 74.26,36.68 80.21,36.68 83.02,39.49 92.16,39.49 92.53,39.12 95.91,39.12 v1(97.18,40.4) 98.91,42.12 100.96,42.12 v1(101.29,41.79)
  IN3 w0.381: v1(123.98,59.73) 123.91,59.65 121.48,59.65 v1(121.47,59.67)
  BOTTOM w0.254: UC1.AD18 124.32,60.07 v1(123.98,59.73) 124.19,59.52 124.3,59.52 UC1.AD17 ; v1(121.47,59.67) 121.64,59.67 UC1.AJ17
  BOTTOM w0.508: v1(71.27,26.35) 70.68,25.76 63.6,25.76 62.82,26.54 v1(61.39,26.54)
  vias: v1(109.54,55.26) v3(100.9,54.92)
+3.3V_CPS: length 43.6
  TOP w0.508: CT21.1 20.24,127.05 v1(20.22,127.03)
  IN1 w0.508: v1(15.53,115.64) 16.09,116.2 22.73,116.2 v1(23.55,117.01) ; v1(20.22,127.03) 19.33,127.03 16.9,129.45 v1(16.26,129.45)
  IN2 w0.508: v1(23.55,117.01) 23.55,118.37 24.01,118.84 24.01,125.2 23.48,125.74 22.32,125.74 21.03,127.03 v1(20.22,127.03)
  BOTTOM w0.127: v1(15.53,115.64) v2(15.53,114.65)
  BOTTOM w0.203: CT19.1 17.24,117.88 17.24,119.03 17.45,119.24 18.04,119.24 18.16,119.35 UT2.28 ; CT22.1 23.43,118.72 23.34,118.72 23.05,119.02 22.88,119.02 22.51,119.39 22.16,119.39 21.61,119.94 UT2.20 ; UT2.6 20.16,126.97 v1(20.22,127.03)
  BOTTOM w0.33: CT79.1 16.23,117.81 CT23.1
  BOTTOM w0.508: v1(16.26,129.45) 16.26,128.96 RT54.1 16.11,128.82 15.39,128.82 15.34,128.77 LT1.2 ; CT19.1 CT23.1 16.04,117.78 15.53,117.28 v1(15.53,115.64) ; CT22.1 CT20.1 23.55,117.67 v1(23.55,117.01)
+3.3V_CPS_R1: length 5.2
  TOP w0.089: v1(17.21,126.6) 16.85,126.24 v2(16.85,125.97)
  TOP w0.508: CT50.1 17.91,125.9 v1(17.21,126.6)
  BOTTOM w0.203: UT2.1 17.89,125.71 17.21,126.39 v1(17.21,126.6)
  BOTTOM w0.508: v1(17.21,126.6) 16.41,127.4 16.4,127.4 16.11,127.69 RT54.2
+3.3V_HDA: length 3.9
  TOP w0.254: L2.2 120.9,60.99 v2(121.45,60.44) 121.93,59.97 CC61.1 122.35,60.98 v1(122.32,61.01)
  BOTTOM w0.254: v1(122.32,61.01) 122.18,61.01 UC1.AJ19
+3.3V_SPI: length 68.2
  TOP w0.127: v3(128.86,40.88) 128.4,40.41 v1(128.16,40.41)
  IN1 w0.254: v1(107.62,40.5) 107.3,40.81 107.05,41.07 107.05,41.43 110.29,44.67 110.9,44.67 v1(110.93,44.7)
  IN2 w0.508: v1(128.16,40.41) 127.8,40.78 125.27,40.78 124.01,39.51 122.83,39.51 121.86,38.54 120.25,38.54 119.65,37.94 118.62,37.94 118.35,38.21 118.08,38.21 v1(117.55,38.75) ; v1(117.33,41.19) 117.33,42.39 117.18,42.54 117.18,42.6 116.78,43 115.96,43 114.56,44.4 v1(114.56,44.47)
  IN3 w0.254: v1(122.29,58.39) 122.33,58.39 122.74,57.97 122.74,56.12 121.21,54.59 121.21,53.06 120.96,52.8 120.65,52.8 120.33,52.49 120.33,52.2 117.65,49.52 114.73,49.52 114.02,48.81 114.02,48.46 113.5,47.94 112.82,47.94 112.67,47.78 113.52,46.93 v1(113.69,46.93)
  IN3 w0.508: v1(113.69,46.93) 113.77,46.93 114.56,46.15 v1(114.56,44.47) ; v1(110.93,44.7) 111.12,44.89 111.12,45.56 112.06,46.5 112.06,47.17 112.67,47.78
  BOTTOM w0.254: RC139.1 107.31,40.5 v1(107.62,40.5) 107.86,40.5 108.12,40.24 108.12,36.95 108.51,36.55 RX7.1 ; v1(110.93,44.7) 110.93,44.76 RC19.1 ; v1(122.29,58.39) 122.28,58.39 122.28,58.38 UC1.AJ16 ; RX4.1 115.08,34.43 115.96,35.3 115.96,37.16 v1(117.55,38.75)
  BOTTOM w0.508: RC20.1 113.98,46.32 113.98,46.64 v1(113.69,46.93) ; v1(117.33,41.19) 117.09,40.96 117.09,39.2 v1(117.55,38.75) ; RC18.1 114.94,45.2 114.56,44.81 v1(114.56,44.47)
+3.3V_VBUS_IN: length 275.7
  TOP w0.254: PDS01.3 54.08,122.06 54.33,121.81 55.91,121.81 56.17,122.07 56.17,122.64 56,122.8 56,124.61 ; PRB38.1 163.79,35.31 163.41,35.7 v1(163.41,35.89)
  TOP w0.457: 76.89,39.36 v1(76.89,39.7)
  TOP w0.508: PD11.3 81,141.14 v3(80.32,141.14) 80.11,141.14 v1(79.47,141.78) 79.47,142.59 PCS16.1 79.5,142.87 80.28,143.65 PUS04.3 ; 76.89,39.36 77.54,38.71 78,38.71 79,37.7 v1(79,30.09) ; v1(48.29,125.9) 48.59,126.2 PRS12.1 ; PRS13.1 55.77,133.74 v1(55.48,134.03)
  IN1 w0.508: v1(48.29,125.9) 48.85,125.9 50.01,127.06 53.77,127.06 v1(54.82,126)
  IN2 w0.508: v1(79.47,141.78) 79.47,141.56 79.1,141.19 78.45,141.19 74.9,137.64 72.56,137.64 71.47,138.73 64.98,138.73 64.6,138.35 57.12,138.35 55.48,136.71 v1(55.48,134.03) 54.82,133.37 v1(54.82,126) 54.36,125.55 54.36,122.69 57.46,119.59 57.46,115.98 56.53,115.04 56,115.04 55.86,115.19 53.2,115.19 51.09,113.07 51.09,107.17 50.72,106.8 50.72,100.47 50.35,100.11 50.35,88.22 50.92,87.65 50.92,86.94 51.73,86.14 51.73,72.4 52.13,71.99 52.13,71.18 54.45,68.86 54.45,61.24 53.06,59.86 53.06,57.63 53.5,57.19 53.5,52.11 54.13,51.48 54.13,49.28 54.74,48.67 54.74,45.21 57.06,42.88 59.22,42.88 62.34,39.77 73.19,39.77 73.25,39.7 v1(76.89,39.7) ; v1(163.41,35.89) 163.41,35.59 163.1,35.29 159.73,35.29 158.9,34.46 156.1,34.46 155.56,33.92 152.83,33.92 151.31,35.44 146.92,35.44 146.81,35.55 145.15,35.55 144.49,36.2 134.35,36.2 133.02,34.87 129.86,34.87 129.25,34.26 116.76,34.26 115.48,32.98 114.49,32.98 114.02,32.51 112.72,32.51 111.91,33.33 108.11,33.33 107.73,32.95 107.73,32.2 107.36,31.83 97.47,31.83 96.52,30.89 91.73,30.89 90.56,29.71 79.38,29.71 v1(79,30.09)
+3.3V_VDD_PIC: length 60.5
  TOP w0.508: 35.8,124.9 35.8,121.67 35.69,121.57 ; 35.69,121.57 34.26,120.14 34.26,117.65 v1(34.69,117.22) ; 35.69,121.57 35.69,121.06 RT8.1 36.49,120.26 RT5.1 ; RE72.1 47.88,91.78 v1(47.79,91.86)
  IN1 w0.508: v1(41.88,115.5) 41.88,116.62 42.29,117.03 47.39,117.03 v1(47.99,116.43)
  IN2 w0.508: v1(47.79,91.86) 47.79,96.25 47.35,96.69 47.35,101.52 46.63,102.24 46.63,104.1 45.69,105.04 45.69,112.72 46.19,113.22 46.19,114.63 v1(47.99,116.43) ; v1(41.88,115.5) 41.09,115.5 40.42,116.18 37.24,116.18 36.41,117 34.91,117 v1(34.69,117.22) ; v1(32.83,126.86) 31.5,126.86 29.78,125.15 v1(29.78,124.44)
  BOTTOM w0.508: v1(29.78,124.44) 30.29,123.94 CT5.1 RT3.1 ; v1(41.88,115.5) JCCG4.1
  vias: v1(33.24,126.4) v3(32.25,127.03)
+3.3V_WLAN: length 2.3
  TOP w0.127: CW9.1 73.36,136.47 v3(73.95,137.05)
  vias: v1(69.63,137.22) v1(69.63,136.61) v1(70.24,137.22) v1(70.24,136.61) v1(70.35,118.07) v1(70.57,118.64) v1(70.99,118.07) v1(71.2,118.64) v3(71.94,117.71) v3(75.09,117.64)
+3V_DVDD: length 29.7
  TOP w0.127: v1(31.6,8.04) 32.11,8.04 v2(32.29,7.86)
  TOP w0.203: UA1.9 30.24,14.25 31.27,15.28 CA44.1
  TOP w0.381: 32.77,21.17 RA2.2 ; 32.77,21.17 v1(32.17,21.17) ; 32.77,21.17 32.87,21.07 CA15.2 CA5.2 32.84,18.95 32.84,18 CA6.1 32.76,17.75 32.23,17.75 32.11,17.86 RA3.2 32.01,17.6 31.36,16.95 CA16.1 31.27,16.68 CA48.1 CA44.1 ; RA8.1 v1(31.6,8.04)
  IN3 w0.381: v1(31.6,8.04) 32.14,8.58 32.14,11.13 32.98,11.97 34.93,11.97 35.31,12.35 35.31,15.15 35.21,15.25 35.21,17.37 34.18,18.4 33.06,18.4 31.44,20.01 31.44,20.45 v1(32.17,21.17)
+3V_EMMC: length 38.3
  TOP w0.229: v1(82.63,31.36) 82.66,31.33 82.66,31.07 82.94,30.79 UM1.K9 UM1.J10 ; v1(85.57,33.32) 85.11,32.86 UM1.F5 UM1.E6
  TOP w0.356: 88.93,38.83 CM9.1 89.62,39.01 RM1.2
  TOP w0.381: UM2.5 84.47,42.56 84.72,42.31
  TOP w0.508: v1(86.74,35.26) 87.13,35.66 87.13,38.55 CM2.1 CM1.1 88.93,38.83 ; RM1.2 89.89,40.18 v3(89.37,40.7) 87.88,42.18 84.85,42.18 84.72,42.31 ; v1(76.97,30.89) 76.73,31.13 CM7.1
  BOTTOM w0.508: v1(76.97,30.89) 76.97,31.26 77.4,31.69 80.23,31.69 80.57,31.36 v1(82.63,31.36) 82.63,30.31 83.41,29.54 86.36,29.54 87.13,30.31 87.13,32.86 86.43,33.56 85.81,33.56 v1(85.57,33.32) 85.37,33.53 85.37,34.79 85.84,35.26 v1(86.74,35.26)
+3VALW: length 504.2
  TOP w0.254: PRW03.1 147.39,111.5 v1(147.91,112.02)
  TOP w0.381: C43.1 215.08,60.41 v1(214.85,60.64) ; v1(127.1,29.1) 127.1,30.44 127.94,31.28 R35.1 ; C57.1 40.64,97.49 41.27,97.49 41.47,97.29 U4.5 ; v1(147.55,89.59) 147.04,90.1 UC9.5
  TOP w0.457: PRB27.1 209.65,47.47 209.3,47.81 208.35,47.81 207.91,48.26 207.91,48.52 207.4,49.03 207.4,49.73 207.67,50 v1(208,50)
  TOP w0.508: v1(102.79,41.16) 102.79,40.71 102.95,40.55 CC85.1 RC163.1 ; 49.45,61.57 47.89,61.57 46.96,60.64 46.71,60.64 ; 49.45,61.57 49.39,61.62 RE46.1 ; 49.45,61.57 50.35,60.66 52.94,60.66 54.03,61.76 54.03,63.78 55.34,65.08 55.34,68.07 ; RW5.1 77.44,116.4 79.29,118.25 81.21,118.25 82.67,119.71 88.19,119.71 88.94,118.95 88.94,117.73 90.32,116.35 v3(92.45,116.35) 108.02,116.35 112.51,111.87 v1(112.51,109.81) 112.51,108.44 111.77,107.71 R43.1 ; v1(39.42,87.67) 39.09,88 RE49.1 ; v1(25.75,129.22) 25.75,129.45 26.26,129.96 v1(26.61,129.96) ; RC163.1 102.95,39.43 102.44,38.92 101.58,38.92 101.57,38.91 101.14,38.91 100.8,38.57 100.8,38.08 101.84,37.04 v1(102.12,37.04) ; RC163.1 103.58,39.59 103.72,39.73 103.79,39.73 103.81,39.75 RC88.2 ; v1(171.56,28.63) 171.56,28.3 PR33.1 ; v1(58.24,27.39) 59.28,28.43 Q15.3 59.28,30.77 59.67,31.16 R66.1 61.02,31.55 R65.1 ; v1(91.63,38.21) 91.28,38.56 RM1.1 ; RE21.2 33.97,64.91 34.18,64.7 34.18,63.52 34.43,63.28 34.43,62.71 ; v1(166,42.71) 166.14,42.71 166.47,42.38 PR41.2 ; v1(32.83,35.38) 33.66,36.21 36.28,36.21 37.42,37.36 39.24,37.36 39.99,36.61 44.18,36.61 46.24,38.67 51.28,38.67 53.17,36.77 R53.1 ; v1(20.77,117.98) 20.77,119.35 RT11.1 ; RL7.1 23.4,88.72 24.01,89.33 26.32,89.33 v1(26.62,89.04) 26.87,89.29 27.63,89.29 ; PRM06.1 32.05,26.66 31.59,26.21 v1(31.59,24.47) ; 27.63,89.29 27.62,89.28 27.62,87.66 28.58,86.7 RE18.2 28.6,86.06 28.93,85.73 ; 27.63,89.29 28.28,89.29 28.91,89.92 28.91,90.78 DE2.2 30.51,92.38 33.25,92.38 35.45,94.59 37.22,94.59 37.56,94.24 37.56,94.23 ; v1(137.35,110.71) 135.72,109.09 134.23,109.09 132.95,107.81 v1(132.53,107.81) ; PR1803.1 166.9,45.97 166.9,49.18 v1(167.08,49.36) ; RE25.1 v1(52.58,87.74) ; v1(218.47,62.24) 218.47,65.2 219.11,65.83 R70.1 ; v1(17.65,86.66) UL2.5 ; 37.56,94.23 37.93,94.59 RE56.1 RE55.1 38.67,95.67 38.67,97.52 v1(38.93,97.79) 39.68,97.79 C57.1 ; 37.56,94.23 37.56,93.42 37.91,93.07 RE57.1 RE58.1 38.98,92.1 v1(38.55,91.67) ; RC92.2 121.4,50.46 119.52,48.57 118.75,48.57 118.25,48.07 v1(118.25,45.88) ; v1(30.78,21.98) 30.21,21.98 RA11.2 ; PR5.2 61.24,122.11 61.69,122.56 PRS28.1 62.32,121.93 v1(61.91,121.52) ; RC225.2 v1(43.29,100.31) ; UW1.5 69.39,137.79 70.07,138.48 70.07,139.71 70.93,140.56 72.13,140.56 RW12.1 ; v1(42.6,97.85) 42.82,98.06 RC226.1
  IN1 w0.508: v1(91.63,38.21) 91.84,38.43 96.36,38.43 96.85,37.93 98.19,37.93 98.93,37.19 101.96,37.19 v1(102.12,37.04) ; 166.93,49.21 166.66,48.94 165.76,48.94 163.56,46.74 160.99,46.74 160.19,47.54 157.13,47.54 156.18,46.59 156.18,45.13 155.41,44.36 v1(153.91,44.36) ; 166.93,49.21 v1(167.08,49.36) ; 166.93,49.21 166.93,43.64 v1(166,42.71) ; v1(14.7,111.37) 14.7,115.73 15.77,116.8 19.59,116.8 v1(20.77,117.98) 20.77,120.68 21.59,121.5 21.59,123.44 22.39,124.24 22.39,125.34 22.56,125.52 22.56,125.52 22.84,125.8 22.84,125.8 22.89,125.85 24.79,125.85 v1(25.14,125.5) ; v1(147.91,112.02) 146.22,110.33 144.41,110.33 144.26,110.18 141.9,110.18 141.46,110.62 141.43,110.62 141.39,110.66 137.4,110.66 v1(137.35,110.71) ; v1(39.42,87.67) 39.42,87.67 39.67,87.67 40.44,86.9 42.84,86.9 43.81,87.86 v1(45.4,87.86) 47.9,87.86 48.57,87.2 52.05,87.2 v1(52.58,87.74) ; v1(42.6,97.85) 42.54,97.79 v1(38.93,97.79)
  IN2 w0.508: v1(68.36,136.55) 67.08,136.55 66.4,137.22 62.9,137.22 61.07,135.39 61.07,130.35 60.5,129.78 60.5,127.97 59.95,127.42 59.95,124.18 61.9,122.23 61.9,121.8 61.91,121.79 v1(61.91,121.52) ; v1(42.71,91.31) 43.54,90.47 43.54,89.72 v1(45.4,87.86) ; v1(102.75,35.63) 102.12,36.27 v1(102.12,37.04) ; 19.26,127.73 24.05,127.73 25.14,126.64 v1(25.14,125.5) ; 19.26,127.73 19.26,126.18 17.59,124.51 17.59,122.11 16.8,121.32 15.66,121.32 14.09,122.88 14.09,123.55 v1(12.95,124.69) ; 19.26,127.73 17.8,127.73 v1(17.37,127.3) ; v1(132.53,107.81) 132.24,107.51 127.47,107.51 126.39,108.59 118.88,108.59 118.17,109.3 113.01,109.3 v1(112.51,109.81) ; v1(147.74,48.3) 151.84,44.2 153.75,44.2 v1(153.91,44.36) ; v1(102.79,41.16) 102.8,41.16 103.51,40.45 106.08,40.45 107.39,41.75 108.91,41.75 111.69,44.53 111.73,44.53 111.74,44.53 112.22,44.53 112.23,44.53 112.34,44.53 112.34,44.53 112.85,44.53 112.85,44.53 112.92,44.53 113.99,45.6 117.97,45.6 v1(118.25,45.88)
  IN3 w0.508: v1(43.29,100.31) 43.2,100.22 43.2,98.45 v1(42.6,97.85) ; v1(137.35,110.71) 138.76,109.3 140.03,109.3 142.32,107.01 142.32,104.94 143.82,103.43 v1(143.82,94.75) 143.82,93.32 v1(147.55,89.59) ; v1(62.23,114.35) 62.65,113.93 64.74,113.93 65.21,114.4 66.15,114.4 66.76,115 71.25,115 71.5,115.25 74.48,115.25 v1(75.09,115.86) ; v1(14.7,111.37) 14.16,110.83 14.16,106.88 14.8,106.23 14.8,102.95 13.39,101.53 13.39,90.88 14.56,89.71 14.56,88.12 13.64,87.19 v1(13.64,86.5) ; v1(166.52,52.65) 166.52,50.68 167.08,50.12 v1(167.08,49.36) ; v1(38.55,91.67) 38.12,91.24 38.12,88.97 v1(39.42,87.67)
  BOTTOM w0.254: CX1.1 106.13,29.37 106.23,29.47 UX1.1 ; UT3.13 26.73,129.84 v1(26.61,129.96)
  BOTTOM w0.381: PRH03.1 165.98,49.14 166.86,49.14 v1(167.08,49.36) ; UC6.5 143.15,90.35 142.85,90.66 142.85,91.58 143.38,92.11 143.38,92.64 143.37,92.65
  BOTTOM w0.508: v1(17.37,127.3) 16.87,127.8 RT20.1 RT17.1 ; v1(147.74,48.3) 147.17,47.73 146.06,47.73 RC63.1 ; RT14.1 24.51,125.5 v1(25.14,125.5) ; v1(12.95,124.69) RT29.1 RT26.1 13.83,125.96 15.29,127.42 LT1.1 ; 103.6,30.49 103.62,30.5 103.83,30.28 CX2.1 105.58,30.27 CX1.1 ; v1(62.23,114.35) 61.06,114.35 60.5,114.91 60.5,120.4 61.62,121.52 v1(61.91,121.52) ; JPWR2.6 224.24,63.33 224.24,62.01 223.33,61.1 219.62,61.1 v1(218.47,62.24) ; v1(20.77,117.98) 20.76,117.97 20.76,116.99 21.26,116.49 RT53.1 RT52.1 ; RT23.1 24.85,123.19 v1(25.35,123.19) ; CT38.1 v1(25.75,129.22) ; v1(166.52,52.65) PRH05.1 ; v1(13.64,86.5) 17.48,86.5 v1(17.65,86.66)
  vias: v1(32.01,55.88) v1(31.99,54.76) v1(32.3,55.33) v1(32.65,55.88) v1(32.61,54.76) v1(32.97,55.33) v1(33.23,55.88) v1(33.19,54.77) v1(33.59,55.34) v1(33.68,54.41) v1(38.95,61.57) v1(39.53,61.57) v1(41.64,60.43) v1(42.25,60.41) v1(68.36,137.16) v1(68.97,137.16) v1(68.97,136.55) v1(102.43,30.21) v1(102.87,30.62) v1(173.73,43.95) v1(174.32,43.95) v1(175.74,36.79) v1(176.32,36.79) v1(215.87,58.83) v1(215.87,58.25) v1(215.87,57.67) v1(216.45,58.83) v1(216.45,58.25) v1(216.45,57.67) v1(220.44,44.04) v1(220.44,43.4) v1(221.08,44.04) v1(221.08,43.4) v1(221.66,43.72) v3(34.45,56.54) v3(173.68,39.72)
+3VALW_EC: length 213.8
  TOP w0.102: CE7.2 33.52,79.11 CE37.1 33.97,79.11 34.27,79.41 UE1.103 36.54,79.41 37.06,79.92 v1(37.53,79.92)
  TOP w0.203: UE1.82 42.95,84.33 43.27,84.65 v1(43.27,85.21) 43.27,85.33 42.75,85.85 42.75,86.61 42.74,86.62 42.74,86.96 42.54,87.16 CE20.1 ; v1(37.07,74.92) 36.76,74.61 UE1.115 34.89,74.61 34.64,74.35 33.83,74.35 CE13.1 ; v1(40.8,72.14) 41.4,71.55 41.4,71.03 38.95,68.59 UE1.5 38.95,65.32 CE5.1 ; CE10.1 44.59,66.56 44.55,66.6 UE1.19 44.55,68.59 44.18,68.95 44.18,69.88 44.39,70.08 v1(44.58,70.08) 44.64,70.08 45.01,69.71 46.03,69.71 46.23,69.51 46.23,69.06 45.75,68.59 UE1.22 ; CE6.1 53.34,73.41 UE1.43 48.93,73.41 v1(48.28,74.05)
  TOP w0.381: CE20.1 42.24,86.43 CE36.1
  TOP w0.508: CE21.1 RE1.1 31.22,91.11 29.69,89.58 DE2.1 30.04,88.9 RE30.2 RE31.2 30.94,87.25 RE3.1 30.68,87.24 v1(30.33,86.89) ; RE72.2 47.56,89.07 v1(46.16,89.07) 46.16,89.51 46.74,90.09 46.74,91.7 v3(47.11,92.07) 47.11,93.82 46.34,94.59 v1(45.66,94.59) ; DT1.1 29.68,125.97 v1(29.62,126.04) ; RE10.2 RE11.2 42.33,61.31 RE2.2 43.08,62.86 42.79,63.15 v1(42.79,63.2) 42.57,63.2 42.01,63.76 RE9.2 ; v1(46.13,65.35) 46.13,65.27 45.62,64.76 CE11.1 CE12.1 44.7,64.77 44.7,65.88 CE10.1 ; v1(53.04,65.59) 54.11,65.59 54.48,65.97 RE71.2 54.48,67.67 RE14.2 ; RE8.2 38.46,64.1 CE5.1 ; PR64.1 v1(47.85,122.88)
  IN1 w0.508: v1(45.66,94.59) 48.57,94.59 49.23,95.25 51.8,95.25 52.49,95.93 52.49,104.47 v1(51.91,105.04) ; v1(50.22,84.32) 49.62,84.92 43.56,84.92 v1(43.27,85.21) ; v1(50.87,115.6) 43.54,115.6 v1(42.74,116.39) ; v1(40.8,72.14) 41.4,72.75 42.87,72.75 43.44,72.17 43.44,70.52 43.88,70.08 v1(44.58,70.08) 44.71,69.95 46.43,69.95 47.09,70.61 47.09,72.86 v1(48.28,74.05) ; v1(42.79,63.2) 43.43,63.2 45.57,65.35 v1(46.13,65.35) 46.53,64.94 52.4,64.94 v1(53.04,65.59)
  IN2 w0.508: v1(48.28,74.05) 48.28,76.59 48.51,76.82 48.51,82.61 v1(50.22,84.32) ; v1(47.85,122.88) 47.85,119.6 50.87,116.58 v1(50.87,115.6) ; v1(37.53,79.92) 37.41,79.92 36.76,79.27 36.76,75.22 v1(37.07,74.92) 38.36,74.92 40.8,72.47 v1(40.8,72.14)
  IN3 w0.508: v1(29.62,126.04) 30.39,125.27 30.39,121.33 31.86,119.86 31.86,119.38 32.81,118.42 33.61,118.42 34.22,117.81 37.13,117.81 38.3,116.64 40.78,116.64 41.03,116.39 v1(42.74,116.39) ; v1(37.53,79.92) 37.23,79.62 35.07,79.62 30.72,83.98 30.72,86.5 v1(30.33,86.89) ; v1(43.27,85.21) 43.27,85.21 43.29,85.23 43.49,85.23 44.1,85.83 44.1,86.33 44.56,86.8 44.56,87.84 45.78,89.07 v1(46.16,89.07)
  BOTTOM w0.305: JESPI1.2 45.38,94.87 v1(45.66,94.59) 45.44,94.37 JESPI1.1
  BOTTOM w0.508: v1(50.87,115.6) 50.49,115.22 48.65,115.22 46.1,112.67 46.1,105.52 46.94,104.68 50.72,104.68 51.08,105.04 v1(51.91,105.04)
+3VALW_PCH: length 273.2
  TOP w0.127: v1(86.28,117.5) v3(86.28,118.59)
  TOP w0.254: RE19.2 43.42,90.71 43.67,90.97 45.67,90.97 v1(46.14,90.5) ; v1(127.33,59.08) 127.37,59.08 127.78,58.67 127.78,58.14 128.4,57.52 RC37.2 ; v1(130.48,28.34) 127.16,28.34 126.59,28.91 126.59,30.4 125.94,31.05 v1(125.94,32.74)
  TOP w0.457: RC33.2 127.48,53.04 127.1,53.42 v1(126.96,53.42)
  TOP w0.508: v1(69.64,41.63) 69.64,40.51 68.4,39.26 68.4,35.72 67.56,34.88 67.56,33.22 67.84,32.94 68.4,32.94 68.78,32.56 69.83,32.56 71.15,31.24 71.15,27.73 69.91,26.49 67.15,26.49 66.51,25.84 64.03,25.84 R84.2 ; v1(103.92,47.37) 103.92,47.18 103.86,47.13 103.86,46.89 103.76,46.79 RC128.1 102.83,46.59 102.59,46.84 RC129.1 ; v1(122.99,46.71) 123.13,46.56 RC45.2 124.95,46.07 125.48,45.54 CC78.1 CC64.1 125.47,44.46 CC65.1 ; L2.1 119.62,61.43 CC100.1 118.93,61.06 v1(118.63,61.35) ; RC39.2 120.37,46.19 121.35,47.17 v1(121.35,47.23)
  IN1 w0.254: v1(128.01,37.52) 128.24,37.52 129.49,38.77 129.49,43.98 v1(130.36,44.85)
  IN1 w0.508: v1(122.21,44.88) 122.21,45.08 122.14,45.14 122.14,46.43 121.35,47.23 v1(121.35,47.23)
  IN2 w0.254: v1(54.53,111.96) 55.79,111.96 58.93,115.1 66.39,115.1 67.69,116.4 71.63,116.4 72.43,117.21 74.28,117.21 74.85,117.78 76.66,117.78 77.29,118.41 83.56,118.41 v1(84.48,117.5)
  IN2 w0.508: 137.31,48.04 137.62,47.73 139.11,47.73 139.88,48.49 139.88,50.51 140.13,50.76 142.27,50.76 142.98,50.05 v1(144.69,50.05)
  IN2 w2.032: 93.48,44.2 96.16,44.2 97.61,45.65 99.14,45.65 101.4,47.91
  IN3 w0.254: v1(128.01,37.52) 128.01,36.13 125.94,34.06 v1(125.94,32.74) ; v1(46.14,90.5) 46.25,90.61 46.25,92.09 46.72,92.57 46.72,96.23 47.62,97.13 47.62,101.89 48.32,102.59 48.32,106.68 49.1,107.46 49.1,108.27 52.32,111.49 54.06,111.49 v1(54.53,111.96)
  BOTTOM w0.254: v1(121.47,59.03) 121.09,59.42 UC1.AK17 ; RC227.2 130.36,28.23 v1(130.48,28.34) ; UC1.AG15 122.36,57.75 v1(122.3,57.75) ; UC1.Y15 125.65,57.69 125.09,57.69 v1(124.83,57.43) ; UC1.V19 126.47,61.17 126.47,62.18 126.08,62.57 124.11,62.57 v1(123.97,62.43) 122.61,62.43 122.31,62.12 121.99,62.12 UC1.AJ21 ; UC1.T16 127.44,59.08 v1(127.33,59.08) ; v1(124.02,57.74) UC1.AD15 ; v1(125.66,59.08) UC1.Y16
  BOTTOM w0.508: RC44.1 111.08,51.71 v1(111.48,52.1) ; v1(122.99,46.71) 122.99,46.06 122.42,45.5 RC47.2 122.21,45.4 v1(122.21,44.88) ; v1(90.01,45.02) 89.78,45.25 83.12,45.25 82.32,44.45 82.32,41.94 79.17,38.79 76.82,38.79 74.28,41.33 72.15,41.33 71.03,42.45 70.07,42.45 69.64,42.02 v1(69.64,41.63)
  BOTTOM w2.032: 91.2,46.92 91.2,52.52 99.86,61.17 99.86,107.31 101.09,108.54 101.09,111.41 97.72,114.78 92.2,114.78 90.65,116.33 89.44,116.33
  vias: v1(85.06,117.5) v1(85.67,117.5) v1(90.62,45.02) v1(91.23,45.02) v1(91.84,45.02)
+3VALWP: length 60.3
  TOP w0.254: 24.39,51.65 23.83,51.65 v1(20.86,48.67) 20.66,48.47 20.66,46.24 20.1,45.68 20.1,45.46 19.43,44.79 PR304.1 ; v1(20.67,45.46) 21.04,45.83 21.04,48.14 24.14,51.24 24.34,51.24
  IN1 w0.508: v1(30.78,65.6) 31.85,66.67 31.85,74.47 32.85,75.47 v1(32.85,75.87)
  IN3 w0.508: v1(32.85,75.87) 32.74,75.98 29.96,75.98 29.66,76.27 29.66,77.14 29.14,77.66 v1(28.56,77.66)
  BOTTOM w0.254: v1(20.86,48.67) 20.61,48.42 PR306.2 20.61,47.86 PR307.1 ; PU301.14 20.34,45.13 v1(20.67,45.46)
  BOTTOM w0.508: v1(28.56,77.66) 29.28,78.37 29.28,85.33 29.02,85.59 29.02,86.43 29.6,87.02 29.6,90.98 28.01,92.57 PR504.1 ; v1(30.78,65.6) 30.08,65.6 28.2,63.72 28.2,59.72
  vias: v1(25.42,52.29) v1(25.42,51.71) v1(26.01,52.29) v1(26.01,51.71) v1(26.59,52.29) v1(26.59,51.71) v3(26.04,50.94)
+3VGS: length 116.3
  TOP w0.089: v1(131.01,113.07) v3(131.87,113.07)
  TOP w0.203: v1(67.22,130.23) PRV14.1
  TOP w0.356: QV1.5 QV1.2
  TOP w0.381: RV5.1 123.95,123.25 124.31,122.89 QV1.5 ; QV1.2 124.31,120.53 123.45,119.67 RV6.1
  TOP w0.508: v1(126.95,120.1) 126.95,120.3 RV154.1 ; RV6.1 122.66,119.16 v1(123.1,118.72)
  IN1 w0.203: v1(67.22,130.23) 68.13,130.23 68.58,129.79 68.58,126.12 69.39,125.3 69.39,124.82 69.87,124.34 71.18,124.34 71.58,124.74 75.83,124.74 76.55,125.46 77.12,125.46 78.76,123.82 79.32,123.82 80.29,122.85 81.28,122.85 83.84,120.29 87.5,120.29 87.77,120.03 89.9,120.03 90.66,120.79 91.68,120.79 92.24,120.23 102.21,120.23 103.51,118.92 107.13,118.92 108,119.78 108,123.41 v1(108.78,124.18)
  IN1 w0.508: v1(126.95,120.1) 126.3,119.45 126.3,116.52 128.38,114.44 130.63,114.44 131.01,114.06 v1(131.01,113.07) ; v1(111.06,117.47) 111.06,117.41 111.95,116.52 121.92,116.52 122.55,117.15 122.55,117.98 123.1,118.53 v1(123.1,118.72)
  IN2 w0.508: v1(123.1,118.72) 124.98,118.72 126.36,120.1 v1(126.95,120.1)
  BOTTOM w0.508: 108.85,125.52 108.39,125.98 107.16,125.98 106.2,126.94 106.2,128.14 106.66,128.6 106.66,129.61 108.17,131.12 108.17,132.9 108.77,133.49 LV4.1 108.49,134.18 107.98,134.69 107.98,138.13 108.34,138.49 RV162.1 ; v1(111.06,117.47) 110.27,118.26 110.27,124 110,124.26
+3VGS_GPU_ON: length 4.1
  BOTTOM w0.089: CZ13.2 137.24,116.4 137.87,116.4 v2(138.36,116.9)
  BOTTOM w0.254: RZ6.2 136.79,115.11 CZ13.2 136.29,115.95 136.24,115.91 UZ4.3
+3VGS_OUT: length 0.7
  BOTTOM w0.089: v2(132.11,117.91) 132.29,117.74 132.72,117.74
+3VLP: length 195.9
  TOP w0.254: v1(30.56,73.57) 31.08,73.57 RE29.2 ; v1(41.08,47.21) 40.03,47.21 39.12,48.12 D1.2
  TOP w0.508: v1(56.63,111.63) 56.25,111.63 55.48,110.85 55.48,105.88 54.96,105.37 v3(54.96,102.01) 54.96,95.58 v1(53.24,93.86) ; R42.1 108.59,107.62 105.25,110.96 v1(105.25,113.57)
  IN1 w0.254: v1(53.24,93.86) 52.18,92.81 51.76,92.81 48.48,89.53 44.72,89.53 44.51,89.31 40.81,89.31 40.62,89.51 39.29,89.51 39.05,89.26 38.26,89.26 35.85,91.67 v1(33.08,91.67) ; v1(23.69,61.3) 23.1,60.71 23.1,56.72 22.42,56.04 21.73,55.35 21.73,53.49 20.79,52.56 20.79,50.74 20.3,50.25 20.3,46.83 21.22,45.92 v1(21.22,45.14)
  IN2 w0.254: v1(30.56,73.57) 30.9,73.57 31.71,72.77 31.71,66.92 31.24,66.45 30.82,66.45 30.21,65.84 30.21,63.81 30.68,63.34 34.4,63.34 v1(34.8,63.74)
  IN2 w0.508: v1(105.25,113.57) 105.25,113.83 103.65,115.43 99.75,115.43 99.21,115.97 92.27,115.97 91.32,116.91 84.01,116.91 83.03,117.89 77.59,117.89 77.01,117.31 75.05,117.31 74.47,116.73 72.63,116.73 71.81,115.92 67.88,115.92 66.29,114.33 65.22,114.33 64.56,113.67 60.77,113.67 59.41,112.32 58.37,112.32 57.68,111.63 v1(56.63,111.63)
  IN3 w0.254: v1(23.69,61.3) 24.53,62.14 28.3,62.14 29.79,63.62 34.68,63.62 v1(34.8,63.74)
  BOTTOM w0.254: v1(30.56,73.57) 31.28,73.57 31.61,73.9 31.61,82.85 30.96,83.49 30.96,85.41 32.54,86.99 33.3,86.99 33.7,87.39 33.7,88.58 33.08,89.2 v1(33.08,91.67) ; v1(41.08,47.21) 40.25,47.21 40.12,47.35 40.12,55.79 37.97,57.93 37.97,59.3 37.7,59.58 37.7,60.44 37.3,60.84 37.08,60.84 35.39,62.53 35.39,63.15 v1(34.8,63.74)
+3VS: length 587.1
  TOP w0.203: CT75.1 41.73,112.48 41.39,112.14 41.39,111.15 41.14,110.91 UT5.5 ; UT5.57 44.13,108.17 44.23,108.08 45.07,108.08 45.28,108.28 CT74.1 ; 43.86,105.22 43.91,105.27 43.91,105.69 43.83,105.77 UT5.51 ; UT5.21 33.81,109.37
  TOP w0.254: PRV17.1 79.67,125.85 79.99,125.53 79.99,123.51 v1(79.51,123.03)
  TOP w0.305: v1(42.06,101.6) 42.4,101.6 43.34,102.54 43.34,103.16 CT73.1 ; JWWAN.17 v1(216.43,55.74) ; v1(33.54,110.53) 33.32,110.75 CT72.1 32.88,110.3 33.81,109.37 ; v1(46.7,108.02) 46.7,107.74 RT66.2 RT68.2 RT70.2 RT72.2 45.36,103.73 CT73.1 ; v1(46.7,108.02) 45.85,108.02 CT74.1 ; v1(46.7,108.02) 46.83,108.15 46.83,108.99 47.74,109.9 47.74,110.5 47.79,110.54 ; CT73.1 43.93,103.74 43.93,104.33 43.86,104.39 43.86,105.22 ; 47.79,110.54 47.83,110.59 48.79,110.59 RT76.2 ; 47.79,110.54 47.74,110.59 46.22,110.59 RT74.2 RT79.2 46.19,111.43 45.67,111.95 45.67,112.38 45.68,112.39 RT80.2 46.02,112.47 46.25,112.7 46.25,114.11 45.53,114.83 44.76,114.83 v1(44.67,114.92) 44.56,114.92 RT83.2 RT77.2 ; RC212.2 144.39,34.98 v1(144.46,34.92) ; v1(30.02,113.57) 29.52,113.57 RI15.1 28.29,113.39 QI3.2
  TOP w0.381: v1(181.69,68.63) 181.61,68.54 181.61,66.14 181.92,65.82 182.56,65.82 182.91,65.46 Q11.2 ; R33.1 121.44,27.61 121.26,27.79 Q10.5 120.38,27.79 v1(120.2,27.97) ; R49.1 182.91,67.91 Q11.5 ; UC4.5 103.86,45.05 104.06,45.25 104.52,45.25 v1(104.66,45.39)
  TOP w0.406: UE2.5 40.3,90.76 v1(40.54,90.76)
  TOP w0.432: v1(119.92,32.74) 119.92,32.37 118.46,30.91 118.46,30.16 R34.1 118.57,29.83 118.36,29.62 118.36,28.21 v1(118.44,28.13) 118.78,27.79 Q10.2
  TOP w0.508: RS3.1 196.36,32.63 v1(196.88,32.63) ; v1(104.12,41.95) 104.57,41.5 RC59.1 ; RC71.1 104.28,52.74 103.4,51.86 v1(103.32,51.86) ; v1(183.95,64.11) R48.1 183.05,63.03 v1(182.29,62.26) ; v1(128.86,25.07) 129.19,25.4 R36.1 ; v1(192.11,62.84) 191.89,62.84 191.52,63.2 191.52,64.57 191.79,64.84 RC194.2 ; v1(50.2,46.77) 50.15,46.81 R24.1 49.69,47.45 49.31,47.07 48.54,47.07 Q6.2 ; v1(130.4,43.43) 130.36,43.39 RC200.2 ; RC72.1 105.27,46.08 105.27,46.07 RC73.1 105.17,45.97 104.66,45.46 v1(104.66,45.39) ; CD10.2 68.32,68.81 v1(68.32,67.86) 68.32,67.36 RD3.1 ; v1(87.92,118.7) 87.92,117.42 91.56,113.77 99.83,113.77 105.48,108.12 RC9.1 ; R5.1 209.87,55.53 v1(209.87,56) 209.87,57.71 210.92,58.76 211.88,58.76 212.24,59.11 212.81,59.11 213.65,58.28 RC208.2 214.59,58.28 v1(214.92,58.61) ; CW3.1 CW4.1 67.17,116.7 CW5.1 66.61,117.79 v1(66.44,117.97) ; R50.2 181.69,69.36 v1(181.69,68.63) 182.27,68.05 R49.1 ; RC181.1 104.42,38.17 104.32,38.27 v1(103.84,38.27) ; v1(30.06,106.09) 30.91,106.09 RT117.1 ; v1(139.04,48.78) 139.04,48.15 140.62,46.57 v1(141.3,46.57) ; v1(34.48,115.27) 33.97,115.27 33.18,114.49 RT115.2 ; v1(44.29,90.36) 44.24,90.3 CE22.1 ; v1(70.27,41.6) 70.27,42.53 RD1.1 RD2.1 ; v1(42.32,111.78) 42.21,111.89 CT75.1 ; 32.51,103.18 v1(32.5,103.2) 30.09,103.2 29.77,103.52 RT93.1 ; RD15.1 v1(56.25,69.64) 56.25,71.62 55.18,72.69 RE13.2 ; RL3.1 25,87.22 v1(25.28,87.5) ; R83.1 R82.1 v1(53.13,110.83)
  IN1 w0.508: v1(104.66,45.39) 104.99,45.39 108.75,49.14 v1(108.75,50.33) 107.49,50.33 107.17,50.64 106.69,50.64 105.59,51.75 103.93,51.75 103.82,51.86 v1(103.32,51.86) ; v1(103.46,45.59) 103.17,45.88 100.76,45.88 99.54,44.66 96.71,44.66 95.58,43.53 85.06,43.53 83.82,42.29 81.98,42.29 81.64,41.94 79.18,41.94 v1(78.82,41.59) ; v1(210.5,56) 210.6,55.91 210.6,51.72 ; v1(53.13,110.83) 50.76,110.83 48.92,108.99 47.14,108.99 46.7,108.55 v1(46.7,108.02) ; v1(40.54,90.76) 41.26,90.04 43.98,90.04 v1(44.29,90.36) ; v1(68.32,67.86) 68.32,68.05 67.81,68.56 65.6,68.56 65.41,68.37 60.07,68.37 58.8,67.1 56.5,67.1 56.07,67.54 56.07,69.45 v1(56.25,69.64) ; v1(28.67,88.69) 27.51,88.69 27.12,88.3 25.75,88.3 25.28,87.83 v1(25.28,87.5) ; v1(50.2,46.77) 53.56,46.77 v1(55.56,48.77)
  IN2 w0.305: v1(34.48,115.27) 34.16,114.96 31.02,114.96 30.55,114.49 30.55,113.91 30.2,113.57 v1(30.02,113.57) 30.7,112.89 31.18,112.89 v1(33.54,110.53) 33.64,110.43 40.13,110.43 41.49,111.78 v1(42.32,111.78) 44.19,113.66 44.19,114.45 v1(44.67,114.92)
  IN2 w0.508: v1(149.13,41.97) 148.45,41.97 148.19,41.71 143.01,41.71 141.3,43.43 v1(141.3,46.57) ; v1(77.71,42.92) 77.02,42.23 76.56,42.23 75.49,41.16 74.61,41.16 74.06,41.71 72.54,41.71 72.43,41.6 v1(70.27,41.6) ; v1(216.43,55.74) 216.43,56.21 214.92,57.72 v1(214.92,58.61) ; v1(196.88,32.63) 195.84,33.68 193.34,33.68 192.25,32.58 188.43,32.58 187.84,33.17 181.16,33.17 v1(180.99,33.33) ; v1(118.44,28.13) 118.6,27.97 v1(120.2,27.97) 124.05,27.97 125.18,29.11 v1(126.03,29.11) ; 211.97,46.4 212.52,45.86 212.52,42.38 212.11,41.97 212.11,39.09 211.65,38.63 211.65,37.8 214.21,35.25 v1(214.21,34.04) ; v1(122.82,44.84) 124.36,44.84 v1(124.84,45.32) ; v1(30.06,106.09) 30.06,104.21 31.07,103.2 v1(32.5,103.2) 32.5,102.5 34.64,100.35 v1(35.51,100.35) ; v1(182.29,62.26) 182.29,60.82 v1(181.4,59.93) 181.07,59.6 180.46,59.6 179.73,60.33 176.76,60.33 175.47,61.62 175.47,64.58 v1(174.89,65.16) ; v1(181.69,68.63) 181.69,65.96 183.54,64.11 v1(183.95,64.11) 185.37,64.11 186.02,63.46 191.27,63.46 191.89,62.84 v1(192.11,62.84) ; v1(139.04,48.78) 139.26,49 139.26,50.8 139.83,51.36 141.06,51.36 v1(141.69,52)
  IN3 w0.508: v1(137.63,116.95) 138.32,116.95 138.93,116.34 138.93,115.44 139.15,115.22 v1(139.15,114.5) 138.92,114.27 138.92,112.43 139.48,111.87 140.93,111.87 146.62,106.19 146.62,96.52 148.15,94.98 148.15,93.04 v1(148.98,92.21) ; v1(214.21,34.04) 214.92,33.33 219.65,33.33 221.75,35.43 v1(222.53,35.43) 222.59,35.49 v1(222.59,38.77) ; v1(192.11,62.84) 191.87,62.59 191.87,60.69 194.65,57.91 202,57.91 202.78,57.13 205.88,57.13 206.15,56.85 209.02,56.85 v1(209.87,56) ; v1(28.67,88.69) 28.67,89.37 34.6,95.3 34.6,99.45 v1(35.51,100.35)
  IN3 w1.016: 25.82,32.53 24.1,30.82 24.1,28.42 29.64,22.88 32.25,22.88
  BOTTOM w0.254: 107.04,33.42 107.04,33.18 107.25,32.97 UX1.8
  BOTTOM w0.305: JDIMM1.255 78.27,44.49 77.86,44.08 77.86,43.08 v1(77.71,42.92) ; QI2.5 v1(28.67,88.69) ; v1(119.92,32.74) 119.92,33.53 119.03,34.43 117.26,34.43 116.63,33.79 116.63,32.96 116.02,32.35 116.02,31.96 115.02,30.96 RX6.1 ; v1(103.84,38.27) 103.84,37.76 RC28.1 ; 99.13,34.12 99.02,34.01 99.02,33.68 v1(98.83,33.49) ; 99.13,34.12 100.12,34.12 RC27.1 100.74,34.28 QC1.5 ; 99.13,34.12 99.13,34.27 99.51,34.65 99.51,35.27 100.74,36.51 QC1.2 ; v1(25.28,87.5) 25.28,88.35 25.62,88.69 QI2.2 ; RC205.2 128.21,45.17 v1(128.21,44.92) ; v1(35.51,100.35) 35.52,100.36 35.52,103.86 36.24,104.58 36.24,109.65 35.87,110.02 34.05,110.02 v1(33.54,110.53) ; v1(64.42,44.33) 65.19,44.33 65.36,44.49 JDIMM2.255
  BOTTOM w0.356: v1(182.29,62.26) 182.19,62.16 181.75,62.16 181.08,62.84 U2.1 ; C42.1 v1(222.59,38.77)
  BOTTOM w0.381: 179.92,63.36 180.57,63.36 U2.1 ; v1(180.99,33.33) 180.99,33.86 180.06,34.79 180.06,36.36 180.54,36.84 181.56,36.84 RC209.1
  BOTTOM w0.406: v1(139.04,48.78) 139.04,48.55 139.56,48.03 139.76,48.03 RC86.1 139.98,47.81 140.57,47.81 140.9,47.48 RC3.2
  BOTTOM w0.508: v1(56.25,69.64) 55.81,69.64 55.05,68.88 55.05,56.18 v1(55.33,55.9) ; v1(181.4,59.93) 181.4,58.87 181.05,58.52 PRZ16.1 ; v1(105.96,38.54) 105.91,38.54 105.89,38.56 105.75,38.56 105.41,38.9 RC188.1 ; R28.1 174.89,64.47 v1(174.89,65.16) ; v1(124.84,45.32) 125.08,45.55 RC42.1 ; C21.1 181.19,66.05 181.69,66.56 v1(181.69,68.63) ; JIOB1.12 202.24,35.69 201.25,34.7 201.25,32.85 201.65,32.46 ; RC206.2 131.4,37.75 131.89,38.24 RC1.2 ; v1(108.75,50.33) RC115.1 108.78,49.7 RC114.1 ; v1(126.03,29.11) 126.12,29.02 126.12,26.13 126.54,25.71 128.22,25.71 v1(128.86,25.07) ; v1(103.48,42.07) 103.48,42.75 103.97,43.25 103.97,45.08 v1(103.46,45.59) ; RC2.2 131.87,38.61 RC1.2 ; R29.1 178.43,61.87 179.92,63.36 ; RC36.1 123.02,44.84 v1(122.82,44.84) ; 201.65,32.46 203.06,31.05 214.05,31.05 214.64,31.64 214.64,32.36 214.21,32.8 v1(214.21,34.04) ; 201.65,32.46 200.58,31.39 197.47,31.39 196.88,31.97 v1(196.88,32.63) ; RC57.1 125.59,45.43 125.49,45.53 RC42.1 ; RC61.1 130.19,43.22 v1(130.4,43.43) ; v1(104.66,45.39) 105.22,44.82 105.22,43.12 104.12,42.02 v1(104.12,41.95) ; v1(222.53,35.43) 223.13,34.82 R72.1 ; RC69.2 144.43,39.34 RC35.1 144.34,39.04 143.97,38.66 RC49.1 144.8,38.27 v1(144.86,38.32) ; 107.04,33.42 107.04,34.22 106.35,34.92 CX4.1 CX3.1 106.48,36.4 v1(106.48,37.3) ; RC42.1 RC55.1 ; RC116.1 141.46,51.76 v1(141.69,52) ; v1(148.98,92.21) 148.63,91.86 RC105.1 ; RC1.2 132.09,38.62 v1(132.6,39.13) ; v1(139.15,114.5) 139.54,114.5 140.88,113.17 PRW05.1
  vias: v1(27.19,32.85) v1(27.82,32.85) v1(28.46,32.85) v1(29.09,32.85) v1(33.03,22.2) v1(33.59,21.94) v1(38.08,38.77) v1(38.72,38.77) v1(39.35,38.77) v1(40.65,56.69) v1(40.65,56.1) v1(40.65,55.52) v1(41.23,56.69) v1(41.23,56.1) v1(41.23,55.52) v1(41.23,54.94) v1(41.82,56.69) v1(41.82,56.1) v1(41.82,55.52) v1(80.22,120.37) v1(80.76,120.09) v1(211.04,50.82) v1(211.03,50.24) v1(211.03,46.95) v1(211.45,47.37) v3(58.58,41.18)
