# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D31: length 66.3
  IN3 w0.076: 104.46,86.9 104.84,86.52 111.95,86.52 113.25,85.23 113.97,85.23 115.04,84.16 v1(116.7,84.16)
  IN3 w0.117: 104.46,86.9 104.05,87.31 93.57,87.31 91.11,89.77 90.94,89.77 90.26,89.09 90.1,89.09 89.93,89.26 89.93,89.42 90.61,90.1 90.61,90.27 90.2,90.68 77.56,90.68 77.44,90.8 77.44,91.06 77.32,91.17 77.09,91.17 76.97,91.06 76.97,90.8 76.86,90.68 76.39,90.68 76.27,90.8 76.27,90.84 76.12,90.99 75.96,90.99 75.8,90.84 75.8,90.8 75.69,90.68 72.16,90.68 71.81,90.33 66.03,90.33 65.52,89.81 61.56,89.81 61.44,89.7 61.44,89.4 v1(61.57,89.27)
  BOTTOM w0.076: v1(116.7,84.16) 116.7,84.14 117.03,83.8 UC1.AU60
  BOTTOM w0.112: v1(61.57,89.27) 60.6,90.24 JDIMM2.80
DDR_B_D32: length 65.3
  IN3 w0.076: v1(116.61,73.08) 116.61,73.07 115.45,73.07 112.68,70.31 112.31,70.31 111.31,69.32 104.58,69.32
  IN3 w0.109: 102.76,67.5 104.58,69.32
  IN3 w0.117: v1(63.04,64.95) 62.82,64.95 62.59,64.71 62.59,64.32 62.71,64.2 64.74,64.2 65.11,64.57 71.19,64.57 71.31,64.69 71.31,65.32 71.41,65.41 77.66,65.41 77.77,65.29 77.77,65.07 77.89,64.96 78.12,64.96 78.24,65.07 78.24,65.29 78.36,65.41 78.59,65.41 78.71,65.29 78.71,65.07 78.83,64.96 79.06,64.96 79.18,65.07 79.18,65.29 79.29,65.41 79.53,65.41 79.64,65.29 79.64,65.07 79.76,64.96 79.99,64.96 80.11,65.07 80.11,65.29 80.23,65.41 81.17,65.41 81.17,65.42 88.46,65.42 88.99,65.96 92.55,65.96 93.84,67.24 102.51,67.24 102.76,67.5
  BOTTOM w0.076: UC1.AU40 116.92,72.77 v1(116.61,73.08)
  BOTTOM w0.102: JDIMM2.169 64.08,65.99 v1(63.04,64.95)
DDR_B_D33: length 65.9
  IN3 w0.076: v1(117.36,73.13) 117.34,73.13 117.34,73.15 117.05,73.43 114.66,73.43 111.79,70.56 104.72,70.56 104.16,69.99 104.16,69.21 102.98,68.03
  IN3 w0.109: 102.71,67.76 102.98,68.03
  IN3 w0.117: v1(64.61,64.95) 67.09,64.95 67.2,65.06 67.2,65.4 67.32,65.51 68.62,65.51 68.74,65.4 68.74,65.02 68.86,64.9 69.09,64.9 69.21,65.02 69.21,65.42 69.33,65.54 69.95,65.54 70.15,65.74 70.4,65.74 70.51,65.63 70.51,65.02 70.63,64.9 70.86,64.9 70.98,65.02 70.98,65.63 71.1,65.74 78.61,65.74 78.62,65.75 79.78,65.75 79.79,65.75 83.62,65.75 83.74,65.87 83.74,66.17 83.86,66.29 84.09,66.29 84.21,66.17 84.21,65.87 84.32,65.75 84.56,65.75 84.68,65.87 84.68,66.17 84.79,66.29 85.03,66.29 85.14,66.17 85.14,65.87 85.26,65.75 85.49,65.75 85.61,65.87 85.61,66.17 85.73,66.29 85.96,66.29 86.08,66.17 86.08,65.87 86.19,65.75 86.43,65.75 86.54,65.87 86.54,66.17 86.66,66.29 86.91,66.29 87.02,66.17 87.02,65.87 87.14,65.75 87.37,65.75 87.49,65.87 87.49,66.17 87.61,66.29 87.85,66.29 87.97,66.17 87.97,65.87 88.08,65.75 88.32,65.75 88.43,65.87 88.43,66.17 88.55,66.29 92.42,66.29 93.7,67.58 102.53,67.58 102.71,67.76
  BOTTOM w0.076: UC1.AT40 117.68,72.8 v1(117.36,73.13)
  BOTTOM w0.102: v1(64.61,64.95) 64.66,64.99 JDIMM2.173
DDR_B_D34: length 66.6
  IN3 w0.076: 104.4,67.86 105.92,67.86 106.26,67.52 111.34,67.52 112.17,68.35 112.17,69.19 112.58,69.6 113.11,69.6 114.49,70.99 116.79,70.99 117.21,71.41 v1(117.33,71.41)
  IN3 w0.109: 104.4,67.86 103.13,66.59 103.13,66.51 102.95,66.33
  IN3 w0.117: v1(63.04,61.64) 63.43,61.25 63.44,61.25 63.46,61.23 65.06,61.23 65.92,62.09 65.92,62.39 66.46,62.93 67.1,62.93 67.22,62.82 67.22,62.58 67.36,62.43 71.07,62.43 71.18,62.54 71.43,62.54 71.54,62.66 71.54,62.82 71.66,62.93 71.89,62.93 72.01,62.82 72.01,62.66 72.13,62.54 72.36,62.54 72.48,62.66 72.48,62.82 72.59,62.93 72.83,62.93 72.94,62.82 72.94,62.66 73.06,62.54 73.3,62.54 73.41,62.66 73.41,62.87 73.53,62.98 73.76,62.98 73.88,62.87 73.88,62.66 74,62.54 79.75,62.54 80.22,62.07 80.73,62.07 82.4,63.74 89.13,63.74 89.7,64.31 93.23,64.31 94.44,65.52 102.14,65.52 102.95,66.33
  BOTTOM w0.076: v1(117.33,71.41) UC1.AT37
  BOTTOM w0.112: v1(63.04,61.64) 63.54,62.14 64.52,62.14 64.86,62.49 JDIMM2.183
DDR_B_D35: length 66.2
  IN3 w0.076: 104.78,68.37 104.85,68.44 111.19,68.44 112.55,69.81 113.08,69.81 114.68,71.41 v1(116.68,71.41)
  IN3 w0.117: 104.78,68.37 104.57,68.37 102.93,66.73 102.93,66.64 102.23,65.94 94.38,65.94 93.09,64.65 89.56,64.65 88.99,64.08 82.13,64.08 81.71,63.65 81.25,63.65 81.13,63.54 81.13,62.95 81.02,62.84 80.78,62.84 80.67,62.95 80.67,63.54 80.55,63.65 80.32,63.65 80.2,63.54 80.2,62.98 80.08,62.86 79.85,62.86 79.73,62.98 79.73,63.54 79.62,63.65 79.37,63.65 79.25,63.54 79.25,62.99 79.14,62.88 78.9,62.88 78.79,62.99 78.79,63.54 78.67,63.65 78.44,63.65 78.32,63.54 78.32,62.99 78.2,62.88 77.97,62.88 77.85,62.99 77.85,63.54 77.74,63.65 77.49,63.65 77.02,63.18 74.47,63.18 74.39,63.27 73.94,63.27 73.82,63.38 73.82,63.54 73.71,63.65 73.47,63.65 73.36,63.54 73.36,63.38 73.24,63.27 71.17,63.27 71.05,63.15 71.05,62.88 70.94,62.77 70.7,62.77 70.59,62.88 70.59,63.15 70.47,63.27 70.23,63.27 70.12,63.15 70.12,62.88 70,62.77 69.77,62.77 69.65,62.88 69.65,63.15 69.53,63.27 66.32,63.27 65.59,62.53 65.59,62.22 65,61.64 v1(64.56,61.64)
  BOTTOM w0.076: v1(116.68,71.41) UC1.AU37
  BOTTOM w0.112: v1(64.56,61.64) 64.72,61.49 66.45,61.49 JDIMM2.187
DDR_B_D36: length 65.8
  IN3 w0.076: 103.71,69.84 103.71,70.01 104.82,71.12 111.86,71.12 114.5,73.76 118.02,73.76 v1(118.63,73.15)
  IN3 w0.117: 103.71,69.84 103.71,69.38 102.57,68.24 93.43,68.24 92.14,66.95 80.03,66.95 79.49,66.41 78.34,66.41 78.34,66.41 70.2,66.41 69.88,66.73 69.27,66.73 69.19,66.81 68.83,66.81 68.78,66.75 67.26,66.75 66.21,65.7 60.75,65.7 v1(59.99,64.95)
  BOTTOM w0.076: v1(118.63,73.15) 118.33,72.86 UC1.AR40
  BOTTOM w0.102: JDIMM2.170 59.2,65.74 v1(59.99,64.95)
DDR_B_D37: length 67.7
  IN3 w0.076: v1(118.61,72.31) 118.61,72.67 117.68,73.6 114.59,73.6 111.95,70.96 104.89,70.96 103.96,70.03 103.96,69.87
  IN3 w0.109: 103.96,69.87 103.96,69.35 102.52,67.91 102.41,67.91
  IN3 w0.117: v1(61.52,64.95) 61.52,65.24 61.63,65.36 66.34,65.36 66.9,65.92 69.86,65.92 70.02,66.08 78.47,66.08 78.48,66.08 79.63,66.08 80.17,66.62 81.77,66.62 81.89,66.5 81.89,66.2 82.01,66.08 82.24,66.08 82.36,66.2 82.36,66.5 82.47,66.62 82.71,66.62 82.82,66.5 82.82,66.2 82.94,66.08 83.17,66.08 83.29,66.2 83.29,66.5 83.41,66.62 92.28,66.62 93.57,67.91 102.41,67.91
  BOTTOM w0.076: v1(118.61,72.31) UC1.AP40
  BOTTOM w0.102: 59.04,64.74 59.31,64.74 59.51,64.54 61.11,64.54 v1(61.52,64.95)
  BOTTOM w0.112: JDIMM2.174 59.04,64.74
DDR_B_D38: length 68.7
  IN3 w0.076: 104.52,67.61 105.92,67.61 106.17,67.35 111.41,67.35 112.34,68.28 112.34,68.35 114.81,70.82 116.41,70.82 116.42,70.81 116.87,70.81 117.11,71.05 118.25,71.05 v1(118.61,71.4)
  IN3 w0.109: 104.52,67.61 103.51,66.59 103.51,66.42
  IN3 w0.117: 103.51,66.42 102.28,65.19 94.58,65.19 93.37,63.98 89.84,63.98 89.27,63.41 82.53,63.41 80.86,61.74 80.08,61.74 79.61,62.21 79.37,62.21 79.25,62.09 79.25,61.73 79.14,61.61 78.9,61.61 78.79,61.73 78.79,62.09 78.67,62.21 78.43,62.21 78.32,62.09 78.32,61.73 78.2,61.61 77.97,61.61 77.85,61.73 77.85,62.09 77.73,62.21 71.32,62.21 71.21,62.1 66.41,62.1 65.2,60.9 62.26,60.9 v1(61.52,61.64)
  BOTTOM w0.076: v1(118.61,71.4) UC1.AP37
  BOTTOM w0.112: v1(61.52,61.64) 61,61.13 59.92,61.13 59.31,61.74 JDIMM2.186
DDR_B_D39: length 67.9
  IN3 w0.076: v1(118.64,70.49) 118.28,70.85 117.18,70.85 116.98,70.65 116.28,70.65 116.27,70.66 114.87,70.66 112.5,68.28 112.5,68.21 111.48,67.19 106.08,67.19 105.92,67.35 104.65,67.35
  IN3 w0.117: 104.65,67.35 103.81,66.51 103.81,66.24 102.42,64.86 95.06,64.86 93.85,63.65 89.98,63.65 89.4,63.08 82.67,63.08 80.83,61.24 66.01,61.24 64.91,60.13 60.3,60.13 59.99,60.45 v1(59.99,61.64)
  BOTTOM w0.076: v1(118.64,70.49) UC1.AR37
  BOTTOM w0.112: JDIMM2.182 59.35,62.74 59.99,62.1 v1(59.99,61.64)
DDR_B_D40: length 68.1
  IN3 w0.076: v1(117.34,69.57) 117.2,69.57 116.86,69.91 116.39,69.91 116.1,69.61 114.63,69.61 111.7,66.69 104.86,66.69 104.52,66.36 104.37,66.2 104.37,65.13 102.91,63.67 102.86,63.67
  IN3 w0.109: v1(61.52,59.61) 61.97,59.15 62.99,59.15 63.27,58.88 63.28,58.88
  IN3 w0.117: 102.86,63.67 96.65,63.67 94.87,61.89 84.5,61.89 84.38,61.77 84.38,60.16 84.27,60.05 81.22,60.05 80.43,59.26 78.38,59.26 78.26,59.38 78.26,59.93 78.15,60.05 77.91,60.05 77.8,59.93 77.8,59.38 77.68,59.26 72.23,59.26 72.15,59.34 65.8,59.34 65.32,58.86 63.51,58.86 63.5,58.88 63.28,58.88
  BOTTOM w0.076: UC1.AT33 117.47,69.39 v1(117.34,69.57)
  BOTTOM w0.112: JDIMM2.190 59.32,60.74 59.63,60.43 60.7,60.43 v1(61.52,59.61)
DDR_B_D41: length 67.6
  IN3 w0.076: 103,63.34 104.27,64.61 104.27,64.79 104.54,65.06 104.54,66.14 104.86,66.46 112.02,66.46 113.03,67.48 113.54,67.48 115.44,69.38 116.15,69.38 116.32,69.56 v1(116.69,69.56)
  IN3 w0.102: 63.07,58.64 63.07,58.4
  IN3 w0.109: 60.78,58.83 62.88,58.83 63.07,58.64
  IN3 w0.117: 103,63.34 96.78,63.34 95,61.56 84.83,61.56 84.72,61.44 84.72,60.03 84.4,59.71 81.36,59.71 80.57,58.93 72.1,58.93 72.04,58.99 65.92,58.99 65.74,58.82 65.74,58.1 65.65,58.01 64.37,58.01 64.26,58.12 64.26,58.41 64.14,58.53 63.91,58.53 63.79,58.41 63.79,58.12 63.67,58.01 63.19,58.01 63.07,58.12 63.07,58.4 ; v1(59.99,59.61) 60.78,58.83
  BOTTOM w0.076: UC1.AU33 117.03,69.21 v1(116.69,69.56)
  BOTTOM w0.112: v1(59.99,59.61) 59.58,59.61 59.45,59.74 JDIMM2.194
DDR_B_D42: length 66.6
  IN3 w0.076: 104.89,64.61 105.4,65.13 112.58,65.13 114.94,67.49 116.3,67.49 v1(116.68,67.87)
  IN3 w0.109: 104.89,64.61 104.89,63.91 102.98,62 102.86,62
  IN3 w0.117: v1(64.56,56.63) 64.79,56.4 67.82,56.4 68.74,57.32 71.6,57.32 72.52,56.4 78.24,56.4 78.36,56.52 78.36,57.03 78.48,57.15 78.71,57.15 78.83,57.03 78.83,56.52 78.94,56.4 79.18,56.4 79.29,56.52 79.29,57.03 79.41,57.15 79.65,57.15 79.76,57.03 79.76,56.52 79.88,56.4 82.92,56.4 83.04,56.52 83.04,58.22 83.16,58.33 83.4,58.33 83.52,58.22 83.52,57.14 83.63,57.02 83.87,57.02 83.98,57.14 83.98,58.22 84.1,58.33 84.87,58.33 86.79,60.25 95.54,60.25 97.29,62 102.86,62
  BOTTOM w0.076: v1(116.68,67.87) 116.7,67.87 116.7,67.85 116.72,67.82 116.72,67.81 117.05,67.36 UC1.AU30
  BOTTOM w0.112: v1(64.56,56.63) 64.7,56.49 66.45,56.49 JDIMM2.207
DDR_B_D43: length 67.4
  IN3 w0.076: v1(117.41,67.8) 117.41,67.7 117.04,67.32 115.03,67.32 112.67,64.96 105.53,64.96 105.09,64.52
  IN3 w0.109: 103.03,61.67 105.09,63.73 105.09,64.52
  IN3 w0.117: 103.03,61.67 97.43,61.67 95.68,59.92 86.93,59.92 85.01,58 84.54,58 84.42,57.88 84.42,56.19 84.31,56.07 84.07,56.07 83.95,56.19 83.95,56.57 83.84,56.69 83.6,56.69 83.49,56.57 83.49,56.19 83.37,56.07 72.15,56.07 71.24,56.99 68.88,56.99 67.88,55.98 63.16,55.98 63.04,56.1 v1(63.04,56.63)
  BOTTOM w0.076: UC1.AT30 117.68,67.31 117.4,67.68 v1(117.41,67.8)
  BOTTOM w0.112: JDIMM2.203 63.9,57.49 v1(63.04,56.63)
DDR_B_D44: length 69
  IN3 w0.076: v1(117.97,69.57) 117.62,69.92 117.11,69.92 116.96,70.08 116.27,70.08 115.97,69.78 114.54,69.78 111.62,66.86 104.79,66.86 104.36,66.42 104.21,66.27 104.21,65.35 102.86,64
  IN3 w0.109: 63.75,59.2 63.45,59.2 v1(63.04,59.61)
  IN3 w0.117: 63.75,59.2 65.18,59.2 66.37,60.38 66.61,60.38 66.73,60.26 66.73,59.79 66.84,59.68 67.08,59.68 67.19,59.79 67.19,60.26 67.31,60.38 67.54,60.38 67.66,60.26 67.66,59.79 67.78,59.68 68.01,59.68 68.13,59.79 68.13,60.26 68.24,60.38 69.85,60.38 69.97,60.26 69.97,60.02 70.08,59.9 70.32,59.9 70.43,60.02 70.43,60.26 70.55,60.38 79.8,60.38 80.28,59.9 80.6,59.9 81.08,60.38 83.93,60.38 84.05,60.5 84.05,62.1 84.17,62.22 94.73,62.22 96.51,64 102.86,64
  BOTTOM w0.076: v1(117.97,69.57) 118.11,69.39 UC1.AR33
  BOTTOM w0.112: v1(63.04,59.61) 63.92,60.49 JDIMM2.191
DDR_B_D45: length 69.7
  IN3 w0.076: v1(118.61,69.57) 118.61,70.03 118.5,70.14 118.49,70.14 118.34,70.29 117.64,70.29 117.47,70.13 117.18,70.13 117.01,70.29 116.23,70.29 115.88,69.94 114.47,69.94 111.55,67.02 105.87,67.02 105.79,67.1 104.81,67.1 104.73,67.02 104.72,67.02 104.19,66.49 104.19,66.49 104.04,66.34 104.04,65.74 102.86,64.56
  IN3 w0.117: 102.86,64.56 102.64,64.33 96.37,64.33 94.59,62.55 92.91,62.55 92.79,62.67 92.79,63.01 92.67,63.13 92.44,63.13 92.32,63.01 92.32,62.67 92.21,62.55 91.97,62.55 91.86,62.67 91.86,63.01 91.74,63.13 91.51,63.13 91.39,63.01 91.39,62.67 91.27,62.55 91.04,62.55 90.92,62.67 90.92,63.01 90.8,63.13 90.57,63.13 90.45,63.01 90.45,62.67 90.34,62.55 83.83,62.55 83.72,62.44 83.72,60.83 83.6,60.71 83.37,60.71 83.25,60.83 83.25,62.29 83.13,62.4 82.74,62.4 82.62,62.29 82.62,60.83 82.51,60.71 82.12,60.71 81.99,60.84 81.99,61.19 81.88,61.31 81.64,61.31 81.52,61.19 81.52,60.84 81.4,60.71 66.23,60.71 65.13,59.61 v1(64.56,59.61)
  BOTTOM w0.076: v1(118.61,69.57) 118.75,69.39 UC1.AP33
  BOTTOM w0.112: JDIMM2.195 66.45,59.49 65.1,59.49 64.98,59.61 v1(64.56,59.61)
DDR_B_D46: length 68.1
  IN3 w0.076: v1(117.97,67.77) 117.62,67.42 117.37,67.42 117.11,67.16 115.12,67.16 112.76,64.79 105.64,64.79 105.28,64.44
  IN3 w0.109: 105.28,64.44 105.28,63.54 103.08,61.33
  IN3 w0.117: v1(61.52,56.63) 62.49,55.65 68.02,55.65 69.02,56.65 71.1,56.65 72.01,55.74 84.64,55.74 84.75,55.85 84.75,57.28 87.06,59.59 95.82,59.59 97.57,61.33 103.08,61.33
  BOTTOM w0.076: UC1.AR30 118.33,67.31 v1(117.97,67.77)
  BOTTOM w0.112: JDIMM2.204 59.31,57.24 59.48,57.06 61.08,57.06 v1(61.52,56.63)
DDR_B_D47: length 68.9
  IN3 w0.076: 110.99,63.41 111.19,63.41 111.71,63.94 112.38,63.94 112.9,64.46 112.9,64.69 115.21,66.99 117.18,66.99 117.39,67.21 117.97,67.21 118.52,67.77 v1(118.61,67.77)
  IN3 w0.109: 110.99,63.41 105.54,63.41 103.13,61 103,61
  IN3 w0.117: 103,61 97.71,61 95.96,59.25 87.2,59.25 85.09,57.14 85.09,55.52 84.97,55.41 71.76,55.41 71.5,55.67 68.57,55.67 68.2,55.29 60.11,55.29 59.99,55.41 v1(59.99,56.63)
  BOTTOM w0.076: UC1.AP30 118.98,67.31 v1(118.61,67.77)
  BOTTOM w0.112: v1(59.99,56.63) 59.6,56.24 JDIMM2.208
DDR_B_D48: length 68.1
  IN3 w0.076: 104.64,59.48 104.91,59.48 106.94,61.51 110.57,61.51 112.22,63.16 113.41,63.16 114.3,64.05 114.3,65.07 115.14,65.9 v1(116.71,65.9)
  IN3 w0.117: v1(59.99,54.66) 59.99,53.52 60.11,53.4 60.48,53.4 60.6,53.52 60.6,53.97 60.71,54.08 60.95,54.08 61.06,53.97 61.06,53.52 61.18,53.4 71.14,53.4 72.19,52.35 75.18,52.35 75.19,52.34 77.02,52.34 77.8,53.12 84.84,53.12 89.45,57.73 96.59,57.73 98.34,59.48 104.64,59.48
  BOTTOM w0.076: v1(116.71,65.9) 116.7,65.9 116.7,65.9 UC1.AU27
  BOTTOM w0.112: v1(59.99,54.66) 59.57,54.24 JDIMM2.216
DDR_B_D49: length 69
  IN3 w0.076: 104.64,59.81 104.73,59.81 106.68,61.76 110.59,61.76 112.15,63.33 113.32,63.33 114.05,64.05 114.05,65.07 115.24,66.26 116.92,66.26 117.27,65.91 117.31,65.91 v1(117.34,65.89)
  IN3 w0.117: 104.64,59.81 98.2,59.81 96.45,58.06 89.31,58.06 84.7,53.45 74.26,53.45 74.15,53.34 74.15,52.8 74.03,52.68 73.79,52.68 73.68,52.8 73.68,53.34 73.56,53.45 73.33,53.45 73.21,53.34 73.21,52.8 73.09,52.68 72.86,52.68 72.74,52.8 72.74,53.34 72.63,53.45 72.38,53.45 72.03,53.8 62.37,53.8 v1(61.52,54.66)
  BOTTOM w0.076: UC1.AT27 117.36,65.88 v1(117.34,65.89)
  BOTTOM w0.112: v1(61.52,54.66) 60.94,55.24 JDIMM2.212
DDR_B_D50: length 66.7
  IN3 w0.076: v1(117.34,65.01) 117.32,65.01 116.65,64.34 115.59,64.34 114.52,63.27 114.52,62.54 113.57,61.58 111.89,61.58 110.73,60.42 107.82,60.42 106.83,59.43
  IN3 w0.109: 106.83,59.43 105.24,57.84 104.64,57.84
  IN3 w0.117: v1(64.56,50.88) 69.19,50.88 69.4,50.66 71.18,50.66 71.55,50.29 79.73,50.29 79.85,50.41 79.85,51.37 79.97,51.48 80.2,51.48 80.32,51.37 80.32,50.41 80.43,50.29 80.67,50.29 80.79,50.41 80.79,51.37 80.9,51.48 81.14,51.48 81.25,51.37 81.25,50.82 81.37,50.71 81.6,50.71 81.72,50.82 81.72,51.37 81.84,51.48 85.59,51.48 90.2,56.09 97.27,56.09 99.02,57.84 104.64,57.84
  BOTTOM w0.076: v1(117.34,65.01) 117.34,65 UC1.AT25
  BOTTOM w0.112: v1(64.56,50.88) 64.56,51.4 65.16,51.99 JDIMM2.225
DDR_B_D51: length 66.5
  IN3 w0.076: v1(116.66,65) 116.66,64.63 116.54,64.51 115.53,64.51 114.36,63.34 114.36,62.6 113.5,61.75 111.82,61.75 110.69,60.62 107.57,60.62 106.67,59.72
  IN3 w0.109: 106.67,59.72 105.12,58.17 104.64,58.17
  IN3 w0.117: 104.64,58.17 98.88,58.17 97.13,56.43 90.06,56.43 85.46,51.82 79.52,51.82 79.4,51.7 79.4,51.09 79.28,50.97 79.05,50.97 78.93,51.09 78.93,51.7 78.82,51.82 78.57,51.82 77.38,50.62 72.2,50.62 71.78,51.04 69.49,51.04 69.24,51.3 63.46,51.3 v1(63.04,50.88)
  BOTTOM w0.076: v1(116.66,65) 116.66,64.97 117.03,64.6 UC1.AU25
  BOTTOM w0.112: v1(63.04,50.88) 63.46,50.46 64.77,50.46 65.3,50.99 JDIMM2.229
DDR_B_D52: length 68.9
  IN3 w0.076: v1(118.61,65.91) 118.23,66.29 117.12,66.29 116.93,66.49 115.22,66.49 113.79,65.07 113.79,64.05 113.25,63.51 112.07,63.51 111.47,62.91 108.47,62.91
  IN3 w0.109: 102.99,60.15 103.09,60.15 105.86,62.91 108.47,62.91
  IN3 w0.117: v1(63.04,54.66) 63.56,54.14 72.17,54.14 72.52,53.79 77.68,53.79 77.8,53.9 77.8,54.43 77.91,54.55 78.15,54.55 78.26,54.43 78.26,53.9 78.38,53.79 78.61,53.79 78.73,53.9 78.73,54.43 78.85,54.55 79.08,54.55 79.2,54.43 79.2,53.9 79.31,53.79 84.56,53.79 89.17,58.4 96.31,58.4 98.06,60.15 102.99,60.15
  BOTTOM w0.076: UC1.AP27 v1(118.61,65.91)
  BOTTOM w0.112: JDIMM2.211 63.87,55.49 v1(63.04,54.66)
DDR_B_D53: length 69.7
  IN3 w0.076: v1(119.24,65.91) 118.69,66.46 117.21,66.46 117.02,66.65 115.13,66.65 113.16,64.69 113.16,64.48 112.41,63.73 111.95,63.73 111.38,63.16 110.68,63.16
  IN3 w0.109: 110.68,63.16 105.83,63.16 103.15,60.48 102.92,60.48
  IN3 w0.117: 102.92,60.48 97.93,60.48 96.18,58.73 89.04,58.73 88.63,58.32 88.46,58.32 88.21,58.58 88.04,58.58 87.87,58.41 87.87,58.25 88.13,57.99 88.13,57.82 87.97,57.66 87.8,57.66 87.16,58.3 86.99,58.3 86.83,58.14 86.83,57.97 87.47,57.33 87.47,57.16 87.3,57 87.14,57 86.49,57.64 86.33,57.64 86.16,57.47 86.16,57.31 86.81,56.67 86.81,56.5 86.64,56.34 86.48,56.34 85.94,56.87 85.78,56.87 85.61,56.71 85.61,56.54 86.15,56.01 86.15,55.84 84.84,54.53 80.24,54.53 79.88,54.88 71.54,54.88 71.51,54.91 68.56,54.91 68.16,54.52 64.71,54.52 v1(64.56,54.66)
  BOTTOM w0.076: UC1.AN27 119.44,65.68 v1(119.24,65.91)
  BOTTOM w0.112: JDIMM2.215 66.45,54.49 65.14,54.49 64.98,54.66 v1(64.56,54.66)
DDR_B_D54: length 69.1
  IN3 w0.076: v1(119.24,65) 118.72,64.47 117.25,64.47 116.79,64.01 115.73,64.01 114.85,63.13 114.85,62.4 113.71,61.25 112.08,61.25 110.82,60 107.96,60 105.25,57.29
  IN3 w0.117: v1(59.99,50.88) 60.82,50.05 68.26,50.05 68.77,49.54 84.6,49.54 90.48,55.43 97.55,55.43 99.29,57.18 105.14,57.18 105.25,57.29
  BOTTOM w0.076: UC1.AN25 v1(119.24,65)
  BOTTOM w0.112: v1(59.99,50.88) 59.63,51.24 JDIMM2.228
DDR_B_D55: length 68.7
  IN3 w0.076: 107.7,60.02 107.94,60.26 110.8,60.26 111.96,61.42 113.64,61.42 114.69,62.47 114.69,63.2 115.66,64.18 116.72,64.18 117.18,64.64 118.24,64.64 v1(118.63,65.02)
  IN3 w0.109: 104.64,57.51 105.19,57.51 107.7,60.02
  IN3 w0.117: 104.64,57.51 99.16,57.51 97.41,55.76 90.34,55.76 84.46,49.88 68.9,49.88 68.4,50.38 62.01,50.38 v1(61.52,50.88)
  BOTTOM w0.076: UC1.AP25 118.98,64.67 118.7,64.95 v1(118.63,65.02)
  BOTTOM w0.112: v1(61.52,50.88) 60.15,52.24 JDIMM2.224
DDR_B_D56: length 70.5
  IN3 w0.076: v1(117.34,63.17) 117.18,63.17 116.83,63.52 116.44,63.52 115.95,63.03 115.95,62.76 113.95,60.76 113.26,60.76 112,59.5 109.55,59.5 108.03,57.99 107.96,57.99 106.21,56.24
  IN3 w0.109: 106.21,56.24 105.96,55.99 104.64,55.99
  IN3 w0.117: 104.64,55.99 100.17,55.99 98.42,54.24 97.83,54.24 97.72,54.12 97.72,53.38 97.6,53.26 97.37,53.26 97.25,53.38 97.25,54.12 97.13,54.24 91.77,54.24 85.74,48.21 79.35,48.21 78.25,47.11 72.69,47.11 72.23,47.57 66.36,47.57 66.24,47.69 66.24,48.32 66.12,48.43 61.63,48.43 61.52,48.55 v1(61.52,49.24)
  BOTTOM w0.076: v1(117.34,63.17) UC1.AT22
  BOTTOM w0.112: v1(61.52,49.24) 60.52,50.24 JDIMM2.232
DDR_B_D57: length 69.9
  IN3 w0.076: v1(116.69,63.16) 116.59,63.16 114.17,60.75 114.17,60.67 113.55,60.05 112.78,60.05 112.07,59.34 109.61,59.34 106.14,55.87 106.12,55.87
  IN3 w0.109: 106.12,55.87 105.35,55.1 104.64,55.1
  IN3 w0.117: v1(59.99,49.24) 61.18,48.05 62.11,48.05 62.22,47.94 65.26,47.94 65.96,47.24 72.09,47.24 72.62,46.71 78.42,46.71 79.09,47.38 80.62,47.38 81.1,47.87 85.87,47.87 91.91,53.91 95.68,53.91 95.8,53.79 95.8,53.04 95.92,52.93 96.15,52.93 96.27,53.04 96.27,53.79 96.38,53.91 96.62,53.91 96.73,53.79 96.73,53.04 96.85,52.93 97.97,52.93 100.13,55.08 104.63,55.08 104.64,55.1
  BOTTOM w0.076: UC1.AU22 117.03,62.81 116.69,63.16 v1(116.69,63.16)
  BOTTOM w0.112: JDIMM2.236 58.25,49.24 v1(59.99,49.24)
DDR_B_D58: length 68.4
  IN3 w0.076: v1(116.69,62.28) 116.65,62.28 113.92,59.55 112.99,59.55 112.28,58.84 109.86,58.84 109.09,58.08 109.09,56.4 108.72,56.02 107.54,56.02 105.46,53.94
  IN3 w0.117: 105.46,53.94 105.03,53.94 104.89,53.79 100.7,53.79 98.53,51.62 94.28,51.62 94.17,51.5 94.17,50.75 94.05,50.63 93.82,50.63 93.7,50.75 93.7,51.5 93.58,51.62 93.35,51.62 93.23,51.5 93.23,50.75 93.12,50.63 92.88,50.63 92.77,50.75 92.77,51.5 92.65,51.62 92.41,51.62 92.3,51.5 92.3,50.75 92.18,50.63 91.95,50.63 91.83,50.75 91.83,51.5 91.71,51.62 91.47,51.62 86.41,46.56 82.2,46.56 80.96,45.32 77.97,45.32 77.76,45.11 71.42,45.11 71.23,45.3 70.9,45.63 67.78,45.63 67.47,45.94 65.36,45.94 65.11,46.19 v1(64.56,46.19)
  BOTTOM w0.076: v1(116.69,62.28) 117.03,61.93 UC1.AU21
  BOTTOM w0.112: JDIMM2.249 64.77,45.99 v1(64.56,46.19)
DDR_B_D59: length 70
  IN3 w0.076: v1(117.34,62.28) 117.14,62.08 117.04,62.08 116.66,61.7 116.31,61.7 113.99,59.39 113.06,59.39 111.77,58.1 110.13,58.1 109.26,57.23 109.26,56.33 108.76,55.83 108.01,55.83 105.79,53.61 105.17,53.61
  IN3 w0.117: 105.17,53.61 105.02,53.46 100.84,53.46 98.67,51.29 96.64,51.29 96.51,51.16 96.51,50.82 96.39,50.71 96.16,50.71 96.04,50.82 96.04,51.16 95.92,51.28 95.69,51.28 95.57,51.16 95.57,50.41 95.45,50.3 95.22,50.3 95.1,50.41 95.1,51.16 94.97,51.29 94.62,51.29 94.5,51.17 94.5,50.41 94.38,50.3 90.62,50.3 86.55,46.23 82.34,46.23 81.1,44.99 78.1,44.99 77.89,44.78 71.28,44.78 70.76,45.29 67.64,45.29 67.38,45.55 65.27,45.55 65.07,45.75 63.48,45.75 v1(63.04,46.19)
  BOTTOM w0.076: UC1.AT21 117.68,61.93 v1(117.34,62.28)
  BOTTOM w0.112: JDIMM2.245 63.84,46.99 v1(63.04,46.19)
DDR_B_D60: length 71.8
  IN3 w0.076: v1(119.24,63.17) 118.7,63.71 117.11,63.71 116.97,63.85 115.8,63.85 115.02,63.06 115.02,62.33 113.77,61.09 113.12,61.09 111.87,59.83 108.08,59.83 106.68,58.43
  IN3 w0.109: 106.68,58.43 105.06,56.81 104.86,56.81 104.7,56.65
  IN3 w0.117: v1(64.56,49.24) 64.85,49.53 67.32,49.53 68.1,48.74 72.22,48.74 72.52,48.44 77.87,48.44 78.3,48.87 85.46,48.87 85.97,49.38 85.97,49.54 85.73,49.78 85.73,49.94 85.9,50.11 86.06,50.11 86.3,49.87 86.46,49.87 86.63,50.04 86.63,50.21 86.4,50.44 86.4,50.6 86.56,50.77 86.73,50.77 86.96,50.54 87.12,50.54 87.29,50.7 87.29,50.87 87.06,51.1 87.06,51.27 87.22,51.43 87.39,51.43 87.62,51.2 87.79,51.2 87.95,51.36 87.95,51.53 87.72,51.76 87.72,51.93 87.88,52.09 88.05,52.09 88.28,51.86 88.45,51.86 88.61,52.02 88.61,52.19 88.38,52.42 88.38,52.59 88.55,52.75 88.71,52.75 88.94,52.52 89.11,52.52 89.27,52.69 89.27,52.85 89.04,53.08 89.04,53.25 89.21,53.41 89.37,53.41 89.61,53.18 89.77,53.18 89.94,53.35 89.94,53.51 89.7,53.75 89.7,53.91 89.87,54.08 90.03,54.08 90.27,53.84 90.43,53.84 90.6,54.01 90.6,54.17 90.36,54.41 90.36,54.57 90.53,54.74 90.69,54.74 90.93,54.5 91.09,54.5 91.49,54.9 98.15,54.9 99.9,56.65 104.7,56.65
  BOTTOM w0.076: v1(119.24,63.17) UC1.AN22
  BOTTOM w0.112: v1(64.56,49.24) 64.81,48.99 JDIMM2.237
DDR_B_D61: length 71.7
  IN3 w0.076: v1(118.61,63.17) 118.23,63.55 117.04,63.55 116.9,63.68 115.87,63.68 115.18,62.99 115.18,62.26 113.84,60.92 113.19,60.92 111.93,59.67 109.48,59.67 108.14,58.33 108.02,58.33 107.64,57.95
  IN3 w0.109: 106.01,56.32 107.64,57.95
  IN3 w0.117: 106.01,56.32 100.04,56.32 98.29,54.57 91.63,54.57 85.6,48.54 78.43,48.54 77.94,48.05 77.33,48.05 77.21,47.93 77.21,47.68 77.09,47.56 76.86,47.56 76.74,47.68 76.74,47.93 76.63,48.05 72.45,48.05 72.09,48.41 71.84,48.41 71.73,48.29 71.73,48.02 71.61,47.91 71.38,47.91 71.26,48.02 71.26,48.29 71.14,48.41 70.91,48.41 70.79,48.29 70.79,48.02 70.67,47.91 70.44,47.91 70.32,48.02 70.32,48.29 70.21,48.41 67.96,48.41 67.55,48.82 67.3,48.82 67.19,48.71 67.19,48.02 67.07,47.91 66.84,47.91 66.72,48.02 66.72,48.71 66.6,48.82 66.2,48.82 66.08,48.94 66.08,49.08 65.97,49.19 65.73,49.19 65.62,49.08 65.62,48.94 65.5,48.82 63.45,48.82 v1(63.04,49.24)
  BOTTOM w0.076: v1(118.61,63.17) UC1.AP22
  BOTTOM w0.112: v1(63.04,49.24) 63.63,49.83 65.03,49.83 65.19,49.99 JDIMM2.233
DDR_B_D62: length 70.1
  IN3 w0.076: 105.42,53.36 105.78,53.36 107.82,55.41 108.57,55.41 109.42,56.26 109.42,57.06 110.25,57.88 111.79,57.88 113.13,59.22 114.06,59.22 116.35,61.51 116.74,61.51 117.11,61.88 118.24,61.88 v1(118.61,62.25)
  IN3 w0.117: v1(61.52,46.19) 61.52,45.54 61.63,45.42 64.93,45.42 65.13,45.22 67.24,45.22 67.5,44.96 70.55,44.96 71.07,44.44 78.03,44.44 78.24,44.65 81.24,44.65 82.48,45.89 86.69,45.89 90.76,49.96 96.12,49.96 97.11,50.96 98.8,50.96 100.44,52.59 104.65,52.59 105.42,53.36
  BOTTOM w0.076: UC1.AP21 v1(118.61,62.25)
  BOTTOM w0.112: JDIMM2.250 61.06,45.74 v1(61.52,46.19)
DDR_B_D63: length 71.6
  IN3 w0.076: v1(119.24,62.25) 118.71,61.72 117.18,61.72 116.78,61.32 116.39,61.32 114.13,59.06 113.19,59.06 111.86,57.72 110.42,57.72 109.59,56.88 109.59,56.19 108.62,55.22 107.88,55.22 105.86,53.19
  IN3 w0.117: v1(59.99,46.19) 60.51,45.68 60.91,45.68 61.49,45.09 64.8,45.09 64.99,44.89 67.1,44.89 67.38,44.61 70.25,44.61 70.75,44.11 78.17,44.11 78.38,44.32 81.37,44.32 82.62,45.56 82.97,45.56 83.09,45.44 83.09,45.03 83.21,44.92 83.44,44.92 83.56,45.03 83.56,45.44 83.68,45.56 86.82,45.56 90.89,49.63 96.26,49.63 97.16,50.53 98.85,50.53 99.76,51.44 103.49,51.44 104.3,52.25 104.92,52.25 105.86,53.19
  BOTTOM w0.076: UC1.AN21 v1(119.24,62.25)
  BOTTOM w0.112: v1(59.99,46.19) 59.44,46.74 JDIMM2.246
DDR_B_DQS0: length 74.5
  IN3 w0.076: 113.63,95.51 113.65,95.51 113.69,95.56 114.8,95.56 117.03,93.32 117.03,92.09 117.41,91.71 118.24,91.71 118.5,91.45 118.5,90.75 121.17,88.08 121.17,86.8 121.34,86.64 121.64,86.64 121.71,86.56 v1(121.71,86.4)
  IN3 w0.124: 113.63,95.51 110.34,95.51 106.23,99.63 93.8,99.63 93.4,100.03 84.29,100.03 81.85,102.47 71.69,102.47 71.45,102.23 70.43,102.23 70.23,102.44 65.3,102.44 65.01,102.73 61.96,102.73 61.83,102.6 61.83,102.19 v1(61.95,102.07)
  BOTTOM w0.076: UC1.AH65 v1(121.71,86.4)
  BOTTOM w0.109: JDIMM2.34 59.11,101.74 59.26,101.89 59.57,101.89 60.05,101.41 61.3,101.41 61.3,101.41 61.35,101.41 61.59,101.65 61.59,101.96 61.7,102.07 v1(61.95,102.07)
DDR_B_DQS1: length 83.2
  IN3 w0.076: 123.11,96.62 123.14,96.58 123.14,96.41 123.11,96.37 123.11,95.97 122.84,95.7 122.84,94.17 122.62,93.95 122.35,93.95 122.2,93.8 v1(122.2,93.71)
  IN3 w0.114: 63.25,107.21 v1(63.42,107.38) ; 64.55,106.84 63.23,106.84 63.14,106.93 63.14,106.98
  IN3 w0.124: 63.25,107.21 63.24,107.21 63.14,107.1 63.14,106.98 ; 64.55,106.84 65.73,108.02 66.16,108.02 66.41,107.77 66.41,107.57 66.53,107.45 66.91,107.45 67.04,107.57 67.04,107.77 67.29,108.02 71.47,108.02 71.65,107.84 72.67,107.84 72.97,107.54 73.69,107.54 74.03,107.88 77.55,107.88 77.9,107.53 78.5,107.53 78.86,107.89 79.68,107.89 80.1,108.31 82.5,108.31 85.61,105.21 93.36,105.21 93.37,105.21 99.37,105.21 99.78,104.81 100.36,104.81 100.75,105.2 115.79,105.2 119.8,101.2 120.8,101.2 123.34,98.66 123.34,98.01 123.11,97.78 123.11,96.62
  BOTTOM w0.076: UC1.AG70 122.77,89.61 122.77,89.42 122.69,89.35 122.59,89.35 122.52,89.41 122.46,89.54 122.46,89.75 122.5,89.83 122.5,90.11 122.44,90.24 122.44,90.37 122.5,90.48 122.5,90.79 122.5,92.14 121.78,92.85 121.78,93.88 121.88,93.99 122.11,93.99 122.2,93.9 v1(122.2,93.71)
  BOTTOM w0.109: JDIMM2.13 65.7,106.99 65.52,107.17 65.14,107.17 64.27,108.03 63.31,108.03 63.13,107.86 63.13,107.68 v1(63.42,107.38)
DDR_B_DQS2: length 66.2
  IN3 w0.076: v1(117.97,86.94) 118.14,87.12 118.14,87.42 118.06,87.5 117.85,87.5 117.68,87.34 115.89,87.34 115.02,88.21 115.02,88.64 114.32,89.34 114.01,89.34 113.04,90.31 111.37,90.31 111.17,90.31 110.88,90.6 107.52,90.6 106.13,91.99 106.09,91.99 105.89,92.19 105.89,92.24
  IN3 w0.124: 105.89,92.24 105.89,92.48 104.41,93.95 94.33,93.95 91.88,96.4 81.72,96.4 80.88,97.24 71.91,97.24 71.48,96.8 65.19,96.8 64.66,97.33 63.24,97.33 63.08,97.17 63.08,96.91 63.24,96.75 v1(63.45,96.75)
  BOTTOM w0.076: UC1.AR65 118.33,86.58 v1(117.97,86.94)
  BOTTOM w0.109: JDIMM2.55 65.66,96.49 65.51,96.63 64.95,96.63 64.27,97.32 63.31,97.32 63.2,97.21 63.2,96.99 v1(63.45,96.75)
DDR_B_DQS3: length 66.2
  IN3 w0.076: 104.51,87.78 105.42,86.87 112.02,86.87 113.28,85.61 114.07,85.61 115.36,84.33 116.15,84.33 116.35,84.54 117.63,84.54 117.65,84.52 117.65,84.52 v1(117.97,84.2)
  IN3 w0.124: 104.51,87.78 104.45,87.84 93.79,87.84 90.38,91.24 82.18,91.24 81.22,92.2 80.21,92.2 79.75,91.74 72.41,91.74 71.58,90.91 65.79,90.91 65.23,90.35 61.69,90.35 61.38,90.66 61.38,91.02 v1(61.11,91.28)
  BOTTOM w0.076: v1(117.97,84.2) 118.33,83.84 UC1.AR60
  BOTTOM w0.109: JDIMM2.76 59.02,91.24 59.21,91.43 59.54,91.43 59.86,91.75 61.23,91.75 61.37,91.6 61.37,91.39 61.27,91.28 v1(61.11,91.28)
DDR_B_DQS4: length 66.7
  IN3 w0.076: 102.23,66.48 102.36,66.48 104.49,68.61 111.11,68.61 112.49,69.98 112.85,69.98 114.64,71.77 117.68,71.77 117.85,71.94 117.85,72.13 v1(118.03,72.31)
  IN3 w0.124: 102.23,66.48 94.18,66.48 92.88,65.18 89.29,65.18 88.73,64.62 81.92,64.62 81.48,64.18 71.95,64.18 71.57,63.8 66.06,63.8 65.81,63.55 65.21,63.55 65.06,63.4 65.06,62.47 64.76,62.18 63.09,62.18 62.81,62.45 62.81,63.52 62.77,63.56 v1(62.66,63.68)
  BOTTOM w0.076: v1(118.03,72.31) 118.34,71.93 UC1.AR38
  BOTTOM w0.102: 62.68,63.65 v1(62.66,63.68)
  BOTTOM w0.109: 62.68,63.65 62.82,63.51 62.82,63.09 63.05,62.86 64.28,62.86 64.32,62.9 64.32,62.9 64.91,63.49 JDIMM2.179
DDR_B_DQS5: length 68.2
  IN3 w0.076: 103.05,62.8 103.07,62.8 104.48,64.21 104.48,64.61 104.53,64.75 105.27,65.49 111.46,65.49 113.02,67.05 113.75,67.05 115.06,68.36 115.45,68.36 115.86,68.77 115.87,68.77 116.3,69.2 116.84,69.2 116.85,69.21 117.64,69.21 117.81,69.03 117.81,68.81 v1(117.97,68.65)
  IN3 w0.114: 61.87,58.39 v1(61.9,58.42)
  IN3 w0.124: 61.87,58.39 61.6,58.12 61.6,57.74 61.87,57.48 67.72,57.48 68.7,58.46 71.6,58.46 72.16,57.9 80.59,57.9 81.84,59.15 84.6,59.15 86.45,60.99 95.19,60.99 96.99,62.8 103.05,62.8
  BOTTOM w0.076: UC1.AR32 v1(117.97,68.65)
  BOTTOM w0.109: JDIMM2.200 58.98,58.24 59.09,58.36 59.57,58.36 60.2,57.72 61.38,57.72 61.59,57.93 61.59,58.11 v1(61.9,58.42)
DDR_B_DQS6: length 67.9
  IN3 w0.076: v1(117.97,65.91) 118.07,65.82 118.08,65.61 118.01,65.53 116.23,65.53 116.11,65.65 115.14,65.65 114.77,65.28 114.77,64.22 114.01,63.46 114.01,63.23 113.09,62.31 111.85,62.31 110.79,61.26 107.36,61.26 105.01,58.92 104.64,58.92
  IN3 w0.124: 104.64,58.92 98.52,58.92 96.79,57.18 89.72,57.18 85.13,52.59 78.07,52.59 77.28,51.8 71.89,51.8 71.64,52.05 63.19,52.05 63.06,52.18 63.06,52.63 63.19,52.75 v1(63.42,52.75)
  BOTTOM w0.076: v1(117.97,65.91) 118.33,65.55 UC1.AR27
  BOTTOM w0.109: JDIMM2.221 65.66,52.99 65.52,53.12 64.75,53.12 64.55,53.32 63.16,53.32 63.05,53.21 63.05,52.87 63.17,52.75 v1(63.42,52.75)
DDR_B_DQS7: length 69.9
  IN3 w0.076: 104.64,54.34 104.69,54.34 104.72,54.37 105.11,54.37 109.75,59.01 112.21,59.01 112.92,59.72 113.73,59.72 116.33,62.32 116.33,62.42 116.54,62.63 117.62,62.63 v1(117.97,62.28)
  IN3 w0.124: 104.64,54.34 100.62,54.34 100.58,54.31 100.47,54.31 98.35,52.19 91.24,52.19 86.17,47.13 81.44,47.13 81.14,46.82 81.14,46.29 80.7,45.86 77.76,45.86 77.54,45.64 71.81,45.64 70.94,46.5 65.54,46.5 65.29,46.75 61.65,46.75 61.4,47 61.4,47.26 v1(61.14,47.52)
  BOTTOM w0.076: UC1.AR21 117.97,62.25 v1(117.97,62.28)
  BOTTOM w0.109: JDIMM2.242 59.02,47.74 59.17,47.89 59.67,47.89 59.98,48.19 61.19,48.19 61.39,47.99 61.39,47.78 v1(61.14,47.52)
DDR_B_DQS#0: length 74.4
  IN3 w0.076: v1(121.71,87.04) 121.71,86.87 121.64,86.79 121.4,86.79 121.34,86.85 121.34,88.15 118.66,90.82 118.66,91.52 118.31,91.87 117.48,91.87 117.2,92.16 117.2,93.39 114.87,95.72 113.65,95.72 113.64,95.73 113.63,95.73
  IN3 w0.124: v1(61.19,102.07) 61.62,102.5 61.62,102.69 61.87,102.94 65.1,102.94 65.39,102.65 70.32,102.65 70.52,102.44 71.36,102.44 71.6,102.69 81.94,102.69 84.37,100.25 93.49,100.25 93.89,99.85 106.31,99.85 110.43,95.73 113.63,95.73
  BOTTOM w0.076: UC1.AH66 v1(121.71,87.04)
  BOTTOM w0.109: JDIMM2.32 59.08,102.24 59.23,102.09 59.65,102.09 60.13,101.61 61.21,101.61 61.36,101.75 61.36,101.91 v1(61.19,102.07)
DDR_B_DQS#1: length 83.3
  IN3 w0.076: v1(122.2,94.36) 122.44,94.12 122.55,94.12 122.67,94.24 122.67,95.77 122.94,96.04 122.94,96.48 122.93,96.49
  IN3 w0.114: 64.7,106.69 64.68,106.67 64.68,106.67 64.64,106.64 63.14,106.64 62.93,106.85 62.93,106.89 62.93,106.89 62.93,106.95 62.92,106.96 62.92,106.98 ; 62.88,107.16 v1(62.66,107.38)
  IN3 w0.124: 64.7,106.69 65.82,107.81 66.07,107.81 66.19,107.68 66.19,107.48 66.44,107.23 67,107.23 67.25,107.48 67.25,107.68 67.38,107.81 71.39,107.81 71.56,107.63 72.58,107.63 72.88,107.33 73.78,107.33 74.12,107.67 77.46,107.67 77.81,107.32 78.59,107.32 78.95,107.68 79.76,107.68 80.19,108.1 82.42,108.1 85.52,105 94.17,105 94.18,105 99.29,105 99.69,104.6 100.45,104.6 100.84,104.99 115.71,104.99 119.71,100.98 120.71,100.98 123.12,98.57 123.12,98.1 122.89,97.87 122.89,96.53 122.93,96.49 ; 62.88,107.16 62.92,107.12 62.92,106.98
  BOTTOM w0.076: UC1.AG69 122.63,89.07 122.39,89.31 122.3,89.5 122.3,89.79 122.33,89.87 122.33,90.08 122.28,90.21 122.28,90.4 122.33,90.52 122.33,90.86 122.33,91.05 122.33,92.07 121.62,92.78 121.62,93.95 121.82,94.15 121.99,94.15 v1(122.2,94.36)
  BOTTOM w0.109: v1(62.66,107.38) 62.93,107.65 62.93,107.94 63.22,108.23 64.35,108.23 65.22,107.37 65.6,107.37 65.6,107.37 65.63,107.37 65.74,107.49 JDIMM2.11
DDR_B_DQS#2: length 66.2
  IN3 w0.076: v1(117.97,87.86) 117.62,87.5 115.96,87.5 115.19,88.27 115.19,88.71 114.39,89.51 114.08,89.51 113.11,90.47 111.3,90.47 111.23,90.47 110.95,90.76 107.59,90.76 106.2,92.15 106.16,92.15 106.1,92.21 106.1,92.24
  IN3 w0.124: 106.1,92.24 106.1,92.57 104.5,94.17 94.42,94.17 91.97,96.61 81.81,96.61 80.97,97.45 71.82,97.45 71.39,97.02 65.28,97.02 64.75,97.54 63.15,97.54 62.86,97.26 62.86,96.93 v1(62.68,96.75)
  BOTTOM w0.076: v1(117.97,87.86) 118.33,87.49 UC1.AR66
  BOTTOM w0.109: v1(62.68,96.75) 62.83,96.75 63.01,96.93 63.01,97.29 63.23,97.51 64.35,97.51 65.03,96.83 65.5,96.83 65.66,96.99 JDIMM2.53
DDR_B_DQS#3: length 66.3
  IN3 w0.076: 104.66,87.93 104.67,87.92 104.67,87.89 104.7,87.86 104.7,87.82 105.49,87.04 112.09,87.04 113.35,85.78 114.14,85.78 115.42,84.5 116.08,84.5 116.28,84.7 117.56,84.7 v1(117.97,85.11)
  IN3 w0.124: v1(61.87,91.28) 61.59,91 61.59,90.75 61.78,90.56 65.14,90.56 65.71,91.13 71.49,91.13 72.32,91.95 79.66,91.95 80.12,92.41 81.31,92.41 82.27,91.46 90.47,91.46 93.88,88.05 104.54,88.05 104.66,87.93
  BOTTOM w0.076: v1(117.97,85.11) 118.33,84.75 UC1.AR61
  BOTTOM w0.109: JDIMM2.74 59.05,91.74 59.17,91.63 59.46,91.63 59.77,91.94 61.36,91.94 61.61,91.7 61.61,91.39 61.72,91.28 v1(61.87,91.28)
DDR_B_DQS#4: length 66.7
  IN3 w0.076: 102.23,66.69 102.23,66.69 102.26,66.67 102.32,66.67 104.42,68.77 111.05,68.77 112.42,70.15 112.78,70.15 114.57,71.94 117.61,71.94 117.69,72.01 117.69,72.24 117.61,72.31 v1(117.34,72.31)
  IN3 w0.124: v1(63.42,63.68) 63.27,63.68 63.03,63.43 63.03,62.54 63.18,62.39 64.68,62.39 64.84,62.56 64.84,63.49 65.12,63.76 65.72,63.76 65.98,64.02 71.48,64.02 71.86,64.4 81.39,64.4 81.83,64.84 88.64,64.84 89.2,65.4 92.8,65.4 94.09,66.69 102.13,66.69 102.15,66.71 102.16,66.71 102.18,66.69 102.23,66.69
  BOTTOM w0.076: UC1.AT38 117.72,72.13 117.59,72.28 v1(117.34,72.31)
  BOTTOM w0.109: v1(63.42,63.68) 63.15,63.68 63.02,63.55 63.02,63.17 63.13,63.06 64.2,63.06 64.83,63.69 65.36,63.69 65.67,63.99 JDIMM2.177
DDR_B_DQS#5: length 68.1
  IN3 w0.076: 103.05,62.58 103.14,62.58 103.27,62.71 103.27,62.73 103.28,62.74 103.28,62.78 104.65,64.15 104.65,64.58 104.68,64.66 105.34,65.32 111.53,65.32 113.09,66.89 113.82,66.89 115.13,68.2 115.53,68.2 116.37,69.04 116.91,69.04 116.92,69.05 117.57,69.05 117.65,68.97 117.65,68.81 117.5,68.65 v1(117.34,68.65)
  IN3 w0.114: 61.16,58.39 v1(61.14,58.42)
  IN3 w0.124: 61.16,58.39 61.39,58.16 61.39,57.65 61.78,57.27 67.8,57.27 68.79,58.25 71.51,58.25 72.07,57.69 80.68,57.69 81.92,58.94 84.69,58.94 86.54,60.78 95.27,60.78 97.08,62.58 103.05,62.58
  BOTTOM w0.076: UC1.AT32 v1(117.34,68.65)
  BOTTOM w0.109: v1(61.14,58.42) 61.4,58.16 61.4,58.01 61.3,57.92 60.29,57.92 59.65,58.56 59.14,58.56 58.96,58.74 JDIMM2.198
DDR_B_DQS#6: length 67.9
  IN3 w0.076: 104.64,58.7 104.65,58.7 104.67,58.73 104.72,58.73 104.74,58.75 105.08,58.75 107.42,61.09 110.86,61.09 111.91,62.14 113.16,62.14 114.17,63.16 114.17,63.39 114.94,64.15 114.94,65.21 115.21,65.48 116.04,65.48 116.16,65.36 117.64,65.36 v1(118.02,65.02)
  IN3 w0.124: 104.64,58.7 98.61,58.7 96.88,56.97 89.81,56.97 85.22,52.38 78.16,52.38 77.37,51.59 71.8,51.59 71.55,51.84 63.1,51.84 62.85,52.09 62.85,52.56 v1(62.66,52.75)
  BOTTOM w0.076: UC1.AR25 118.33,64.71 v1(118.02,65.02)
  BOTTOM w0.109: JDIMM2.219 65.72,53.49 65.55,53.32 64.83,53.32 64.63,53.52 63.08,53.52 62.86,53.3 62.86,52.95 v1(62.66,52.75)
DDR_B_DQS#7: length 70
  IN3 w0.076: v1(117.97,63.19) 117.97,63.19 117.57,62.8 116.47,62.8 116.17,62.49 116.17,62.39 113.66,59.88 112.85,59.88 112.14,59.17 109.68,59.17 105.04,54.53 104.67,54.53 104.65,54.56 104.64,54.56
  IN3 w0.124: v1(61.9,47.52) 61.61,47.24 61.61,47.08 61.74,46.96 65.38,46.96 65.63,46.72 71.03,46.72 71.89,45.85 77.45,45.85 77.67,46.07 80.61,46.07 80.92,46.38 80.92,46.91 81.35,47.34 86.09,47.34 91.15,52.4 98.26,52.4 100.38,54.52 100.49,54.52 100.53,54.56 104.64,54.56
  BOTTOM w0.076: v1(117.97,63.19) 117.97,63.17 UC1.AR22
  BOTTOM w0.109: JDIMM2.240 59.04,48.24 59.2,48.09 59.59,48.09 59.93,48.43 61.29,48.43 61.62,48.09 61.62,47.8 v1(61.9,47.52)
DDR_B_MA0: length 69.2
  IN3 w0.076: v1(110.57,75.83) 110.57,75.94 110.5,76.02 105.54,76.02 104.75,75.23
  IN3 w0.175: 103.37,74.65 103.95,75.23 104.75,75.23 ; 62.56,74.18 62.38,74.36 62,74.36 61.76,74.13 61.49,74.13 61.28,74.33 60.41,74.33
  IN3 w0.183: 103.37,74.65 103.31,74.59 87.61,74.59 87.23,74.98 86.65,74.98 86.54,75.08 86.54,75.39 86.35,75.58 85.91,75.58 85.74,75.4 85.74,75.16 85.56,74.98 80.97,74.98 80.79,75.16 80.79,75.28 80.61,75.46 80.24,75.46 80.06,75.28 80.06,75.16 79.87,74.98 78.46,74.98 78.27,74.8 78.27,74.48 78.09,74.3 77.72,74.3 77.54,74.48 77.54,75.04 77.36,75.22 72.34,75.22 70.97,73.85 68.41,73.85 68.23,74.04 68.23,74.11 68.04,74.29 67.68,74.29 67.49,74.11 67.49,74.04 67.31,73.85 66.7,73.85 66.55,73.71 66.11,73.26 65.59,73.26 65.22,73.64 64.92,73.64 64.61,73.33 63.96,73.33 63.81,73.48 63.38,73.48 63.23,73.33 62.74,73.33 62.56,73.51 62.56,74.18 ; v1(60.81,73.71) 60.64,73.71 60.22,73.29 59.81,73.29 59.62,73.47 59.62,74.15 59.81,74.33 60.41,74.33
  BOTTOM w0.076: UC1.BA46 114.57,75.58 114.49,75.5 112.79,75.5 112.7,75.6 111.22,75.6 111.15,75.68 v2(111.15,75.81) 111.15,76.01 111.07,76.09 110.65,76.09 110.57,76.01 v1(110.57,75.83)
  BOTTOM w0.183: v1(60.81,73.71) 61.1,73.42 61.1,72.94 60.93,72.77 59.47,72.77 59.32,72.92 59.32,74.07 59.15,74.24 JDIMM2.144
DDR_B_MA1: length 69.8
  IN3 w0.175: v1(106.56,78.03) 106.56,77.72 106.39,77.54 103.8,77.54
  IN3 w0.183: 103.8,77.54 103.37,77.97 89.01,77.97 87.97,79.01 87.16,79.01 86.98,79.19 86.98,80.06 86.79,80.24 86.43,80.24 86.24,80.06 86.24,79.19 86.06,79.01 85.7,79.01 85.51,79.19 85.51,80.06 85.33,80.24 84.96,80.24 84.78,80.06 84.78,79.19 84.6,79.01 84.23,79.01 84.05,79.19 84.05,80.06 83.87,80.24 83.5,80.24 83.32,80.06 83.32,79.19 83.14,79.01 82.77,79.01 82.59,79.19 82.59,80.06 82.4,80.24 82.04,80.24 81.86,80.06 81.86,79.19 81.67,79.01 81.36,79.01 80.95,79.43 80.95,80.06 80.76,80.24 80.01,80.24 79.83,80.06 79.83,79.55 79.65,79.36 71.61,79.36 69.85,77.61 67.45,77.61 67.01,77.16 66.53,77.16 66.35,76.97 66.35,76.87 66.17,76.68 65.8,76.68 65.62,76.87 65.62,76.97 65.43,77.16 64.02,77.16 63.84,76.97 v1(63.84,76.69)
  BOTTOM w0.076: UC1.AY46 114.96,75.87 114.86,75.97 114.65,76.05 114.51,76.05 114.28,75.98 114.14,75.98 114.03,76.04 113.76,76.04 113.56,75.83 112.93,75.83 112.83,75.93 111.74,75.93 111.2,76.48 106.19,76.48 106.12,76.55 106.12,77.58 v1(106.56,78.03)
  BOTTOM w0.183: JDIMM2.133 66.45,76.99 65.45,76.99 65.06,77.38 64.01,77.38 63.84,77.21 v1(63.84,76.69)
DDR_B_MA2: length 68.7
  IN3 w0.175: 103.83,78.43 107.38,78.43 v1(107.78,78.03) ; 62.16,78.08 65.26,78.08
  IN3 w0.183: v1(60.79,76.69) 60.79,77.06 60.66,77.19 59.62,77.19 58.73,78.07 58.73,79.37 58.92,79.55 60.16,79.55 60.35,79.37 60.35,78.26 60.53,78.08 62.16,78.08 ; 103.83,78.43 103.37,78.9 89.71,78.9 87.45,81.16 79.38,81.16 78.95,80.73 71.67,80.73 69.98,79.04 68.57,79.04 68.55,79.02 66.75,79.02 65.81,78.08 65.26,78.08
  BOTTOM w0.076: UC1.AY47 115.24,76.16 114.81,76.16 114.65,76.22 114.51,76.22 114.29,76.16 114.17,76.16 114.09,76.19 114.06,76.2 113.69,76.2 113.49,76 113,76 112.9,76.1 111.81,76.1 111.18,76.72 109.09,76.72 v1(107.78,78.03)
  BOTTOM w0.183: JDIMM2.132 59.23,77.24 59.28,77.19 60.3,77.19 v1(60.79,76.69)
DDR_B_MA3: length 67.2
  IN3 w0.175: 64.13,77.62 65.06,77.62 ; 103.37,78.43 103.99,77.81 105.73,77.81 v1(105.95,78.03)
  IN3 w0.183: 64.13,77.62 63.83,77.62 63.32,77.11 63.04,77.11 62.54,77.62 62.28,77.62 61.97,77.3 61.97,77.04 v1(62.31,76.69) ; 103.37,78.43 89.2,78.43 88.17,79.47 87.68,79.47 87.44,79.71 87.44,80.52 87.26,80.7 79.57,80.7 79.37,80.49 79.37,79.99 79.2,79.83 78.81,79.83 78.43,80.21 78.06,80.21 77.68,79.83 77.31,79.83 76.86,80.27 76.37,80.27 76.09,79.99 75.5,79.99 75.22,80.27 71.86,80.27 70.18,78.58 68.76,78.58 68.74,78.56 66.94,78.56 66.76,78.38 66.76,77.8 66.58,77.62 65.06,77.62
  BOTTOM w0.076: v1(105.95,78.03) 105.04,78.03 104.96,77.95 104.96,76.33 105.04,76.25 111.19,76.25 111.68,75.77 112.76,75.77 112.86,75.67 113.82,75.67 UC1.BB46
  BOTTOM w0.183: JDIMM2.131 65.51,77.49 65.1,77.9 62.48,77.9 62.31,77.73 v1(62.31,76.69)
DDR_B_MA4: length 67.9
  IN3 w0.175: 103.37,79.82 104.23,78.96 108.65,78.96 108.82,78.79 108.82,78.28 v1(108.57,78.03) ; 61.45,79.48 62.11,79.48 62.29,79.31 62.29,79.11 62.46,78.93 62.81,78.93 62.99,79.11 62.99,79.31 63.16,79.48 64.55,79.48
  IN3 w0.183: 64.55,79.48 64.92,79.48 65.28,79.12 65.54,79.12 66.11,79.68 66.11,80.39 66.48,80.75 68.53,80.75 69.1,81.32 69.85,81.32 70.27,80.9 70.53,80.9 71.29,81.66 72.16,81.66 72.6,82.09 77.47,82.09 77.9,81.66 78.57,81.66 79,82.09 80.56,82.09 80.56,82.09 87.83,82.09 88.58,81.34 88.84,81.34 89.29,81.79 89.55,81.79 90.78,80.57 94.33,80.57 94.51,80.39 94.51,80 94.7,79.82 95.11,79.82 95.29,80 95.29,80.37 95.47,80.56 95.84,80.56 96.02,80.37 96.02,80 96.2,79.82 103.37,79.82 ; v1(61.57,78.54) 61.2,78.91 61.2,79.24 61.45,79.48
  BOTTOM w0.076: v1(108.57,78.03) 108.57,77.64 v2(108.84,77.37) 109.33,76.89 111.25,76.89 111.88,76.26 112.38,76.26 112.87,76.75 113.45,76.75 113.53,76.66 114.05,76.66 114.05,76.66 114.14,76.7 114.34,76.7 114.43,76.66 114.43,76.66 114.44,76.66 114.45,76.66 114.82,76.66 114.89,76.58 UC1.BA47
  BOTTOM w0.183: JDIMM2.128 59.1,78.24 59.83,77.51 61.4,77.51 61.57,77.68 v1(61.57,78.54)
DDR_B_MA5: length 68.6
  IN3 w0.175: v1(111.01,78.03) 111.27,78.29 112.81,78.29 112.98,78.47 112.98,78.78 112.81,78.95 110.17,78.95 109.63,79.49 105.72,79.49 105.54,79.67
  IN3 w0.183: v1(62.33,79.98) 62.09,80.22 62.09,80.6 62.39,80.9 62.83,80.9 63.19,80.54 63.56,80.54 63.92,80.9 65.32,80.9 67.26,82.84 70.61,82.84 70.78,83.01 77.83,83.01 78.38,83.57 81,83.57 81.56,83.01 89.64,83.01 91.16,81.49 101.19,81.49 101.37,81.31 101.37,80.93 101.55,80.74 102.01,80.74 102.19,80.93 102.19,81.31 102.37,81.49 102.74,81.49 102.92,81.31 102.92,80.93 103.1,80.74 104.94,80.74 105.54,80.14 105.54,79.67
  BOTTOM w0.076: v1(111.01,78.03) 111.01,77.81 111.34,77.47 v2(111.54,77.47) 111.65,77.36 114.95,77.36 UC1.AY48
  BOTTOM w0.183: JDIMM2.126 59.27,78.74 59.76,79.23 61.81,79.23 62.33,79.75 v1(62.33,79.98)
DDR_B_MA6: length 67.5
  IN3 w0.076: 108.18,78.4 108.18,77.83 108.35,77.66 109.71,77.66 109.79,77.73 v1(109.79,78.03)
  IN3 w0.175: 103.37,79.36 104.03,78.7 107.87,78.7 108.18,78.4
  IN3 w0.183: v1(63.86,78.54) 63.86,78.84 64.04,79.02 64.73,79.02 65.19,78.56 65.64,78.56 66.57,79.49 66.57,80.1 66.75,80.28 67.34,80.28 67.52,80.1 67.52,79.71 67.75,79.48 68.42,79.48 68.61,79.67 68.61,80.18 68.86,80.43 69.7,80.43 70.08,80.05 70.34,80.05 71.48,81.19 78.76,81.19 79.19,81.63 87.64,81.63 88.58,80.68 88.84,80.68 89.29,81.14 89.55,81.14 89.81,80.88 89.81,80.62 89.36,80.17 89.36,79.91 89.91,79.36 90.22,79.36 90.4,79.54 90.4,79.92 90.58,80.11 90.95,80.11 91.13,79.92 91.13,79.54 91.31,79.36 91.68,79.36 91.86,79.54 91.86,79.92 92.04,80.11 92.41,80.11 92.59,79.92 92.59,79.54 92.78,79.36 93.14,79.36 93.32,79.54 93.32,79.92 93.51,80.11 93.87,80.11 94.06,79.92 94.06,79.54 94.24,79.36 103.37,79.36
  BOTTOM w0.076: v1(109.79,78.03) 109.66,78.03 109.37,77.74 109.37,77.51 109.72,77.16 111.2,77.16 111.41,76.95 113.48,76.95 113.6,76.83 114.02,76.83 114.11,76.86 114.13,76.86 114.37,76.86 114.46,76.83 114.67,76.83 114.75,76.86 114.75,76.86 114.85,76.9 114.9,76.99 114.87,77.1 UC1.BA48
  BOTTOM w0.183: v1(63.86,78.54) 63.7,78.69 63.7,79.08 63.87,79.25 64.86,79.25 65.62,78.49 JDIMM2.127
DDR_B_MA7: length 70.6
  IN3 w0.076: v1(118.61,77.83) 118.61,78.12 118.53,78.2 115.5,78.2
  IN3 w0.175: 115.5,78.2 113.95,78.2 113.77,78.37 113.77,79.12 113.6,79.3 111.86,79.3 111.28,79.88 110.64,79.88 109.98,80.54 105.52,80.54 105.05,81.01 103.54,81.01 103.37,81.19 103.37,81.78 ; 62.2,81.36 64.42,81.36
  IN3 w0.183: 103.37,81.78 103.19,81.96 91.35,81.96 89.83,83.47 81.75,83.47 80.81,84.41 80.37,84.41 79.99,84.03 78.19,84.03 77.79,83.62 70.73,83.62 70.41,83.31 67.07,83.31 65.12,81.36 64.42,81.36 ; v1(60.81,79.98) 60.81,80.28 60.7,80.4 59.55,80.4 59.37,80.58 59.37,81.18 59.55,81.36 62.2,81.36
  BOTTOM w0.076: UC1.AP48 118.98,77.38 v1(118.61,77.83)
  BOTTOM w0.183: v1(60.81,79.98) 60.81,80.22 60.56,80.47 59.9,80.47 59.21,79.79 59.21,79.79 59.16,79.74 JDIMM2.122
DDR_B_MA8: length 64.8
  IN3 w0.175: v1(110.4,78.03) 110.4,78.26 109.44,79.23 105.39,79.23 105.2,79.41
  IN3 w0.183: v1(63.86,79.98) 63.86,80.1 64.04,80.28 64.68,80.28 65.02,79.95 65.47,79.95 65.64,80.12 65.64,80.58 66.81,81.74 67.15,81.74 67.33,81.56 67.33,81.4 67.51,81.22 68.34,81.22 68.94,81.82 69.27,81.82 69.84,82.38 70.18,82.38 70.64,81.92 70.9,81.92 71.53,82.55 78.47,82.55 78.65,82.73 78.65,82.92 78.84,83.1 79.2,83.1 79.39,82.92 79.39,82.73 79.57,82.55 80.13,82.55 80.56,82.98 80.93,82.98 81.37,82.55 88.02,82.55 88.49,82.08 88.75,82.08 89.2,82.54 89.46,82.54 90.97,81.03 96.37,81.03 96.55,80.85 96.55,80.47 96.74,80.28 97.07,80.28 97.26,80.47 97.26,80.85 97.44,81.03 97.8,81.03 97.99,80.85 97.99,80.47 98.17,80.28 98.54,80.28 98.72,80.47 98.72,80.85 98.9,81.03 99.27,81.03 99.45,80.85 99.45,80.47 99.63,80.28 100,80.28 100.18,80.47 100.18,80.85 100.36,81.03 100.73,81.03 100.91,80.85 100.91,80.47 101.1,80.28 105.02,80.28 105.2,80.1 105.2,79.41
  BOTTOM w0.076: UC1.BB48 113.7,77.1 113.65,77.14 111.45,77.14 111.27,77.33 110.22,77.33 110.14,77.4 v2(110.14,77.55) 110.14,77.77 v1(110.4,78.03)
  BOTTOM w0.183: v1(63.86,79.98) 63.86,79.7 64.03,79.53 64.32,79.53 64.72,79.93 65.1,79.93 65.3,79.73 65.3,79.26 65.57,78.99 66.45,78.99 JDIMM2.125
DDR_B_MA9: length 66.7
  IN3 w0.076: 115.58,79.29 116.93,79.29 117.14,79.08 118.25,79.08 v1(118.61,78.73)
  IN3 w0.175: 115.58,79.29 114.66,79.29 114.12,79.82 112.53,79.82 111.28,81.07 105.76,81.07 105.28,81.55 104.08,81.55 103.91,81.72 103.91,82.35 103.37,82.88
  IN3 w0.183: 103.37,82.88 91.73,82.88 90.21,84.4 85.98,84.4 84.64,85.75 80.4,85.75 79.77,85.12 70.09,85.12 69.74,84.77 67.22,84.77 65.26,82.81 63.34,82.81 v1(62.33,81.81)
  BOTTOM w0.076: v1(118.61,78.73) 118.61,78.71 UC1.AP50
  BOTTOM w0.183: JDIMM2.121 66.45,79.99 65.45,79.99 64.95,80.48 63.65,80.48 v1(62.33,81.81)
DDR_B_MA10: length 68.4
  IN3 w0.076: 104.64,74.96 104.79,74.96 105.65,75.82 107.45,75.82 v1(107.8,75.46)
  IN3 w0.175: 103.37,74.08 103.69,74.08 104.57,74.96 104.64,74.96
  IN3 w0.183: 103.37,74.08 87.47,74.08 87.03,74.52 79.94,74.52 79.75,74.33 79.75,74.02 79.57,73.84 77.53,73.84 77.1,74.26 72.14,74.26 71.27,73.39 66.89,73.39 66.74,73.25 66.3,72.8 65.09,72.8 64.85,73.04 60.63,73.04 60.39,72.8 59.34,72.8 59.15,72.99 59.15,73.22 58.97,73.4 58.34,73.4 58.16,73.22 58.16,71.92 58.34,71.74 60.56,71.74 60.74,71.92 v1(60.74,72.34)
  BOTTOM w0.076: v1(107.8,75.46) 108.22,75.88 v2(108.75,75.88) 109.93,75.88 110.37,75.44 112.63,75.44 112.73,75.34 114.56,75.34 114.8,75.58 115.29,75.58 115.49,75.68 115.68,75.87 UC1.AW46
  BOTTOM w0.183: v1(60.74,72.34) 60.15,71.74 JDIMM2.146
DDR_B_MA11: length 71.7
  IN3 w0.076: 114.9,79.61 116.84,79.61 117.2,79.24 119.28,79.24 119.6,78.93 119.6,78.15 v1(119.24,77.8)
  IN3 w0.175: 114.9,79.61 114.79,79.61 114.31,80.09 112.64,80.09 110.74,81.99 104.72,81.99 ; 65,83.2 63.07,83.2 62.84,82.97
  IN3 w0.183: 65,83.2 67.49,85.69 71.52,85.69 71.63,85.59 79.58,85.59 80.2,86.21 84.83,86.21 86.18,84.86 90.41,84.86 91.92,83.34 103.37,83.34 104.72,81.99 ; 62.84,82.97 62.45,82.58 61.97,82.58 60.94,83.62 60.68,83.62 59.97,82.91 59.97,82.65 v1(60.81,81.81)
  BOTTOM w0.076: v1(119.24,77.8) UC1.AN48
  BOTTOM w0.183: v1(60.81,81.81) 60.81,81.41 60.34,80.95 59.73,80.95 59.03,80.24 JDIMM2.120
DDR_B_MA12: length 70.1
  IN3 w0.076: 115.02,78.56 115.45,78.56 115.64,78.36 119.16,78.36 119.24,78.44 v1(119.24,78.71)
  IN3 w0.175: 115.02,78.56 114.21,78.56 114.04,78.73 114.04,79.39 113.86,79.56 111.97,79.56 111.39,80.15 110.75,80.15 110.09,80.81 105.64,80.81 105.47,80.98 ; 64.03,82.21 63.86,82.04 v1(63.86,81.81)
  IN3 w0.183: 64.03,82.21 64.17,82.35 65.46,82.35 67.27,84.16 69.76,84.16 69.84,84.08 71.19,84.08 71.37,84.27 71.37,84.48 71.56,84.66 71.92,84.66 72.1,84.48 72.1,84.27 72.29,84.08 77.59,84.08 78,84.49 79.8,84.49 80.18,84.87 81,84.87 81.94,83.94 82.25,83.94 82.43,84.12 82.43,85.1 82.62,85.28 82.98,85.28 83.16,85.1 83.16,84.12 83.35,83.94 83.71,83.94 83.9,84.12 83.9,85.1 84.08,85.28 84.44,85.28 84.63,85.1 84.63,84.12 84.81,83.94 90.02,83.94 91.54,82.42 103.46,82.42 103.64,82.24 103.64,81.46 103.82,81.28 105.16,81.28 105.46,80.98 105.47,80.98
  BOTTOM w0.076: v1(119.24,78.71) UC1.AN50
  BOTTOM w0.183: v1(63.86,81.81) 63.86,81.11 64.03,80.93 65.18,80.93 65.62,80.49 JDIMM2.119
DDR_B_MA13: length 66.8
  IN3 w0.175: v1(109.5,73.85) 109.5,72.75 109.32,72.58 105.26,72.58 103.07,70.38 102.98,70.38
  IN3 w0.183: v1(62.33,69.06) 62.33,68.75 62.23,68.64 61.37,68.64 61.18,68.46 61.18,67.97 61.37,67.79 62.86,67.79 63.04,67.97 63.04,68.48 63.21,68.65 63.56,68.65 63.73,68.48 63.73,67.98 63.93,67.79 65.25,67.79 66.52,69.05 70.68,69.05 71.31,68.42 79.26,68.42 79.91,69.07 82.63,69.07 83.16,68.54 91.48,68.54 92.77,69.82 100.86,69.82 101.42,70.38 102.98,70.38
  BOTTOM w0.076: v1(109.5,73.85) 109.94,74.29 110.46,74.29 110.61,74.45 112.23,74.45 112.38,74.3 112.59,74.3 113.15,73.74 113.44,73.74 113.55,73.85 113.79,73.85 113.8,73.85 114.05,73.85 114.19,73.79 114.3,73.79 114.39,73.83 114.42,73.85 114.66,73.85 UC1.BA43
  BOTTOM w0.183: JDIMM2.158 59.02,68.74 59.73,68.02 61.29,68.02 v1(62.33,69.06)
