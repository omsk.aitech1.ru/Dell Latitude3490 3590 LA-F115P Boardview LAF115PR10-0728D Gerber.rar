# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N21721769: length 5.8
  TOP w0.089: v2(32.24,112.72) 31.48,112.72 RT82.1
  TOP w0.102: v2(32.24,112.72) 32.4,112.56 32.4,111.86 32.85,111.41 33.22,111.41 34.1,110.52 34.52,110.52 34.68,110.68 35.03,110.68 35.14,110.57 UT5.20
N21721781: length 4.8
  TOP w0.102: CT76.1 33.68,112.65 33.68,111.96 34.11,111.53 35.13,111.53 35.94,110.72 36.17,110.72 36.34,110.55 UT5.17
N21725461: length 2.9
  BOTTOM w0.102: TP85.1 14.97,121.8 15.32,121.45 16.07,121.45 16.27,121.66 UT2.32
N22121555: length 3
  TOP w0.089: v2(73.14,141.26) 72.83,140.95 72.83,140.5 72.58,140.25 72.58,140.09 RW12.2
  TOP w0.254: RW12.2 71.54,139.68 71.52,139.69 UW1.3
N22253138: length 15.7
  IN3 w0.089: v1(12.88,132.01) 12.07,132.82 4.71,132.82 v1(2.96,131.08)
  BOTTOM w0.102: R68.1 15.38,132.41 14.48,132.41 v2(14.31,132.24) 14.08,132.01 v1(12.88,132.01)
  BOTTOM w0.254: LED1.4 2.55,131.49 v1(2.96,131.08)
N22253145: length 17.2
  IN1 w0.089: v1(13.55,132.39) 13.09,132.85 5.33,132.85 v1(2.96,130.48)
  BOTTOM w0.089: v2(3.03,129.57) 2.96,129.64 v1(2.96,130.48)
  BOTTOM w0.102: R69.1 15.95,132.61 13.76,132.61 v1(13.55,132.39)
  BOTTOM w0.254: v1(2.96,130.48) 3.04,130.48 3.42,130.87 3.42,131.68 LED1.2
N22308928: length 4
  BOTTOM w0.089: RS6.2 183.99,37.59 v2(183.99,38.57)
  BOTTOM w0.102: JHDD.4 182.2,36.33 182.84,36.97 183.37,36.97 RS6.2
N22328185: length 9.1
  TOP w0.089: PR7.1 60.68,114.32 60.44,114.08 v2(59.24,114.08)
  TOP w0.254: PQ1.2 58.91,117.76 59.85,116.82 PR4.2 59.85,116.2 PQ2.1 59.53,115.31 59.93,114.92 PR7.1
N22328194: length 4.2
  TOP w0.254: PQ1.1 57.95,117.9 57.69,117.64 PL3.2 56.21,117.91 55.53,117.91 PD1.2 55.47,117.04 PR3.1
N22328218: length 4.4
  TOP w0.089: v2(173.29,31.35) 173.34,31.41 PR45.1
  TOP w0.254: PQ13.2 173.93,33.67 174.12,33.48 PR31.2 ; PR31.2 174.12,33.09 PR35.2 ; PR31.2 174.08,33.05 PR45.1
N22328219: length 5.2
  TOP w0.089: v2(175.99,34.26) 175.73,33.99 PQ13.3
  TOP w0.254: PQ13.3 174.58,34.18 174.23,34.53 172.61,34.53 172.29,34.2 PR32.2
N22328225: length 1.9
  TOP w0.254: PR40.1 169.15,29.96 PC13.2 169.93,29.86 169.97,29.9 PQ12.5
N22328232: length 5.1
  TOP w0.089: v2(174.24,30.39) 173.3,30.39 PR44.2
  TOP w0.254: PR44.2 172.81,29.9 PQ12.2 171.76,29.9 171.28,30.37 PR36.2
N22328238: length 3.5
  TOP w0.089: PC14.2 177.92,29.13 v2(177.2,28.41)
  TOP w0.254: PQ11.2 176.82,29.73 PR43.1 177.88,29.54 PC14.2
N22328240: length 3.8
  TOP w0.089: PQ13.6 173.28,36.32 v2(172.83,36.76)
  TOP w0.254: PR34.2 173.58,37.14 PR38.1 173.93,36.8 PQ13.5 PQ13.6
N22328258:
  vias: v1(72.35,142.97) v1(72.35,142.36) v1(72.96,142.97) v1(72.96,142.36) v1(73.57,142.97) v1(73.57,142.36) v1(74.18,142.97) v1(74.18,142.36) v1(74.77,142.97) v1(74.77,142.38) v2(75.5,142.22)
N22328295: length 2.6
  TOP w0.089: PD3.1 62.05,116.1 62.19,115.96 62.19,115.15 v2(62.09,115.04)
  TOP w0.254: PR7.2 61.23,115.83 PD3.1
N22328311: length 3
  BOTTOM w0.089: PQ6.1 93.3,146.72 v2(92.9,146.72)
  BOTTOM w0.254: PQ6.1 93.96,146.06 PR12.2
N22328315: length 14.2
  TOP w0.089: v1(90.88,142.76) 90.88,142.37 v2(91.27,141.98)
  TOP w0.254: v1(90.88,142.76) PR8.2 90.94,143.73 PC5.2 92.38,144.09 PQ3.4
  IN2 w0.254: v1(90.88,142.76) 90.88,143.2 93.08,145.4 93.08,149.03 v1(93.63,149.59)
  BOTTOM w0.254: PR10.1 93.63,149.25 v1(93.63,149.59)
N22328320: length 2.7
  BOTTOM w0.102: v2(93.7,150.44) 93.7,150.25 92.81,149.36 PR10.2
  BOTTOM w0.254: PR10.2 92.44,149.71 PQ5.1
N22328363: length 3.8
  TOP w0.254: PR39.1 165.63,39.9 165.38,39.64 v2(164.73,39.64) 164.7,39.64 164.3,39.24 v1(164.3,39)
  BOTTOM w0.254: v1(164.3,39) 164.85,39 165.01,39.15 PBATT1.5
N22328399: length 5.3
  TOP w0.089: PRS26.2 66.42,121.04 v2(66.42,119.88)
  TOP w0.254: PRS27.2 65.75,121.78 PRS26.2 65.3,121.75 64.98,122.07 64.21,122.07 64.02,121.88 PQS10.2
N22328441: length 2.1
  TOP w0.254: PD10.3 91.1,150.31 PR14.2 90.87,151.33 PR16.1
N22328488: length 1.3
  BOTTOM w0.254: PR48.2 90.78,148.09 PQ17.1
N22328506: length 1.9
  TOP w0.254: PRS29.1 64.09,124.26 PCS19.2 64.02,124.21 PQS10.5
N22328522: length 4.6
  TOP w0.089: PRS30.1 65.16,116.98 v2(65.21,117.03)
  TOP w0.254: PRS30.1 PCS20.2 64.25,119 63.86,119.38 63.86,119.76 PQS11.2
N22330692: length 7.8
  TOP w0.254: PQS13.1 48.79,133.47 v2(48.4,133.87) 48.4,134.11 48.87,134.58 PRS08.2 48.87,135.81 49.74,135.81 PCS09.2 PRS11.1 51.43,136.24 PQS01.4
N22330700: length 10.2
  TOP w0.102: PRS03.2 52.21,111.95 v2(52.62,111.53)
  TOP w0.254: PRS01.1 49.93,117.11 PRS05.1 50.29,117.1 50.69,116.7 50.69,116.39 50.09,115.79 50.09,114.61 ; 50.09,114.61 50.59,114.11 PCS03.1 50.88,111.95 PRS03.2 ; 50.09,114.61 PUS01.3
N22330701: length 4.1
  TOP w0.254: PUS01.1 48.98,116.29 PRS01.2 48.15,117.91 PCS04.1 48.21,118.77 PRS39.1 47.47,118.82 PRS02.2
N22330705: length 4.1
  TOP w0.254: PRS04.2 PRS06.1 PCS02.1 47.38,115.39 v2(47.51,115.26) 47.54,115.26 47.55,115.26 PUS01.2
N22330759: length 7.7
  TOP w0.254: PQS04.1 54.52,132.35 54.82,132.66 54.82,134.53 v2(55.01,134.72) 55.01,135.38 54.44,135.95 PRS11.2
N22330768: length 2.1
  TOP w0.254: PRS15.2 65.31,127.3 PQS07.1
N22330771: length 1.4
  TOP w0.254: PRS16.2 60.54,130.11 PQS05.6
N22330812: length 2.6
  TOP w0.254: PQS06.2 65.67,128.57 PRS15.1 PRS10.2
N22330841: length 10.1
  TOP w0.254: PQS05.5 59.72,129.03 v1(59.42,129.33)
  TOP w0.381: PUS03.4 55.12,125.24 v1(55.13,125.23)
  IN3 w0.254: v1(59.42,129.33) 59.93,128.82 59.93,127.15 58.59,125.81 55.71,125.81 v1(55.13,125.23)
N22330850: length 10.1
  TOP w0.089: v2(50.68,126.26) 50.68,125.93 v1(51.02,125.59)
  TOP w0.254: v1(52.71,120.43) 52.71,119.95 52.33,119.57 PDS03.1 ; v1(51.91,123.71) 51.74,123.88 PRS42.2 ; PUS03.2 51.33,125.89 v1(51.02,125.59)
  IN2 w0.254: v1(51.02,125.59) 51.53,125.08 51.53,124.09 v1(51.91,123.71) 52.7,122.92 52.7,120.44 v1(52.71,120.43)
N22330869: length 2.4
  TOP w0.254: PDS05.2 50.15,121.57 51.37,121.57 51.72,121.93 PRS33.2
N22330872: length 2.8
  TOP w0.089: PRS32.2 45.53,117.18 v2(45.53,116.87)
  TOP w0.254: PRS32.2 44.79,119.09 PDS04.2
N22330878: length 1.5
  TOP w0.254: PDS06.2 50.54,120.07 50.97,120.51 PRS23.2
N22330880: length 48.3
  TOP w0.089: PRS18.2 61.36,124.68 v2(59.72,123.04)
  TOP w0.254: PRS18.2 62.23,125.32 PRS34.2 62.27,125.36 62.98,126.07 63.7,126.07 64.16,126.53 64.16,127.03 v1(63.46,127.73) ; PRS45.2 v1(40.97,126.88) ; v1(69.77,135.11) 69.33,135.11 PQS14.1
  IN1 w0.254: v1(40.97,126.88) 41.68,126.88 42.41,126.16 42.88,126.16 43.28,126.55 46.91,126.55 49.99,129.64 50.46,129.64 51.93,131.11 58.38,131.11 59.7,129.79 61.92,129.79 63.46,128.25 v1(63.46,127.73)
  IN2 w0.254: v1(63.46,127.73) 63.46,129.61 63.95,130.11 63.95,133.29 65.78,135.12 69.76,135.12 v1(69.77,135.11)
N22330884: length 7.5
  TOP w0.203: 68.04,132.15 68.04,132.13 67.64,132.13 67.38,131.87 67.38,131.1 66.7,130.41 66.7,127.44 PRS35.1 ; 68.04,132.15 v2(68.06,132.15) ; 68.04,132.15 68.11,132.22 68.11,132.6 68.35,132.84 PQS14.2
N22330886: length 3.4
  TOP w0.089: v2(50.83,131) PRS37.2
  TOP w0.254: PQS12.1 50.65,129.74 PRS37.2
N22330887: length 5
  TOP w0.254: PRS36.2 54.11,133.99 v2(54.11,133.21) 54.11,133.03 53.79,132.71 52.46,132.71 PQS13.2 52.26,131.55 PRS37.1
N22330889: length 4.5
  TOP w0.089: v2(53.59,128) 53.02,128.57 PQS12.2
  TOP w0.254: PRS38.2 50.87,127.22 51.79,127.22 52.55,127.98 PQS12.2
N22330904: length 1.9
  TOP w0.254: PRS40.2 51.68,117.85 PDS03.2
N22330905: length 5
  TOP w0.254: PDS03.3 52.98,119.4 53.3,119.72 53.3,120.58 v2(52.99,120.88) 52.84,121.03 PRS41.2
N22369403: length 11.6
  TOP w0.254: PRS02.1 46.47,119.02 v1(46.82,119.38) ; v1(52.1,124.28) PRS43.2 53.26,124.81 54.17,124.81 54.44,124.54 PRS44.1
  BOTTOM w0.089: v1(46.82,119.38) 46.82,120.34 49.65,123.17 50.53,123.17 51.63,124.28 v1(52.1,124.28)
N22579656: length 8.9
  TOP w0.089: v1(113.23,49.91) v2(114,50.68) 114.6,51.28 115.95,51.28 116.23,51.56 116.23,53.69 RC201.1
  BOTTOM w0.076: UC1.AY3 115.2,51.19 115.08,51.07 114.83,51.07 114.7,50.95 114.31,50.95 114.16,50.8 113.75,50.8 113.23,50.27 v1(113.23,49.91)
N22579745: length 7
  BOTTOM w0.076: v2(114.13,95.74) 113.75,95.36 113.22,95.36 ; 112.85,94.99 112.85,92.8 UC1.AY71
  BOTTOM w0.089: 113.22,95.36 RC202.1
  BOTTOM w0.102: RC202.1 112.85,95.21 112.85,94.99
N22620462: length 2.8
  TOP w0.089: TP86.1 123.3,47.84 v1(123.74,48.28)
  BOTTOM w0.102: UC1.AD1 123.75,49.77 123.77,49.75 123.77,49.55 124.1,49.22
  BOTTOM w0.112: 124.1,49.22 124.1,48.71 123.74,48.35 v1(123.74,48.28)
N22620469: length 2.5
  TOP w0.089: 124.03,48.57 v1(123.72,48.88)
  TOP w0.102: TP87.1 124.03,48.57
  BOTTOM w0.076: 123.51,49.75 123.5,49.76 123.5,50.14 123.75,50.4 UC1.AD2
  BOTTOM w0.112: 123.51,49.75 123.58,49.68 123.58,49.06 123.72,48.91 v1(123.72,48.88)
N22625387: length 4.2
  TOP w0.089: UT5.43 39.94,104.55 40.66,103.83 v2(40.66,103.6) 40.66,103.49 39.18,102 RT99.2
N22625826: length 4.4
  TOP w0.089: UT5.33 35.94,103.86 35.38,103.3 RT100.2 v2(35.38,100.88)
N22647893: length 12.6
  TOP w0.089: v1(52.29,66.22) 51.85,65.78 v2(51.85,65.74) 51.85,65.02 RE81.1 52.14,64.73 RE541.2
  TOP w0.102: v1(45.72,69.17) 45.52,69.17 45.35,69 UE1.21
  IN1 w0.089: v1(52.29,66.22) 52.09,66.02 49.54,66.02 46.39,69.17 v1(45.72,69.17)
N22693381: length 3.5
  BOTTOM w0.102: RX8.1 105.69,32.04 106.29,31.43 106.29,30.83 v2(106.5,30.62) 107.16,29.97 UX1.2
N22693418: length 25.3
  IN2 w0.089: v1(118.45,37.31) 115.08,37.31 114.39,36.61 109.86,36.61 v1(109.42,36.17)
  BOTTOM w0.089: UX1.22 113.58,30.47 RX6.2 114.56,31.45 115.1,31.45 115.73,32.08 115.73,32.47 116.33,33.08 116.33,33.91 117.25,34.83 CX7.1 CX5.1 119.55,35.73 CX6.1 119.14,36.62 v1(118.45,37.31) ; v1(109.42,36.17) RX7.2 ; UX1.14 110.89,34.48 109.83,35.54
  BOTTOM w0.102: RX7.2 109.83,35.54
N22693593: length 4
  BOTTOM w0.089: UX1.27 110.89,28.09 110.21,27.4 108.7,27.4 108.02,26.73 RX5.1
N22726181: length 4.8
  BOTTOM w0.089: UT2.23 20.16,119 20.21,118.94 20.21,116.01 v2(20.29,115.94) 20.54,115.68 RT101.1
N22826101: length 90
  TOP w0.089: UE1.55 v1(50.04,78.21) ; v1(94,41.71) v2(94,40.8)
  IN2 w0.089: v1(50.04,78.21) 50.04,77.62 50.66,77 50.66,72 50.94,71.72 50.94,70.96 53.45,68.45 53.45,61.66 52.06,60.27 52.06,57.21 52.5,56.78 52.5,51.51 53.13,50.88 53.13,48.87 53.75,48.25 53.75,44.8 56.65,41.89 58.81,41.89 61.93,38.77 70.41,38.77 71.21,37.98 72.87,37.98 73.36,38.48 79.2,38.48 81.43,40.7 81.43,41.15 82.52,42.24 91.96,42.24 92.39,41.81 93.91,41.81 v1(94,41.71)
  BOTTOM w0.089: v1(94,41.71) 93.85,41.56 93.85,40.79 92.36,39.3 RE540.1 92.05,37.92 92.05,36.72 RE84.2
N22826272: length 1.1
  TOP w0.089: TPS11.1 119.24,56.32 v1(119.24,55.84)
  BOTTOM w0.076: v1(119.24,55.84) 119.24,55.86 119.25,55.88 119.25,56 118.98,56.26 UC1.AP11
N22826301: length 1.1
  TOP w0.089: TPS10.1 118.21,57.6 v1(118.64,57.6)
  BOTTOM w0.076: v1(118.64,57.6) 118.33,57.3 UC1.AR13
N22894187: length 22.9
  TOP w0.089: UE1.42 49.87,73.01 v1(49.62,72.75) ; v2(54.39,89.21) 54.33,89.28 v1(53.37,89.28) 53.37,88.88 53.44,88.81 RE85.1
  IN1 w0.089: v1(49.62,72.75) 50.35,72.75 50.9,73.31 50.9,82.7 53.87,85.67 53.87,87.64 53.37,88.14 v1(53.37,89.28)
N23005873: length 4.6
  TOP w0.089: v1(20.6,83.04) 20.82,83.26 UL1.26
  BOTTOM w0.089: v1(20.6,83.04) 20.6,82.86 20.85,82.61 21.74,82.61 RL21.1 22.31,83.18 RL17.1
N23415623: length 29.9
  TOP w0.089: v1(40,79.36) 39.18,80.18 39.18,80.49 37.35,82.31 37.35,82.93 ; RE89.1 28.79,73.59 v2(28.79,74.65) 29.21,75.06 30.28,75.06 v1(30.56,74.78)
  TOP w0.102: UE1.96 37.35,82.93
  IN3 w0.089: v1(30.56,74.78) 30.18,74.4 30.18,73.34 30.41,73.11 30.99,73.11 33.31,70.78 37.64,70.78 37.94,70.48 v1(38.54,70.48)
  BOTTOM w0.089: v1(38.54,70.48) 38.54,70.68 40.88,73.02 40.88,78.48 v1(40,79.36)
N23416702: length 5.1
  TOP w0.089: RE90.1 37.83,85.48 38.13,85.17 38.97,85.17 RE91.2 39.73,85.68 40.32,85.09 40.4,85.09 v2(40.47,85.02) 40.55,84.94 UE1.88
N23626434: length 8.9
  TOP w0.089: v2(207.04,38.31) 207.56,38.31 208.61,37.26 R30.1 208.61,35.88 208.89,35.61 210.94,35.61 211.19,35.36 211.19,34.8 211.36,34.63 211.36,33.38 211.67,33.06 U3.3
N23688491: length 4.3
  BOTTOM w0.089: RX9.1 v2(107.41,27.66) 109.55,27.66 109.89,28 UX1.29
N23690231: length 4.6
  TOP w0.102: UT5.18 35.94,110.43 35.04,111.34 34.02,111.34 v4(33.73,111.62) 33.49,111.87 33.49,112.67 RT115.1
N23832113: length 49.9
  TOP w0.089: v2(44.89,103.28) 44.89,102.67 v1(45,102.57) 45.14,102.71 DW1.2 46,102.24 45.68,101.93 RW13.2
  BOTTOM w0.089: v1(45,102.57) 45.24,102.81 45.24,113.13 48.51,116.39 48.51,116.96 50.49,118.94 54.52,118.94 60.01,124.42 60.89,124.42 65.69,129.22 65.69,129.5 67.03,130.84 67.51,130.84 69.74,133.06 69.74,133.5 70.63,134.4 JWLAN1.56
N23832116: length 52.7
  TOP w0.089: DW2.2 41.77,100.32 RW14.2 42.59,99.78 v2(43.16,99.78) 43.61,99.78 44.17,100.34 v1(44.48,100.34)
  BOTTOM w0.089: JWLAN1.54 70.54,133.9 70,133.36 70,133.04 67.61,130.65 67.11,130.65 65.9,129.44 65.9,129.17 60.97,124.24 60.08,124.24 54.6,118.75 50.57,118.75 48.69,116.88 48.69,116.31 45.43,113.05 45.43,102.39 44.48,101.44 v1(44.48,100.34)
N23832154: length 3.7
  TOP w0.102: v1(76.17,134.15) 75.76,133.74 RW15.1
  BOTTOM w0.102: JWLAN1.55 v1(76.17,134.15)
N23832410: length 3.5
  BOTTOM w0.089: UX1.3 107.18,30.47 106.7,30.95 106.7,31.75 v2(106.45,31.99) 106.35,32.1 106.35,32.94 RX10.1
N23852299: length 3.1
  TOP w0.089: Q24.1 64.24,32.21 v2(64.12,32.33) 63.99,32.46 63.99,33.18 R73.2
N23852303: length 7.2
  TOP w0.089: v2(70.1,30.74) R78.1 69,31.16 68.63,31.53 D7.2 67.42,31.02 C60.1 66.81,32.01 66.6,32.23 Q24.2
N24193884: length 50.1
  TOP w0.127: v2(49.21,131.72) 49.69,131.24 v1(49.69,130.81)
  TOP w0.254: v1(81.1,141.75) 81.28,141.57 PU1.4 ; v1(49.69,130.81) 49.14,130.26 49.14,128.38 47.27,126.5 46.9,126.5 46.49,126.09 PR61.2 46.1,125.79 45.89,125.99 PR62.1 45.26,125.85 PQS30.3
  IN1 w0.254: v1(49.69,130.81) 49.13,131.36 49.13,132.38 50.12,133.37 52.32,133.37 56.94,137.99 76.01,137.99 77.63,139.61 80.9,139.61 81.66,140.37 81.66,141.19 v1(81.1,141.75)
N24263922:
  vias: v2(41.94,127.78)
N24264259: length 3.1
  TOP w0.089: v2(42.73,133.1) RT120.2 41.27,131.64 41.27,131.48 41.05,131.26 UT7.3
N24265247: length 4.2
  BOTTOM w0.127: RC227.1 v2(129.31,25.48)
  BOTTOM w0.254: SW3.3 131.4,27.16 131.1,26.86 131.1,25.76 130.82,25.48 RC227.1
N24321471: length 6.7
  BOTTOM w0.089: JSSD1.10 37.13,27.32 37.38,27.57 39.27,27.57 39.9,26.94 R77.1
N24339159: length 1.9
  TOP w0.089: TP76.1 120.34,56.66 119.98,56.3 v1(119.98,55.9)
  BOTTOM w0.076: UC1.AN11 119.63,56.29 119.98,55.95 v1(119.98,55.9)
N24339162: length 2.8
  TOP w0.089: v1(119.93,56.82) 119.93,57.13 119.58,57.49 119.58,58.29 119.48,58.39 TP77.1
  BOTTOM w0.076: UC1.AN13 119.63,57.12 v1(119.93,56.82)
N24377611: length 4
  TOP w0.089: Q25.6 51.65,108.66 51.84,108.47 52.14,108.47 52.3,108.62 Q25.5 52.3,109.63 52.22,109.71 R82.2 51.58,110.17 v2(51.18,110.57)
N24460586: length 5.1
  TOP w0.089: v2(79.51,111.23) 79.42,111.32 79.42,113.14 79.33,113.23 CZ46.2
  TOP w0.254: RZ21.2 CZ46.2 79.51,113.43 80.27,113.43 80.64,113.07 UZ7.3
N24460608: length 4.2
  TOP w0.089: CZ33.2 85.13,113.85 86.48,113.85 v2(86.83,113.5)
  TOP w0.254: UZ7.6 84.34,113.07 CZ33.2
N24460612: length 1.9
  TOP w0.089: v2(86.81,114.98) 86.26,114.43 RZ10.1
N24468099:
  vias: v2(20.25,132.62)
N24557362: length 3.8
  TOP w0.089: TP90.1 122.49,122.19
  TOP w0.102: 122.49,122.19 122.65,122.35 122.65,123.64 122.75,123.74 v1(122.75,124.56)
  BOTTOM w0.102: UV1.U6 122.9,124.56 v1(122.75,124.56)
N24988672: length 4.1
  BOTTOM w0.089: RT39.1 25.37,130.39 23.9,130.39 v2(23.72,130.21)
  BOTTOM w0.102: UT3.15 25.97,130.64 RT39.1
N24988674: length 4.3
  BOTTOM w0.089: 26.73,128.88 26.35,128.51 RT40.1 25.27,128.06 24.14,128.06 v2(23.76,128.44)
  BOTTOM w0.102: 26.73,128.88 26.88,129.04 UT3.11
N25133961: length 45.5
  TOP w0.089: v1(22.86,112.7) 23.12,112.96 DI1.3 ; v1(15.02,108.2) v2(15.02,107.5)
  IN2 w0.089: v1(15.02,108.2) 16.02,107.2 21.77,107.2 22.67,108.09 22.67,110.87 23.24,111.44 23.24,112.31 v1(22.86,112.7)
  BOTTOM w0.089: v1(15.02,108.2) 14.19,107.37 14.19,106.1 14.92,105.36 14.92,102.67 14.33,102.08 14.33,99.53 14.49,99.37 14.49,98.83 14.58,98.74 14.58,92.16 17.77,88.96 19.07,88.96 19.46,89.35 22.02,89.35 23.08,90.4 25.61,90.4 RI13.2
N25133963: length 45.5
  TOP w0.089: v2(22.86,110.64) v1(22.86,112.11) 24.13,112.11 DI1.2
  IN2 w0.089: v1(22.86,112.11) 22.48,111.74 22.48,108.17 21.7,107.39 16.47,107.39 v1(15.02,108.83)
  BOTTOM w0.089: 22.96,90 22.12,89.16 19.53,89.16 19.15,88.78 17.7,88.78 14.39,92.08 14.39,98.66 14.31,98.75 14.31,99.3 14.15,99.46 14.15,102.16 14.74,102.75 14.74,105.29 14,106.02 14,107.82 v1(15.02,108.83)
  BOTTOM w0.102: RI14.2 22.96,90
N28424999: length 4.1
  BOTTOM w0.076: TP30.1 114.31,93.56 114.31,93.56 113.94,93.18 113.94,92.67 115.68,90.93 UC1.AW71
N28425002: length 4.5
  BOTTOM w0.076: TP31.1 113.2,93.01 115.32,90.89 115.32,90.12 UC1.AW70
N28810503: length 4.5
  TOP w0.203: CZ10.1 43.9,58.54 v2(43.09,58.54) 42.69,58.15 40.94,58.15 40.68,58.42 40.5,58.42 40.48,58.43 UZ3.12
N28810563: length 2.5
  TOP w0.203: UZ3.10 40.2,57.63 40.43,57.4 v2(40.95,57.4) 42.07,57.4 CZ11.1
N28842863: length 5.4
  TOP w0.089: v2(119.13,45.96) 119.19,46.01 CC56.1
  TOP w0.305: v1(120.11,47.11) 119.28,47.11 CC56.1
  BOTTOM w0.112: UC1.AL1 120.44,49.42 120.35,49.21 120.3,49.16 120.3,48.35 120.25,48.3 120.25,47.25 v1(120.11,47.11)
N28843886: length 6.1
  BOTTOM w0.076: UC1.BB10 113.28,55.55 112.33,54.61 111.6,54.61 110.61,53.61 v2(110.33,53.61) 109.37,53.61 CC69.1
N28856399: length 5.6
  BOTTOM w0.076: TP19.1 112.5,93.16 112.5,92.61 113.48,91.63 113.48,90.13 113.78,89.83 114.29,89.83 114.46,89.99 UC1.BA70
N28856402: length 2.8
  TOP w0.089: v1(112.89,89.95) 113.47,89.95 TP20.1
  BOTTOM w0.076: UC1.BA68 114.19,89.34 114.06,89.22 113.8,89.22 113.06,89.95 v1(112.89,89.95)
N28857231: length 1.8
  TOP w0.089: v1(113.08,89.38) 112.81,89.11 TP21.1
  BOTTOM w0.076: v1(113.08,89.38) 113.17,89.29 113.48,89.29 UC1.BB68
N28857234: length 6.3
  BOTTOM w0.076: UC1.BB69 113.8,89.62 113.73,89.62 113.31,90.04 113.31,91.56 111.74,93.13 111.74,93.18 111.39,93.53
  BOTTOM w0.089: TP22.1 110.8,94.12 111.39,93.53
N28857237: length 2.3
  TOP w0.089: TP23.1 120.38,55.44 120.38,56.37 120.77,56.76 v1(120.77,56.84)
  BOTTOM w0.076: v1(120.77,56.84) 121.2,57.27 UC1.AK13
N28857240: length 1.2
  TOP w0.089: v1(121.64,56.31) 121.71,56.23 TP24.1
  BOTTOM w0.076: v1(121.64,56.31) 121.32,56.62 UC1.AK12
N28861827: length 19
  TOP w0.089: v1(138.8,86.55) 138.62,86.73 138.62,88.05 138.88,88.31 138.88,89.4 139.18,89.7
  TOP w0.102: 139.18,89.7 139.54,90.06 139.54,91.77 136.44,94.87 v2(133.12,94.87) 131.61,96.38 RC138.1
  BOTTOM w0.076: UC1.C64 135.65,86.29 135.75,86.4 136.99,86.4 137.14,86.55 v1(138.8,86.55)
N28938619: length 35.3
  TOP w0.112: v1(113.33,48.45) 113.33,48.28 113.18,48.13 112.92,48.13 112.78,48.28 112.78,48.48 112.63,48.63 112.35,48.63 112.18,48.46 112.18,47.91 112.31,47.78 113.08,47.78 113.19,47.67 113.19,47.44 113.08,47.33 112.31,47.33 112.18,47.2 112.18,46.63 112.3,46.52 113.85,46.52 114.1,46.77 114.39,46.77 117.05,44.1 118.41,44.1 118.66,43.85 118.86,43.85 v2(118.94,43.94) 119.11,44.1 119.26,44.1 119.45,43.91 119.45,43.8 119.18,43.54 119.18,43.38 119.34,43.22 119.5,43.22 119.65,43.37 119.81,43.37 119.96,43.21 119.96,43.05 119.82,42.9 119.82,42.76 119.93,42.64 119.93,42.5 119.86,42.43 119.59,42.43 119,41.83 119,41.8 118.52,41.32 118.52,41.16 118.7,40.98 118.7,40.82 118.45,40.57 v1(118.45,40.44)
  BOTTOM w0.076: UC1.AV2 116.27,51.11 116.16,51.11 116.03,50.98 116.03,50.87 116.27,50.62 116.27,50.51 115.99,50.23 115.88,50.23 115.78,50.33 115.62,50.33 115.35,50.06 115.35,49.93 115.54,49.73 115.54,49.63 115.34,49.42 114.88,49.42 114.7,49.25 114.3,49.25 113.95,48.89 113.75,48.89 113.67,48.97 113.67,49.2 113.6,49.27 112.7,49.27 112.45,49.03 112.45,48.83
  BOTTOM w0.089: v1(113.33,48.45) 113.74,48.05 113.74,47.88 113.32,47.47 113.15,47.47 113.06,47.56 112.61,47.56 112.45,47.72 112.45,47.94 112.54,48.03 112.8,48.03 112.89,48.12 112.89,48.29 112.8,48.38 112.54,48.38 112.45,48.47 112.45,48.83 ; RC203.1 118.65,39.2 118.78,39.33 118.78,39.8 118.69,39.89 118.19,39.89 117.89,39.58 117.72,39.58 117.49,39.82 117.49,39.99 117.73,40.23 117.73,40.35 117.49,40.59 117.49,40.77 117.67,40.95 117.83,40.95 118.06,40.73 118.36,40.73 118.45,40.64 v1(118.45,40.44)
N28938912: length 2.5
  TOP w0.089: v2(108.03,45.32) 108.03,45.82 v1(107.9,45.96)
  BOTTOM w0.089: CC2.2 108.24,45.62 v1(107.9,45.96)
  BOTTOM w0.102: RC21.1 CC2.2
N29708599: length 1.1
  TOP w0.089: v1(116.84,53.13) 116.84,53.13 116.84,52.86 TP25.1
  BOTTOM w0.076: UC1.AU5 117.03,52.93 v1(116.84,53.13)
N29708601: length 1.5
  TOP w0.089: v1(117.47,53.14) 117.47,52.81 117.69,52.59 TP26.1
  BOTTOM w0.076: v1(117.47,53.14) 117.47,52.87 UC1.AT5
N32433695: length 5.3
  TOP w0.089: RV120.1 152.94,115.88 v2(152.73,115.88)
  TOP w0.102: UV14.J13 155.1,120.11 154.73,119.74 154.73,118.55 153.71,117.53 RV120.1
N32433703: length 4.3
  TOP w0.089: v2(153.96,132.32) 154.09,132.45 RV116.1
  TOP w0.102: RV116.1 155.49,132.06 155.49,130.09 155.34,129.94 UV14.J1
N32433714: length 10.8
  TOP w0.102: v1(163.63,123.43) 163.82,123.62 RV118.1 ; UV14.J10 155.11,122.67 v1(155.49,123.05)
  BOTTOM w0.089: v2(163.46,122.74) 163.63,122.91 v1(163.63,123.43)
  BOTTOM w0.102: v1(155.49,123.05) 156.3,123.87 162.3,123.87 162.74,123.43 v1(163.63,123.43)
N32434049: length 5
  TOP w0.089: v2(152.69,117.15) 152.96,117.43 v1(153.21,117.43)
  BOTTOM w0.102: RV121.1 152.82,117.04 v1(153.21,117.43) 154.71,118.93 154.71,119.71 UV15.J13
N32434050: length 5.1
  BOTTOM w0.089: v2(157.26,131.88) 155.66,131.88 RV117.1
  BOTTOM w0.102: UV15.J1 155.09,129.72 RV117.1
N32434053: length 11.1
  BOTTOM w0.102: RV119.1 163.88,123.99 163.62,123.99 v2(163.36,124.25) 162.82,124.79 156.53,124.79 155.04,123.31 155.04,122.86 155.11,122.8 UV15.J10
N32437553: length 3.8
  TOP w0.102: UV12.J13 155.12,145.93 155.53,146.34 155.53,146.92 155.63,147.02 155.64,147.02 156.6,147.98 156.6,148.3 156.43,148.47 RV123.1
N32437559: length 5.2
  BOTTOM w0.089: RV132.1 157.27,149.78 v2(156.98,150.07)
  BOTTOM w0.102: UV13.J13 155.43,146.25 155.43,146.71 157.27,148.55 RV132.1
N32437560: length 2.9
  BOTTOM w0.102: UV13.J1 155.09,136.31 v2(155.09,134.35) RV131.1
N32437563: length 11.3
  BOTTOM w0.089: v2(164.85,143.62) 164.85,143.42 RV133.1
  BOTTOM w0.102: UV13.J10 155.11,142.99 155.52,142.58 161.65,142.58 161.94,142.86 163.67,142.86 RV133.1
N32842463: length 14
  TOP w0.089: v2(128.88,47.54) 129.29,47.54 v1(129.38,47.46)
  TOP w0.112: RC137.2 129.38,46.76 v1(129.38,47.46)
  IN1 w0.102: 129.69,48.61 129.38,48.29 v1(129.38,47.46)
  IN1 w0.114: v1(127.05,56.3) 127.49,55.86 127.49,55.53 127.71,55.32 128.34,55.32 128.91,54.75 129.21,54.75 129.52,54.43 129.52,54.05 129.07,53.59 129.07,51.83 129.69,51.2 129.69,48.61
  BOTTOM w0.254: UC1.U11 127.48,55.97 127.16,56.3 v1(127.05,56.3) 127.38,56.62 UC1.U12
N33188643: length 3
  TOP w0.102: RA23.2 RA24.1 28.74,20.51 28.3,20.07 28.3,19.31 CA31.1
N37640332: length 1.4
  TOP w0.381: RV2.2 125.59,128.33 v1(126.12,128.33)
  BOTTOM w0.381: UV1.N10 126.58,128.36 126.22,128.36 126.19,128.33 v1(126.12,128.33)
N37640410: length 1.4
  TOP w0.508: v1(120.12,138.49) 120.17,138.55 RV3.1
  BOTTOM w0.381: v1(120.12,138.49) 120.12,138.02 UV1.AA22
N37828209: length 1.4
  TOP w0.508: RV1.1 121.25,138.62 v1(121.36,138.51)
  BOTTOM w0.381: v1(121.36,138.51) 121.36,138.51 121.36,137.82 UV1.Y22
N38038746: length 2.8
  BOTTOM w0.089: v2(150.94,114.56) CV96.1 150.57,115.73 150.5,115.66
  BOTTOM w0.102: 150.5,115.66 RV36.2 RV37.2
N38038992: length 6.3
  TOP w0.102: CV98.2 129.71,122.2 129.52,122.39 129.52,123.59 130.29,124.36 130.29,125.21 v1(129.35,126.15) 129.17,125.97 v2(128.87,125.97)
  BOTTOM w0.102: UV1.K8 128.94,126.56 v1(129.35,126.15)
N38038994: length 4.5
  TOP w0.102: CV99.2 128.69,122.49 128.96,122.77 128.96,125.26 128.65,125.58 v1(128.47,125.58)
  BOTTOM w0.102: v1(128.47,125.58) 128.16,125.58 UV1.L7
N38038995: length 1.9
  TOP w0.089: v2(128.79,119.85) 128.95,120.01 RV40.2
  TOP w0.102: CV98.1 RV40.2
N38038996: length 4
  TOP w0.102: RV41.2 126.48,119.9 v2(126.48,122.03) 126.48,122.18 126.78,122.49 CV99.1
N38349725: length 10.6
  TOP w0.254: v1(128.58,140.56) 128.58,142.6 127.61,143.56 127.61,144.89 126.9,145.6 v2(124.01,145.6) 122.81,145.6 RV39.2
  BOTTOM w0.3: v1(128.58,140.56) UV1.K25
N38996077: length 4.6
  TOP w0.089: v2(153.93,133.84) 154.37,133.4 RV134.1
  TOP w0.102: RV134.1 155.09,133.43 155.47,133.81 155.47,135.96 UV12.J1
N38996080: length 11.5
  TOP w0.102: v1(154.85,142.55) 155.11,142.8 UV12.J10 ; RV135.1 v1(163.98,141.79)
  BOTTOM w0.102: v1(154.85,142.55) 155.84,141.56 v2(163.46,141.56) 163.76,141.56 v1(163.98,141.79)
N40598435: length 1.2
  BOTTOM w0.089: PC307.1 v2(24.51,40.42)
N40598500: length 0.9
  TOP w0.089: v1(23,102.13) v3(23,101.23)
N40598503: length 2
  BOTTOM w0.089: PR306.1 21.52,48.78 v2(21.33,48.96)
  BOTTOM w0.254: PC315.2 21.51,47.85 PR306.1
N40598539: length 1.9
  BOTTOM w0.089: PR509.1 v2(23.15,92.31)
  BOTTOM w0.254: PC517.2 PR509.1
N40598619: length 3.7
  BOTTOM w0.127: PR507.2 27.01,84.27 26.56,83.83 v2(26.11,83.83)
  BOTTOM w0.254: PR507.2 27.12,84.53 26.06,85.59 PD501.1
N40664383: length 3.2
  TOP w0.102: v1(81.23,66.21) 81.99,66.21 TP41.1
  BOTTOM w0.102: v1(81.23,66.21) 80.45,66.99 JDIMM1.165
N40665360: length 6.1
  TOP w0.102: TP42.1 64.85,65.64 64.21,66.29 v1(63.5,66.29)
  BOTTOM w0.102: v1(63.5,66.29) 65.01,66.29 65.71,66.99 JDIMM2.165
N40665398: length 2.1
  TOP w0.089: TP43.1 56.89,67.45 v1(56.89,67.73)
  BOTTOM w0.102: v1(56.89,67.73) 57,67.73 57,67.74 JDIMM2.162
N41527020: length 4.1
  TOP w0.102: TP40.1 73.77,66.91 v1(73.97,66.91)
  BOTTOM w0.102: v1(73.97,66.91) 73.14,67.74 JDIMM1.162
N42785906: length 4.8
  TOP w0.254: v1(205.08,42.59) v2(204.69,42.2) 203.94,41.45 PCB35.1
  BOTTOM w0.203: PRB21.1 204.45,41.27 205.08,41.89 v1(205.08,42.59) 205.08,42.69 205.04,42.73 205.04,43.29 205.17,43.42 PUB01.3
N42785908: length 2.6
  BOTTOM w0.089: PRB08.1 202.25,51.82 201.51,52.56 200.34,52.56 v2(200.16,52.38)
N42785925: length 24.4
  TOP w0.089: v1(198.43,47.3) v2(198.43,47.94)
  IN1 w0.254: v1(198.43,47.3) 198.43,47.79 198.07,48.15 198.07,48.81 197.34,49.53 197.34,53.32 192.88,57.78 184.95,57.78 v1(184.06,58.68)
  BOTTOM w0.203: v1(198.43,47.3) 198.59,47.15 PRB03.1
  BOTTOM w0.254: v1(184.06,58.68) 184.17,58.56 PRB01.3
N42785929: length 1.8
  BOTTOM w0.203: PRB28.1 208.24,45.22 207.76,45.69 PUB01.29
N42785931: length 2.5
  BOTTOM w0.254: PCB40.1 209.96,44.32 PRB34.1 PRB35.1 209.88,45.19 PRB28.2
N42785953: length 3.9
  TOP w0.254: v1(207.43,45.23) 207.6,45.23 208.22,44.61 v2(208.24,44.61) PRB33.1
  BOTTOM w0.203: PUB01.30 207.37,45.29 v1(207.43,45.23) 207.73,44.93 207.73,44.68 PRB31.1
N42785972: length 5.9
  TOP w0.254: PRB37.1 168.04,37.19 167.79,37.45 v2(167.61,37.45) 167,37.45 165.13,35.58 PDB04.3 164.69,35.58 PRB38.2
N42786037: length 29.9
  IN2 w0.102: v1(180.34,42.36) 180.71,42.73 181.18,42.73 183.9,40.02 196.27,40.02 196.77,39.51 202.27,39.51 v1(202.66,39.12)
  BOTTOM w0.102: PRB36.2 206.14,38.9 205.43,38.18 v2(204.78,38.18) 204.68,38.08 204.25,38.08 203.91,38.43 203.6,38.43 202.9,39.12 v1(202.66,39.12)
  BOTTOM w0.254: PRB12.3 180.01,42.76 180.34,42.43 v1(180.34,42.36)
N42786187: length 1.4
  TOP w0.254: PUB02.4 166.97,32.36 167.47,31.86 PRB42.1
N42786400: length 30.1
  TOP w0.089: v2(205.65,38.72) 205.51,38.58 v1(204.36,38.58)
  IN2 w0.102: v1(204.36,38.58) 203.51,38.58 203.17,38.92 203.17,39.29 202.75,39.71 196.91,39.71 196.4,40.22 183.98,40.22 181.26,42.93 180.54,42.93 v1(180.31,43.16)
  BOTTOM w0.089: v1(204.36,38.58) 204.74,38.58 205.22,39.06 PRB32.2
  BOTTOM w0.254: v1(180.31,43.16) 180.31,43.03 180.58,42.76 PRB12.2
N42787412: length 2.6
  TOP w0.089: v2(164.22,32.14) 164.38,32.3 164.38,32.91 164.04,33.26 PRB41.2
  TOP w0.254: PUB02.2 164.58,33.43 164.56,33.45 PRB41.2
N42787418: length 2.8
  TOP w0.089: v2(164.92,38.37) 164.65,38.1 164.27,38.1 PRB40.2
  TOP w0.254: PRB40.2 164.38,37.52 164.88,37.52 165.09,37.32 PDB04.2
N42787433: length 3.3
  TOP w0.254: PRB27.2 PRB29.2 208.3,46.36 v2(207.86,46.8) 207.55,47.11 v1(207.4,47.11)
  BOTTOM w0.203: v1(207.4,47.11) 207.18,46.89 PUB01.26
N42787440: length 0.9
  BOTTOM w0.254: PCB42.1 209.97,47.04 209.18,47.04 209.15,47.06 PRB30.2
N42787460: length 1.1
  BOTTOM w0.089: v2(198.41,46.06) 198.49,46.14 PRB06.2
N42787464: length 1.1
  TOP w0.254: ZTB01.1 210.51,46.36 PRB29.1
N42787500: length 2.5
  BOTTOM w0.089: PRB15.1 200.79,39.77 v2(200.74,39.73)
  BOTTOM w0.254: PRB15.1 202.02,39.77 PCB30.2
N42787538: length 23.4
  TOP w0.089: v1(198.7,48.67) v2(198.7,49.51)
  IN1 w0.254: v1(184.76,58.68) 185.3,58.14 193.02,58.14 197.7,53.46 197.7,49.68 v1(198.7,48.67)
  BOTTOM w0.203: v1(198.7,48.67) 198.7,48.31 198.98,48.03 PRB02.1
  BOTTOM w0.254: PRB01.2 184.17,59.26 v1(184.76,58.68)
N42787589: length 3.3
  TOP w0.089: v1(205.08,49.3) 205.56,49.78 v2(205.56,50.15)
  BOTTOM w0.203: PRB14.2 204.64,49.91 205.08,49.47 v1(205.08,49.3) 205.08,49.11 204.83,48.87 204.83,48.47 204.77,48.4 PUB01.21
N42787591: length 3.2
  TOP w0.089: v2(206.4,49.04) 206.13,48.78 v1(205.39,48.78)
  BOTTOM w0.203: PRB16.2 205.56,49.81 205.56,48.95 v1(205.39,48.78) 205.17,48.55 PUB01.22
N42787599: length 2.2
  BOTTOM w0.203: PUB01.23 205.57,48.33 205.98,48.74 ZTB02.1
  BOTTOM w0.254: PRB19.2 206.27,49.28 ZTB02.1
N45784517: length 4.8
  BOTTOM w0.203: PUZ01.41 179.2,56.5 179.29,56.59 v2(179.56,56.59)
  BOTTOM w0.254: PCZ02.1 182.25,55.38 182.23,55.41 PRZ06.2 182.23,56.22 182.05,56.39 PCZ09.1 PCZ08.1 180.31,56.59 v2(179.56,56.59)
N45784764: length 1.7
  BOTTOM w0.203: PRZ16.2 179.02,57.7 PUZ01.38
N45784907: length 7.1
  TOP w0.089: PCZ33.1 v2(172.47,62.92)
  TOP w0.254: PCZ33.1 173.47,62.07 PCZ26.2 173.64,60.75 v1(173.83,60.56)
  BOTTOM w0.203: PCZ27.2 173.45,61.23 173.45,60.94 173.83,60.56 v1(173.83,60.56) 173.83,59.99 174.43,59.4 PUZ01.28
  BOTTOM w0.254: PCZ27.2 173.43,62.06 PRZ51.2
N45784946: length 1.9
  TOP w0.089: v2(183.21,55.82) PRZ01.1
  TOP w0.254: PRZ01.1 182.16,55.83 181.37,55.83 PCZ01.2
N45784991: length 2
  BOTTOM w0.089: PRZ20.2 180,48.64 v2(180.49,49.13)
  BOTTOM w0.203: PCZ13.1 PRZ20.2
N45785219: length 1.9
  TOP w0.089: v2(169.12,57.97) 168.96,58.13 PCZ35.1
  TOP w0.254: PRZ61.2 168.98,59.05 PCZ35.1
N45789065: length 1.7
  TOP w0.089: PRI03.2 v3(161.27,64.82)
N47599587: length 2.3
  TOP w0.089: v2(179.33,48.29) 178.5,49.13 PRZ24.2
  TOP w0.254: PCZ16.1 178.47,49.28 PRZ24.2
N47697054: length 1.6
  BOTTOM w0.254: PRH05.2 164.78,52.78 164,52.78 163.73,52.5 PUH01.7
N47701287: length 4.5
  TOP w0.089: v1(164.25,50.48) 164.25,50.2 163.84,49.79 v2(163.84,48.57)
  TOP w0.254: PCH11.1 164.74,50.48 v1(164.25,50.48)
  BOTTOM w0.254: PUH01.11 164.02,50.7 v1(164.25,50.48) 164.65,50.07 PRH11.2
N47701297: length 3.8
  BOTTOM w0.089: v2(167.04,52.34) 166.91,52.22 165.37,52.22 PCH10.1
  BOTTOM w0.254: PUH01.9 164.76,51.6 PCH10.1
N47710281: length 4.2
  TOP w0.089: PR2504.2 70.67,115.43 v2(70.43,115.67)
  TOP w0.254: PU2501.4 72.34,114.23 72.55,114.45 72.55,115.17 PC2504.1 PR2504.2
N47714748: length 1.1
  TOP w0.089: PCM11.1 v2(53.11,27.96)
N47727863: length 4
  TOP w0.089: PRW11.2 144.12,110.05 v2(142.59,110.05)
  TOP w0.254: v1(143.98,110.82) 144.17,110.62 PRW11.2
  BOTTOM w0.254: PUW01.11 143.8,110.6 143.98,110.78 ; PCW11.1 144.29,111.05 144.02,110.78 143.98,110.78 ; v1(143.98,110.82) 143.98,110.78
N47727869: length 1.4
  BOTTOM w0.254: PCW10.1 142.66,110.79 142.9,110.55 PUW01.9
N47735962: length 1.9
  BOTTOM w0.254: PRW05.2 140.88,110.88 141.68,110.07 PUW01.7
N47772279: length 2
  BOTTOM w0.089: v2(173.24,63.98) 172.65,63.39 PCZ31.2
  BOTTOM w0.254: PRZ55.1 PCZ31.2
N47887852: length 1.8
  TOP w0.089: PR1804.2 v2(162.84,43.49)
N48572179: length 2.1
  TOP w0.089: v2(167.9,51.97) 166.79,51.97 PCH14.2
  TOP w0.508: PRH12.1 166.66,51.93 PCH14.2
N48572231: length 2.8
  BOTTOM w0.089: v2(148.67,114.56) 147.7,114.56 147.61,114.65 PCW14.2
  BOTTOM w0.254: PRW13.1 146.29,114.65 PCW14.2
N124752685: length 2.3
  TOP w0.089: v2(71.05,61.68) 71.7,62.32 RD11.1
  TOP w0.102: CD30.2 RD11.1
N124753277: length 2.4
  TOP w0.089: CD59.2 RD22.1 58.07,70.26 v2(58.58,70.77)
N227673600: length 4.3
  TOP w0.102: RU23.1 29.78,46.98 v2(30.5,47.7) 31,48.19 UU2.15
N227673690: length 3.4
  TOP w0.102: RU24.1 30.61,46.08 v2(30.62,46.08) 30.62,47.15 31.16,47.69 UU2.16
N248688580: length 4.4
  TOP w0.089: v2(209.75,44.62) 209.2,44.62 208.73,45.09 PRB26.1
  TOP w0.254: PRB26.1 207.98,45.59 207.42,46.16 v1(207.42,46.5)
  BOTTOM w0.203: v1(207.42,46.5) 207.4,46.49 PUB01.27
N248743791: length 34.4
  TOP w0.089: PRZ10.1 v2(181.72,59.08)
  TOP w0.152: PRZ10.1 180.03,59.75 v1(179.07,59.75)
  IN3 w0.152: v1(179.07,59.75) 178.67,60.14 177.15,60.14 176.43,59.42 173.18,59.42 172.15,60.44 170.77,60.44 170.36,60.04 167.25,60.04 166.02,58.81 166.02,57.05 165.33,56.36 159.52,56.36 159.31,56.14 157.66,56.14 157.41,55.9 154.14,55.9 v1(153.04,56.99)
  BOTTOM w0.152: v1(153.04,56.99) 152.61,56.99 152.5,56.88 PHZ01.2

## Copper pours and planes (outline as drawn)
2.5V_VIN on TOP (solid shape): 76.13,113.27 75.76,112.9 74.62,112.9 74.46,112.73 72.75,112.73 72.58,112.56 70.76,112.56 70.57,112.75 70.57,113.13 70.77,113.33 72.21,113.33 72.82,113.94 74.46,113.94 74.62,114.11 76.13,114.11
3V_SN on TOP (solid shape): 24.52,44.61 24.52,43.04 24.43,42.95 23.53,42.95 23.48,43 23.48,43.92 23.32,44.08 22.24,44.08 22.2,44.13 22.2,44.71 22.23,44.75 24.38,44.75
3V_VIN on TOP (solid shape): 18.79,42.15 18.79,40.89 18.6,40.7 17.3,40.7 17.2,40.8 17.2,42.13 17.33,42.26 18.68,42.26
3V_VIN on BOTTOM (solid shape): 14.33,41.97 14.39,41.96 14.41,41.94 14.41,41.21 14.54,41.08 15.39,41.08 15.72,41.41 15.8,41.41 18.36,41.41 18.86,41.91 18.89,41.91 18.94,41.96 20.43,41.96 20.53,41.85 20.53,40.7 20.43,40.6 20.43,39.5 20.55,39.38 21.1,39.38 21.38,39.1 21.38,38.73 21.18,38.54 17.8,38.54 17.14,39.2 14.71,39.2 14.49,38.99 14.49,38.59 14.37,38.47 13.76,38.47 13.7,38.53 13.7,41.65 13.71,41.66 13.71,41.93 13.75,41.98 13.78,41.98 13.89,41.97 14,42 14.01,42 14.26,42
5V_SN on TOP (solid shape): 21.62,102.63 21.62,100.69 21.5,100.56 18.68,100.56 18.62,100.62 18.62,101.36 18.78,101.51 19.55,101.51 19.87,101.84 19.87,102.61 19.93,102.67 21.57,102.67
5V_VIN on TOP (solid shape): 29.8,100.07 29.8,98.8 29.67,98.67 28.12,98.67 28.01,98.78 28.01,100.08 28.11,100.18 29.69,100.18
5V_VIN on BOTTOM (solid shape): 26.08,103.85 26.08,102.76 26.35,102.49 27.35,102.49 27.35,101.94 27.92,101.94 27.92,102.49 28.16,102.49 28.16,101.94 28.71,101.94 28.71,102.49 29.07,102.49 29.73,101.83 29.73,98.68 26.89,98.68 26.5,98.29 25.04,98.29 24.97,98.37 24.97,99.43 25.43,99.9 25.43,103.88 25.5,103.94 25.98,103.94
+0.6V_DDR_VTT on TOP (solid shape): 62.05,44.39 62.05,43.57 61.27,42.79 57.84,42.79 57.5,43.12 57.5,44.12 57.88,44.5 61.95,44.5
+0.6V_DDR_VTT on TOP (solid shape): 40.74,35.89 40.74,34.81 40.68,34.74 40.2,34.74 40.2,34.74 40.2,34.18 40.02,34.18 40.02,34.73 40.01,34.74 39.61,34.74 39.1,35.24 39.1,35.95 39.33,36.17 40.47,36.17
+0.6V_DDR_VTT on TOP (solid shape): outline of 179 points within 67.92,32.91 76.16,44.49
+0.6V_DDR_VTT on BOTTOM (solid shape): 61.4,43.54 61.4,42.88 61.12,42.6 59.71,42.6 59.36,42.96 59.36,43.54 59.31,43.59 57.43,43.59 57.36,43.66 57.36,43.8 57.45,43.89 61.04,43.89
+0.6V_DDR_VTT on BOTTOM (solid shape): 73.49,43.66 73.49,42.74 73.3,42.55 72.27,42.55 72.11,42.72 72.11,43.26 71.8,43.58 70.17,43.58 70.07,43.68 70.07,43.79 70.17,43.89 71.78,43.89 71.8,43.91 73.24,43.91
+0.6V_DDR_VTT on IN2 (solid shape): 61.84,44.02 61.84,43.35 60.99,42.5 60.63,42.5 60.01,43.12 60.01,43.38 60.36,43.72 60.38,43.72 60.82,44.17 61.69,44.17
+0.6V_DDR_VTT on IN2 (solid shape): 73.46,42.84 73.46,42.35 73.21,42.1 71.72,42.1 71.59,42.24 71.59,42.87 71.69,42.97 71.93,42.97 71.94,42.98 72.14,42.98 72.26,43.09 73.21,43.09
+0.6V_DDR_VTT on VCC: 40.8,30.41 36.61,34.63 36.61,36.28 37.16,36.83 39.05,36.83 41.89,33.99 42.7,32.39 46.85,32.45 47.28,32.87 47.28,33.94 48.21,34.86 72,34.86 72.68,34.18 72.68,32.13 49.99,32.14 48.31,30.44
+0.6VSP on TOP (solid shape): 39.89,34.13 39.9,34.12 39.9,34.04 40.33,34.04 40.33,34.58 40.78,34.58 40.78,34.58 40.85,34.58 41,34.43 41,33.51 40.62,33.13 40.06,33.13 39.72,32.79 39.72,31.85 39.46,31.58 39.38,31.58 39.18,31.37 39.18,31.3 38.84,30.97 38.84,29.56 38.79,29.5 37.99,29.5 37.94,29.55 37.94,30.66 38.16,30.88 38.23,30.94 38.29,31.01 38.34,31.06 38.34,31.43 38.21,31.56 37.71,31.56 37.57,31.42 37.57,31.09 37.36,30.88 37.36,29.97 37.3,29.9 37.19,29.9 37.13,29.97 37.13,31.03 37.32,31.22 37.32,34.14 37.37,34.19 38.42,34.19 38.8,34.58 39.71,34.58 39.71,34.58 39.89,34.58
+0.95VSDGPU on TOP (solid shape): outline of 188 points within 119.09,139.75 121.61,146.07
+0.95VSDGPU on BOTTOM (solid shape): 118.81,119.29 118.91,119.29 119.05,119.15 119.05,118.8 119,118.75 119,118.03 119,118.03 118.98,117.94 119,117.85 119,117.85 119,117.27 119.39,116.89 121.68,116.89 122.04,116.52 122.04,115.28 122.04,115.28 122.04,114.85 121.66,114.48 120.84,114.48 120.83,114.47 120.5,114.47 120.5,114.47 120.5,114.99 120.47,115.02 119.99,115.02 119.95,114.98 119.95,114.47 119.95,114.47 119.7,114.47 119.7,114.47 119.7,114.99 119.68,115.01 119.16,115.01 119.15,115.01 119.15,114.47 119.15,114.47 117.4,114.47 117.16,114.71 117.16,116.58 117.26,116.69 117.26,119.08 117.48,119.29 118.81,119.29
+0.95VSDGPU on IN1 (solid shape): outline of 902 points within 107.67,117.94 121.13,146.66
+0.95VSDGPU_OUT on BOTTOM (solid shape): 120.36,114.87 120.36,114.36 120.38,114.34 121.77,114.34 122.11,114.68 124.55,114.68 124.72,114.51 124.72,113.27 125.51,112.48 125.51,111.86 125.43,111.79 124.14,111.79 123.45,112.48 123.33,112.48 123.32,112.53 123.05,112.77 122.77,112.53 122.76,112.48 120.58,112.48 120.58,112.48 118.86,112.48 118.78,112.56 118.78,114.3 118.81,114.33 119.26,114.33 119.29,114.36 119.29,114.87 119.3,114.88 119.55,114.88 119.55,114.87 119.55,114.34 119.56,114.33 120.07,114.33 120.09,114.35 120.09,114.4 120.1,114.4 120.09,114.49 120.09,114.87 120.1,114.88 120.35,114.88
+1.0V_APLL on TOP (solid shape): 126.92,58.82 126.92,58.3 127.13,58.09 127.43,58.09 127.56,57.96 127.58,57.94 127.58,57.56 127.49,57.47 127.1,57.47 126.88,57.24 126.88,56.58 126.82,56.53 126.77,56.48 126.69,56.48 126.65,56.49 126.62,56.49 126.22,56.49 126.21,56.51 126.21,58.18 126.08,58.3 126.08,58.84 126.11,58.86 126.89,58.86
+1.0V_CLK2 on TOP (solid shape): outline of 219 points within 131.63,58.9 135.56,60.62
+1.0V_CLK5 on TOP (solid shape): 131.24,61.74 131.24,60.68 130.36,60.68 130.36,61.82 130.49,61.96 131.02,61.96
+1.0V_MPHYGT on TOP (solid shape): outline of 1401 points within 127.99,47.15 145.08,59.36
+1.0V_MPHYGT on BOTTOM (solid shape): 129.75,59.4 129.75,58.11 129.36,57.72 129.33,57.76 129.3,57.92 129.19,58.05 128.97,58.11 128.77,58.01 128.68,57.86 128.68,57.7 128.62,57.63 128.32,57.63 128.01,57.95 128.01,58.12 128.01,58.16 128.01,58.58 128.13,58.71 128.32,58.71 128.9,59.28 128.9,59.28 129,59.39 129.12,59.39 129.15,59.42 129.28,59.49 129.36,59.62 129.53,59.62
+1.0V_PRIM on TOP (solid shape): 157.13,56.95 157.13,55.53 157.08,55.48 155.63,55.48 155.58,55.53 155.58,57.01 155.74,57.16 156.93,57.16
+1.0V_PRIM on TOP (solid shape): 154.5,33.53 157.48,33.53 157.57,33.44 157.57,32.89 157.74,32.71 158.45,32.71 158.8,32.36 160.34,32.36 160.57,32.13 161.29,32.13 161.36,32.06 161.36,31.38 161.26,31.27 160.26,31.27 159.97,31.56 158.37,31.56 158.15,31.78 156.35,31.78 156.12,31.55 156.12,30.99 155.7,30.57 155.7,29.83 155.55,29.68 154,29.68 153.86,29.82 153.86,30.89 152.52,32.23 152.52,32.74 154.24,32.74 154.24,32.68 154.25,32.63 154.27,32.58 154.3,32.54 154.33,32.49 154.37,32.46 154.41,32.43 154.46,32.4 154.51,32.39 154.57,32.38 154.62,32.38 154.67,32.39 154.72,32.4 154.77,32.43 154.82,32.46 154.85,32.49 154.89,32.54 154.91,32.58 154.93,32.63 154.95,32.68 154.95,32.74 154.95,32.79 154.93,32.84 154.91,32.89 154.89,32.94 154.85,32.98 154.82,33.02 154.77,33.05 154.72,33.07 154.67,33.08 154.62,33.09 154.57,33.09 154.51,33.08 154.46,33.07 154.41,33.05 154.37,33.02 154.33,32.98 154.3,32.94 154.27,32.89 154.25,32.84 154.24,32.79 154.24,32.74 152.52,32.74 152.52,33.66 151.7,34.48 151.7,34.99 151.85,35.14 152.89,35.14
+1.0V_PRIM on TOP (solid shape): outline of 171 points within 122.69,59.03 130.18,62.84
+1.0V_PRIM on TOP (solid shape): outline of 400 points within 143.69,44.92 151.85,57.16
+1.0V_PRIM on BOTTOM (solid shape): 128.37,113.91 128.64,113.91 128.81,113.74 128.81,113.14 128.61,112.94 128.49,112.94 128.29,112.74 128.29,112.29 127.89,111.88 127.52,111.88 127.43,111.79 126.84,111.79 126.79,111.84 126.79,112.54 126.11,113.21 126.11,113.75 126.19,113.83 126.38,113.83 126.45,113.9 126.91,113.9 126.91,113.91 128.36,113.91
+1.0V_PRIM on BOTTOM (solid shape): 149.34,56.62 149.34,56.19 149.31,56.17 149.31,54.92 149.34,54.9 149.34,54.72 149.54,54.52 150.35,54.52 150.68,54.19 150.68,50.2 150.45,49.97 148.65,49.97 148.55,49.87 147.24,49.87 147.16,49.79 146.92,49.79 146.83,49.88 146.83,50.21 146.91,50.29 146.91,51.01 146.29,51.63 146.29,53.4 146.91,54.02 146.91,55.24 146.9,55.24 146.9,55.37 146.61,55.66 145.77,55.66 145.62,55.81 145.62,57.1 145.71,57.2 148.76,57.2
+1.0V_PRIM on IN1 (solid shape): 148.93,100.73 148.93,99.53 148.76,99.36 147,99.36 146.83,99.53 146.83,100.61 147.11,100.89 148.77,100.89
+1.0V_PRIM on IN1 (solid shape): 129.83,112.45 129.83,111.65 129.52,111.35 127.59,111.35 127.22,111.72 127.22,113.09 127.15,113.16 127.15,113.72 127.29,113.85 128.43,113.85
+1.0V_PRIM on IN1 (solid shape): outline of 4236 points within 114.14,47.72 131.01,63.44
+1.0V_PRIM on IN2 (solid shape): outline of 1617 points within 126.66,52.76 140.46,62.77
+1.0V_PRIM on IN3 (solid shape): 157.02,57.79 157.02,56.74 156.88,56.6 155.92,56.6 155.75,56.77 155.75,57.72 155.95,57.92 156.89,57.92
+1.0V_PRIM on IN3 (solid shape): 150.15,100.47 150.15,99.64 149.93,99.59 149.78,99.42 148.37,99.42 148.21,99.59 148.21,100.71 148.27,100.77 149.84,100.77
+1.0V_PRIM on VCC: 127.66,49.7 124.88,52.48 112.52,52.48 112.52,62.04 113.64,63.16 127.4,63.16 131.76,58.81 138.13,58.81 139.93,57.01 151.35,57.01 151.35,50.49 150.56,49.7
+1.0V_SRAM on IN3 (solid shape): outline of 667 points within 123.54,57.82 128.88,62.37
+1.0V_VCCST on TOP (solid shape): 161.48,37.11 161.48,35.96 161.42,35.89 161.1,35.89 161.07,35.92 161.07,36.41 161.04,36.45 160.64,36.45 160.61,36.43 160.61,35.91 160.6,35.9 158.15,35.9 157.62,36.43 157.62,37.15 157.69,37.22 161.38,37.22
+1.0V_VCCST on TOP (solid shape): 131.84,62.57 131.84,62.55 131.93,62.46 131.86,62.23 131.96,62.02 131.96,61.54 131.97,61.14 132.35,61.03 132.36,61.04 132.64,61.04 132.81,60.98 132.99,61.04 133.27,61.04 133.28,61.03 133.4,61.01 133.52,61.03 133.53,61.04 134.04,61.04 134.05,61.03 134.17,61.01 134.3,61.03 134.3,61.04 134.5,61.04 134.57,61.1 135.14,61.1 135.14,60.59 134.35,60.59 134.12,60.75 133.85,60.68 133.71,60.68 133.5,60.76 133.3,60.68 132.98,60.68 132.78,60.76 132.57,60.68 132.36,60.68 132.31,60.72 132.27,60.73 132.14,60.76 132.01,60.73 132,60.72 131.78,60.72 131.78,60.73 131.6,60.73 131.39,60.93 131.39,61.73 131.39,61.74 131.39,61.92 131.16,62.15 130.36,62.15 130.36,62.58 130.42,62.65 131.75,62.65
+1.0V_VCCST_C on TOP (solid shape): 160.94,36.31 160.94,35.77 160.95,35.76 161.34,35.76 161.36,35.75 161.36,34.26 161.37,34.24 161.37,33.59 161.29,33.5 160.52,33.5 160.23,33.8 159.57,33.8 159.36,34.01 159.36,34.53 159.61,34.78 159.61,35.71 159.67,35.76 160.75,35.76 160.75,35.77 160.75,36.32 160.75,36.32 160.94,36.32
+1.0V_VCCSTG on TOP (solid shape): 156.87,37.83 156.87,37.29 156.87,37.29 157.34,37.29 157.45,37.17 157.45,36.37 158.06,35.76 159.4,35.76 159.43,35.73 159.43,35.04 158.89,34.49 158.89,34.05 158.84,34.01 158.26,34.01 157.84,34.42 157.01,34.42 156.76,34.18 156.76,33.9 156.62,33.77 155.27,33.77 155.03,34.01 155.03,34.93 155.41,35.31 155.41,35.97 155.03,36.35 155.03,37.14 155.2,37.3 155.78,37.3 155.81,37.33 155.81,37.83 155.81,37.84 156.07,37.84 156.07,37.83 156.07,37.3 156.08,37.29 156.61,37.29 156.61,37.29 156.61,37.84 156.61,37.84 156.86,37.84
+1.0V_VCCSTG on IN2 (solid shape): 156.98,37.63 156.98,36.7 156.8,36.52 155.3,36.52 155.04,36.78 155.04,37.52 155.06,37.65 155.04,37.79 155.04,37.84 155.36,38.16 156.45,38.16
+1.0V_VCCSTG on IN2 (solid shape): 133.08,61.47 133.07,61.39 133.07,61.35 133.23,61.06 133.56,61.05 133.63,61.11 133.69,61.18 133.89,61.18 133.99,61.06 134.14,61.01 134.21,61.01 134.77,61.01 135.15,60.63 135.56,60.63 135.84,60.35 136.86,60.35 136.95,60.26 136.95,59.78 136.85,59.69 134.86,59.69 134.33,60.23 134.35,60.26 134.27,60.68 133.84,60.67 133.78,60.65 133.72,60.67 133.53,60.75 133.33,60.71 133.27,60.66 133.22,60.6 133.14,60.56 133.06,60.6 132.81,60.75 132.53,60.65 132.5,60.65 132.4,60.75 132.4,61.01 132.53,61.14 132.53,61.2 132.56,61.33 132.54,61.45 132.54,61.49 132.61,61.56 132.99,61.56
+1.0VS_VCCIO on TOP (solid shape): 150.62,58.33 150.62,54.76 150.17,54.31 148.45,54.31 148.15,54.62 148.15,58.23 148.39,58.48 150.47,58.48
+1.0VS_VCCIO on TOP (solid shape): 156.51,50.41 156.51,49.17 156.27,48.93 156.27,47.38 155.94,47.05 154.9,47.05 154.67,47.28 154.67,48.83 154.87,49.03 154.87,50.37 155.08,50.58 156.35,50.58
+1.0VS_VCCIO on TOP (solid shape): 121.23,73.75 121.23,73.62 121.38,73.46 121.64,73.46 121.73,73.38 121.73,73.06 121.63,72.96 120.53,72.96 120.52,72.96 120.45,72.96 120.41,73 120.41,73.61 120.22,73.8 119.88,73.8 119.74,73.95 119.74,74.29 119.88,74.44 120.55,74.44
+1.0VS_VCCIO on TOP (solid shape): 120.21,68 120.44,68 120.96,67.48 121.19,67.48 121.35,67.41 121.51,67.43 121.52,67.43 121.95,67.43 122.08,67.31 122.08,66.86 122.04,66.82 122.04,66.31 121.9,66.16 121.54,66.16 121.3,65.93 119.77,65.93 119.45,66.24 119.45,67.32 119.71,67.58 119.71,67.9 119.81,68.01 120.21,68.01
+1.0VS_VCCIO on TOP (solid shape): 161.73,40.01 161.73,37.55 161.6,37.42 157.02,37.42 157.01,37.44 157.01,37.95 156.98,37.97 156.51,37.97 156.47,37.94 156.47,37.44 156.47,37.43 156.22,37.43 156.2,37.44 156.2,37.95 156.18,37.98 155.71,37.98 155.68,37.95 155.68,37.44 155.66,37.43 155.14,37.43 155.04,37.53 155.02,37.82 154.79,38 154.79,39.72 155.07,40 160.75,40 160.82,40.06 161.68,40.06
+1.0VS_VCCIO on BOTTOM (solid shape): 120.21,74.35 120.29,74.27 120.29,74.27 120.42,74.14 120.42,74.08 121.09,73.41 121.33,73.41 121.43,73.46 121.58,73.46 121.71,73.34 121.7,73.11 121.59,72.99 121.35,72.99 121.34,73 121.22,73.02 121.11,73 121.1,72.99 120.76,72.99 119.75,74 119.75,74.28 119.86,74.39 120.14,74.39
+1.0VS_VCCIO on BOTTOM (solid shape): 120.63,67.45 121.25,67.45 121.26,67.44 121.51,67.43 121.69,67.59 121.71,67.62 121.93,67.62 122.06,67.5 122.06,66.33 121.75,66.02 121.19,66.02 120.99,66.23 120.71,66.23 120.61,66.12 119.92,66.12 119.89,66.15 119.89,66.42 119.88,66.44 119.84,66.52 119.77,66.59 119.74,66.6 119.74,67.05 119.77,67.07 119.89,67.28 119.77,67.5 119.74,67.51 119.74,67.9 119.82,67.98 120.1,67.98
+1.0VS_VCCIO on IN1 (solid shape): 121.7,73.36 121.7,73.19 121.7,73.18 121.7,73.12 120.77,72.19 120.77,69 121.21,68.56 121.29,68.56 121.37,68.52 121.39,68.44 121.38,68.32 121.41,68.21 121.41,68.12 121.34,68.07 121.25,67.44 121.69,67.89 121.69,67.98 121.77,68.04 121.85,68.06 121.93,68.11 121.96,68.15 122.06,68.06 122.06,66.29 122.06,66.28 122.06,65.74 121.83,65.52 121.81,65.52 121.73,65.52 121.66,65.49 121.65,65.49 119.9,65.49 119.59,65.79 119.59,67.55 119.64,67.73 119.59,67.91 119.59,68.59 119.6,68.6 119.63,68.75 119.6,68.9 119.59,68.91 119.59,69.45 119.6,69.54 119.59,69.63 119.59,70.21 119.65,70.39 119.59,70.58 119.59,72.11 119.64,72.29 119.59,72.47 119.59,72.95 119.6,72.97 119.69,73.03 119.77,72.99 120.36,73.26 119.71,73.27 119.67,73.23 119.62,73.26 119.59,73.31 119.59,73.98 119.61,74.02 119.62,74.07 119.78,74.24 120.82,74.24
+1.0VS_VCCIO on IN1 (solid shape): outline of 490 points within 149.21,48.98 157.23,59.49
+1.0VS_VCCIO on IN2 (solid shape): outline of 226 points within 131.91,74.14 136.14,76.11
+1.0VS_VCCIO on IN2 (solid shape): outline of 2293 points within 120.35,53.87 151.09,74.15
+1.2V_DDR on TOP (solid shape): 92.68,75.41 82.68,75.41 82.68,90.41 92.68,90.41
+1.2V_DDR on TOP (solid shape): 92.71,53.96 84.71,53.96 84.71,61.96 92.71,61.96
+1.2V_DDR on TOP (solid shape): 95.49,98.94 87.49,98.94 87.49,106.94 95.49,106.94
+1.2V_DDR on TOP (solid shape): 57.69,68.47 57.69,67.64 58.42,67.64 58.54,67.52 58.54,66.66 58.48,66.59 57.67,66.59 57.6,66.67 57.6,67.19 57.3,67.48 57.3,67.74 57.24,67.81 57.11,68.01 56.88,68.09 56.78,68.18 56.78,68.46 56.88,68.56 57.6,68.56
+1.2V_DDR on TOP (solid shape): outline of 28001 points within 47,47.09 121,109.99
+1.2V_DDR on BOTTOM (solid shape): 46.85,33.36 46.85,32.36 46.53,32.04 45.75,32.04 45.75,32.56 45.05,32.56 45.05,32.04 44.55,32.04 44.55,32.56 43.85,32.56 43.85,32.04 43.12,32.04 43.01,32.15 43.01,33.16 42.66,33.51 42.66,34.15 42.93,34.43 45.78,34.43
+1.2V_DDR on BOTTOM (solid shape): outline of 164 points within 55.81,68.03 59.1,82.53
+1.2V_DDR on BOTTOM (solid shape): outline of 727 points within 67.29,67.29 84.13,82.78
+1.2V_DDR on VCC: 43.01,32.9 42.3,34.3 39.51,37.08 42.33,39.9 42.33,50.06 44.53,52.26 47.26,52.26 48.4,53.4 48.82,53.4 49.31,52.91 49.31,47.85 47.85,46.39 47.85,35.22 46.77,34.15 46.77,33.08 46.64,32.95
+1.2V_VCCSFR_OC on TOP (solid shape): 86.79,111.77 86.79,110.35 86.64,110.19 85.9,110.19 85.77,110.32 85.77,111.72 85.9,111.84 86.71,111.84
+1.2VP on TOP (solid shape): 35.23,33.37 35.23,32.53 35.3,32.47 36.19,32.47 36.19,30.87 36.15,30.84 36.15,29.97 36.09,29.91 36,29.91 35.94,29.96 35.94,30.63 35.51,31.06 35.51,31.77 35.32,31.96 34.69,31.96 34.69,33.37 34.73,33.41 35.2,33.41
+1.2VP on TOP (solid shape): 54.59,32.23 54.59,31.21 56.38,29.42 56.38,25.34 55.87,24.83 52.79,24.83 52.4,25.22 52.4,27.81 52.87,27.81 53.39,27.96 52.87,28.1 52.4,28.1 52.4,30.46 52.22,30.65 43.09,30.65 42.95,30.78 42.95,31.84 43.28,32.17 51.5,32.17 51.52,32.15 51.52,32.09 51.71,31.9 52.1,31.9 52.8,32.6 54.23,32.6
