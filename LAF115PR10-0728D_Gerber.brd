# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UL2  -  [SY6288C20AAC_SOT23-5]  19.29 86.66 90 top
UM1  THGBMBG8D4KBAIR_VFBGA153  [THGBMBG8D4KBAIRNHDI_VFBGA_153P]  87.61 34.79 270 top
UM2  -  [74AUP1G07GW_TSSOP5]  84.47 44.94 180 top
US1  -  [LNG2DMTR_LGA12_2X2]  181.78 31.29 90 top
US2  -  [SY6288D20AAC_SOT23-5]  181.54 37.81 0 top
UT1  S IC CYPD4125-40LQXIT QFN40 FOR INTEL FW  [CYPD4225-40LQXIT_QFN40_6X6]  39.44 125.55 180 bottom
UT2  TUSB546-DCIRNQR USB3.1 DP SW  [TUSB546_QFN40_4X6]  18.16 125.71 270 bottom
UT3  -  [TS3DS10224RUKR_WQFN20_3X3]  30.57 130.64 180 bottom
UT4  -  [RT9069-33GB_SOT23-5]  31.45 118.51 0 top
UT5  -  [PS8338BQFN60GTR-A1_QFN60_5X9]  42.74 110.12 270 top
UT6  -  [AP2330W-7_SC59-3]  37.98 129.3 270 bottom
UT7  -  [SY6861A1AAC_SOT23-5]  40.46 129.36 90 top
UU1  -  [SY6288D20AAC_SOT23-5]  19.02 52.57 0 bottom
UU2  -  [TPS2544RTER_WQFN16_3X3]  32.53 46.89 0 top
UU3  -  [SY6288D20AAC_SOT23-5]  203.64 32.68 270 top
UV1  216-0842024-A11-MAR_FCBGA631  [216-0842024-A11-MAR_FCBGA_631P]  134.54 122.6 90 bottom
UV2  MC74VHC1G08DFT2G_SC70-5  [SN74AHC1G08DCKR_SC70-5]  109.4 122.6 180 bottom
UV12  H5GC4H24AJR-R0C_BGA170  [H5GC4H24AJR-R0C_BGA_170P]  148.71 136.32 90 top
UV13  H5GC4H24AJR-R0C_BGA170  [H5GC4H24AJR-R0C_BGA_170P]  161.51 136.32 90 bottom
UV14  H5GC4H24AJR-R0C_BGA170  [H5GC4H24AJR-R0C_BGA_170P]  161.51 129.71 270 top
UV15  H5GC4H24AJR-R0C_BGA170  [H5GC4H24AJR-R0C_BGA_170P]  148.71 129.71 270 bottom
UW1  -  [SY6288C20AAC_SOT23-5]  71.13 137.79 90 top
UX1  -  [NPCT650VB2YX_QFN32_5X5]  107.59 29.47 0 bottom
UZ1  -  [TPS22967DSGR_SON8_2X2]  160.73 31.71 0 top
UZ2  -  [TPS22961DNYR_WSON8]  155.3 31.33 0 top
UZ3  -  [EM5209VF_DFN14_3X2]  37.9 59.23 270 top
UZ4  -  [TPS22967DSGR_SON8_2X2]  135.51 116.91 270 bottom
UZ5  -  [EM5209VF_DFN14_3X2]  127.14 112.3 270 bottom
UZ7  -  [TPS22967DSGR_SON8_2X2]  80.93 114.07 270 top
YC1  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  144.68 74.44 90 bottom
YC2  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  106.03 48.65 180 top
YC3  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  147.28 45.97 270 bottom
YE1  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  30.55 70.76 270 top
YL1  25MHZ_10PF_7V25000014  [Y_7V25000014_4P]  16.14 82.88 270 top
YV1  27MHZ_10PF_7V27000050  [Y_7V27000011_4P]  108.36 145.16 270 bottom
ZTB01  PAD  [TPC12]  210.69 46.54 0 top
ZTB02  PAD  [TPC12]  205.98 48.98 180 bottom

## Library data of the parts
C1-C3 C5-C12 C14-C19 C21 C23 C26 C27 C31-C37 C40 C41 C57 C59-C62 CA2 CA4 CA6 CA7 CA9 CA10 CA14 CA16 CA17 CA27-CA31 CA34-CA38 CA40-CA42 CC1-CC5 CC8 CC10-CC15 CC28-CC35 CC39-CC56 CC60-CC68 CC72 CC73 CC75 CC78 CC79 CC82 CC83 CC85-CC88 CC90 CC91 CC94-CC101 CD28 CD30 CD31 CD35 CD36 CD39-CD48 CD58 CD59 CE1-CE4 CE6-CE17 CE19-CE23 CE25 CE26 CE28 CE30-CE35 CI1-CI9 CL6 CL10-CL12 CL15 CL18-CL20 CL22-CL25 CM1-CM8 CS1-CS6 CS8-CS14 CS16-CS23 CS25-CS27 CS29 CT1 CT3 CT5-CT7 CT9-CT11 CT14 CT19-CT38 CT40-CT47 CT50 CT54-CT62 CT67 CT68 CT71-CT76 CT81-CT91 CU1-CU7 CU11 CU12 CU16 CU23 CV1 CV33 CV52 CV57 CV59 CV62 CV63 CV71-CV80 CV82 CV85-CV87 CV89 CV90 CV92-CV121 CV123-CV127 CV153 CV155 CV157 CV158 CV160-CV162 CV164-CV166 CV169 CV170 CV173-CV181 CV198 CV210 CV211 CV213 CV216 CV219 CV221 CV227 CV230 CV233 CV235 CV242 CV243 CV247 CV248 CV304-CV309 CV312 CV313 CV333-CV336 CV341-CV344 CV390 CV391 CV394 CV395 CW1-CW4 CW7-CW9 CX1-CX7 CZ1-CZ23 CZ25-CZ33 CZ36 CZ37 CZ40 CZ46 EC2301 EC2302 EC2901 EC2902 EC3001-EC3003 PC7 PC9-PC18 PC21-PC23 PC315 PC316 PC501 PC502 PC505-PC508 PC515-PC518 PC1805-PC1810 PC2503-PC2505 PCA03 PCA04 PCA05 PCA06 PCB01 PCB02 PCB18-PCB24 PCB26 PCB28 PCB29 PCB33-PCB35 PCB38-PCB47 PCG05 PCG06 PCG07 PCG08 PCG10 PCG11 PCH01 PCH02 PCH09-PCH12 PCH14-PCH17 PCI05 PCI06 PCI07 PCI08 PCI10 PCI11 PCI21 PCI22 PCI27 PCI28 PCI30 PCI31 PCM01 PCM02 PCM11 PCM12 PCM15-PCM19 PCM22-PCM24 PCS01 PCS02 PCS03 PCS04 PCS05 PCS06 PCS07 PCS08 PCS10-PCS14 PCS16 PCS17 PCS19 PCS20 PCV04 PCV05 PCV06 PCV07 PCV08 PCV10 PCV16-PCV23 PCV25-PCV29 PCV31 PCV33 PCV34 PCW01 PCW02 PCW09-PCW12 PCW14-PCW17 PCZ01 PCZ02 PCZ03 PCZ04 PCZ05 PCZ06 PCZ07 PCZ08 PCZ09-PCZ33 PCZ35 PCZ36 = C_0402
C4 C22 CA1 CA3 CA5 CA11-CA13 CA15 CA20-CA22 CA26 CA33 CC36-CC38 CC76 CC77 CC80 CC81 CC84 CD19-CD26 CD32-CD34 CD37 CD38 CD49-CD56 CE5 CE24 CS35 CS36 CT2 CT4 CT8 CT15 CT17 CT39 CT53 CT92 CV68 CV70 CV81 CV84 CV88 CV91 CV122 CV225 CV238 CW5 CW6 PC5 PC6 PC8 PC509 PC1801-PC1804 PCA07 PCA08 PCA09 PCA101-PCA109 PCB25 PCB27 PCB30 PCB36 PCB37 PCC01 PCC02 PCC03 PCC04 PCG09 PCG12 PCG101-PCG133 PCH05 PCH06 PCH07 PCH08 PCH13 PCI09 PCI12 PCI29 PCI32 PCI101-PCI128 PCM05 PCM06 PCM07 PCM08 PCM09 PCM10 PCM13 PCM14 PCM20 PCM21 PCS09 PCS15 PCS21 PCV09 PCV11 PCV12 PCV24 PCV30 PCV32 PCW05 PCW06 PCW07 PCW08 PCW13 PCZ34 = C_0603
C30 CC59 CC74 CS7 CS15 CS24 CS30 CS33 CS34 CT93 CU8 CU9 CU13 CU14 CU17 PC312-PC314 PC503 PC504 PC510-PC514 PC519 PC2501 PC2502 PCA01 PCA02 PCB03 PCB04 PCB05 PCB06 PCB10-PCB17 PCB31 PCB32 PCG01 PCG02 PCG03 PCG04 PCH03 PCH04 PCI01 PCI02 PCI03 PCI04 PCI23-PCI26 PCM03 PCM04 PCV01 PCV02 PCV03 PCV13-PCV15 PCV35 PCV36 PCW03 PCW04 = C_0805
C39 C42 C43 C46-C56 CA43-CA50 CC6 CC7 CC69-CC71 CE36-CE39 CM9 CM10 CS32 CT77-CT80 CU19-CU22 PCA110-PCA116 PCG134-PCG146 PCI129-PCI163 = C_0201
CA23 = C_0402: room: AUDIO
CA24 CA25 CA32 = C_0603: room: AUDIO
CC9 CC26 CC27 CC57 CC58 = C_0402: room: CPU
CC17 CC18 = C_0201: room: CPU
CD1 CD2 CD6-CD8 = C_0603: room: DDR4
CD3-CD5 CD9-CD18 CD29 = C_0402: room: DDR4
CD27 PCG171 PCG172 PCI171-PCI173 PCV171 PCV172 = C_D2
CL1-CL5 CL7-CL9 = C_0402: room: LAN
CL13 CU10 CU15 = C_1206
CV2-CV8 CV11 CV15 CV17 CV18 CV20 CV21 CV26 CV28 CV29 CV34 CV35 CV39-CV42 CV46-CV51 CV53 CV56 CV58 CV60 CV64-CV66 = C_0402: room: GPU
CV19 CV27 CV30 CV38 CV43-CV45 CV54 CV55 CV61 CV67 CV69 = C_0603: room: GPU
D1 = BAS40C_SOT23-3
D3 D4 DA3 = BAT54C-7-F_SOT23-3
D5 D6 DE2 DT1 DT2 = RB551V-30_SOD323-2
D7 DC2 DW1 DW2 = RB520SM-30T2R_EMD2-2
DA1 DA2 DA4 DA7 ED2901 = L03ESDL5V0CC3-2_SOT23-3
DA5 = AZ5123-02SPR7G_SOT23-3
DA6 EU2602 EU2604 EU2701 EU4012 = AZC199-02SPR7G_SOT23-3
DE1 = AZ5125-01HPR7G_SOD523-2
DI1 = BAW56W_SOT323-3
DT3-DT10 = ESD101-B1-02ELS_TSSLP-2-4-2
DZ1-DZ5 = RB751S40T1G_SOD523-2
EU2601 EU2603 EU3101 EU4001 EU4002 = L05ESDL5V0NA-4_SLP2510P8-10-9
EU4011 = L30ESD24VC3-2_SOT23-3
F1 = F_SMD1812P150TF-24
F2 = F_SMD1812P110TF-24
F3 = F_MF-NSMF050-2
FD1-FD4 = FIDUCIAL_C40M80: room: ETY-ROOM
FI1 = F_1206L150PR
H1 H4 H7 = H_3P0: room: SCREW
H3 = H_5P0: room: SCREW
H5 H6 = H_3P0-G: room: SCREW
H8 = H_3P3-G
H9 H10 = H_3P5
H11 = H_3P2
H12 = H_3P2-G
H13 = H_3P0X4P0
H14 = H_5P6N
HCPU1 = H_4P0X3P7
HCPU2 = H_3P7
HCPU3 = H_4P0
HCPU4 = H_3P7X4P0
JCCG4 = DC021611210
JCMOS1 = SHORTPADS: User Part Number: PART#
JDEG1 JESPI1 = JXT_FP241AH-010GAAM_10P
JDIMM1 = LOTES_ADDR0206-P001A02_260P: room: DDR4
JDIMM2 = LOTES_ADDR0205-P001A02_260P: room: DDR4
JEDP1 = ACES_51540-04001-P01_40P
JFAN1 JSPK1 = ACES_50224-00401-001_4P
JFP = ACES_51522-00601-001_6P
JFP1 = ACES_51522-00801-001_8P
JHDD = ACES_50406-02071-001_20P
JHDD1 = ACES_51625-01201-001_12P
JHDMI1 = ACON_HMRF6-AK120C_19P-T
JHP1 = YUQIU_PJ753-F07J1BE-B_7P-T
JIOB1 = ACES_51524-0160N-001_16P
JKB1 = HEFEN_AFB02-S30F1A-HF_30P-T
JKBBL1 = ACES_51575-00401-001_4P
JLAN1 = SINGA_2RJ3076-078211F_8P-T
JODD1 = ACES_50673-0120N-P01_12P
JP1 = JUMP_43X79: room: USB
JP2 JP11 JP14 PJP301 PJP1801 PJP2501 PJP2502 PJPA01 PJPH01 PJPM01 PJPM03 PJPW01 = JUMP_43X39
JP5-JP10 JP13 PJP2 PJP501-PJP503 PJP1802 = JUMP_43X79
JPWR1 = JXT_FP226H-004S1AM_4P
JPWR2 = JXT_FP226H-006S1BM_6P
JSSD1 = LCN_DAN05-67306-0103_75P
JTP1 = ACES_51524-0080N-001_8P
JUSB1 JUSB2 = ACON_TARAN-9R1391_9P
JUSBC1 = JAE_DX07S024JJ2R1300_24P
JVGA = ACES_51625-01601-001_16P-T
JWLAN1 = LCN_DAN05-67306-0100_75P
JWWAN = ACES_51540-03041-P01_30P-T
L1 L2 = MURAT_BLM15BD601SN1D_2P
L3 LT2 LU1 LU4 LU8 LU9 = INPAQ_MCM1012B900F06BP_4P
L4 LT3 LT4 = INPAQ_MCM1012B900F06BP_4P-NPM
L5 = MURAT_BLM15PX221SN1D_2P
L6 LV6 = MURAT_BLM15BB221SN1D_2P
LED1 = LED_LTW-295DSKS-5A_4P
LI1-LI4 LU2 LU3 LU5 LU6 = INPAQ_HCM1012GH900BP_4P-NPM
LT1 = MURAT_BLM15PX600SN1D_2P
LV2 LV4 LV7 LV8 PHV01 PHV02 PHZ01 PHZ02 PHZ03 PHZ04 PHZ05 PR1 PR2 PR7-PR17 PR21 PR22 PR31 PR33-PR52 PR60-PR66 PR100 PR302-PR304 PR306-PR308 PR504 PR506 PR508-PR511 PR1801-PR1803 PR1805-PR1807 PR1890 PR2502-PR2504 PRB02 PRB03 PRB05 PRB07 PRB09 PRB11 PRB13 PRB19 PRB20 PRB23-PRB27 PRB30 PRB32 PRB33 PRB36-PRB44 PRG02 PRH01 PRH02 PRH04 PRH05 PRH08 PRH09 PRH11-PRH13 PRH90 PRI02 PRI22 PRM03 PRM06 PRM07 PRM10 PRM11 PRS01 PRS02 PRS03 PRS04 PRS05 PRS06 PRS07 PRS08 PRS09-PRS16 PRS18 PRS23 PRS25-PRS30 PRS32-PRS45 PRV02 PRV03 PRV04 PRV05 PRV08 PRV09 PRV10 PRV12 PRV14 PRV16-PRV19 PRV22 PRV25-PRV33 PRV35 PRW02 PRW03 PRW04 PRW05 PRW09-PRW11 PRW13 PRZ01 PRZ04 PRZ05 PRZ06 PRZ08 PRZ10 PRZ11 PRZ15 PRZ16 PRZ19-PRZ21 PRZ23 PRZ24 PRZ26-PRZ28 PRZ30-PRZ33 PRZ35-PRZ43 PRZ45 PRZ46 PRZ48-PRZ52 PRZ55-PRZ58 PRZ60 PRZ61 PRZ64-PRZ69 R1 R2 R5 R6 R9 R10 R19-R35 R38-R43 R45-R50 R53 R57 R65-R73 R77-R84 R86 R87 RA3 RA7-RA9 RA11 RA23-RA28 RA31-RA34 RA41-RA43 RC1-RC3 RC8 RC10 RC11 RC15 RC24 RC26 RC28 RC29 RC31-RC42 RC49 RC51 RC55 RC62-RC67 RC71 RC77 RC82 RC86 RC87 RC89 RC93 RC94 RC102-RC105 RC108-RC134 RC136-RC148 RC150-RC157 RC159 RC160 RC163 RC164 RC175-RC182 RC188 RC194 RC199-RC203 RC205-RC209 RC211-RC214 RC223-RC227 RC442 RD7 RD9-RD13 RD15 RD17 RD19-RD24 RE1 RE3 RE4 RE6 RE8-RE21 RE23 RE25 RE29-RE32 RE41 RE43 RE45-RE49 RE51-RE59 RE62 RE65 RE67 RE68 RE70 RE71 RE81 RE85 RE88-RE91 RE539-RE541 RH1 RI1-RI16 RL2 RL3 RL6 RL7 RL9 RL17 RL21 RM3 RM12-RM25 RM27 RS1-RS7 RT1-RT6 RT8 RT11-RT32 RT39 RT40 RT52-RT59 RT62-RT84 RT93 RT94 RT97-RT101 RT112-RT121 RU3-RU6 RU9-RU12 RU21-RU26 RV1-RV3 RV8 RV11 RV13 RV15-RV17 RV28 RV29 RV32-RV39 RV53-RV55 RV59 RV79 RV85-RV89 RV116-RV121 RV123 RV131-RV135 RV151-RV159 RV162 RV163 RV260 RV368-RV370 RW6 RW11-RW15 RX1-RX10 RZ1-RZ3 RZ6-RZ8 RZ16 RZ21 = R_0402
LV3 RV4-RV6 RV9 RV12 RV20 RV21 RV40 RV41 RV48-RV52 RV81-RV84 = R_0402: room: GPU
PBATT1 = ACES_50458-01001-P01_10P-T
PC1-PC4 = C_0402: room: DCIN
PC301 = C_0402: room: ETY-ROOM
PC302 PC305-PC308 = C_0402: room: 3_5V
PC303 PC304 = C_0805: room: 3_5V
PC309 = C_0603: room: 3_5V
PC310 PC311 = C_0805: room: ETY-ROOM
PCB07 PCG13 PCI13 = C_EEFCX1E330R
PCB08 PCI14 = C_6P3X4P5-NPM
PD1 PD5 PD6 = TVNST52302AB0_SOT523-3
PD2 PD3 = BAV99W_SC70-3
PD4 PDS02 = PDS5100H-13_POWERDI5-3
PD10 PD11 PDS03 = LRB715FT1G_SOT323-3
PD12 = DFLS160-7_POWERDI123-2
PD501 PDB01 PDB02 PDB03 PDB05 PDS04 PDS05 PDS06 = SDMK0340L-7-F_SOD323-2
PDB04 PDS01 = BAT54CW_SOT323-3
PJP1 PJP3 PJPG01 PJPI01 PJPV01 = JUMP_43X79-NPM
PJP302 PJPH02 PJPM02 PJPW02 = JUMP_43X118
PJPB01 = JUMP_43X118-NPM
PJPDC1 = ACES_50458-00601-001_6P-T
PL1 = 5A_Z150_1210_2P: room: DCIN
PL2 = 5A_Z150_1210_2P-NPM: room: DCIN
PL3 = MURAT_BLM15AG102SN1D_2P
PL4 = 5A_Z150_1210_2P: room: BATT
PL301 PL501 PLH01 PLM01 = L_7X7X3_M_2P
PL311 PLH11 PLM11 PLW11 = TAI-T_HCB2012KF-121T50_2P-NPM
PL511 = 5A_Z150_1210_2P-NPM
PL1801 PLW01 = L_5X5X3_M_2P
PL1811 PLS11 PLS12 = TAI-T_HCB2012KF-121T50_2P
PLA01 = L_5X5X3_M
PLB01 = CYNTE_PCMB104T-1R0MH_2P
PLB11 PLG11 PLI11 PLV11 = 5A_Z150_1210_2P
PLG01 PLI01 PLI02 PLV01 PLV02 = L_7X7X4_M
PQ1 = FDV301N-G_SOT23-3
PQ2 = MMST3904-7-F_SOT323-3
PQ3 PQ4 PQB03 PQS01 PQS02 = AON7409_DFN8-5
PQ5 PQ6 PQ11 PQ15-PQ18 PQ20 PQB04 PQS04 PQS07 PQS08 PQS11 PQS12 PQS14 QI3 = DMN65D8LW-7_SOT323-3
PQ12 PQ13 PQS03 PQS05 PQS10 PQS30 = DMN65D8LDW-7_SOT363-6
PQ19 PQS06 PQS13 = AO3409_SOT23-3
PQA01 PQM01 = AON7934_DFN3X3A8-10
PQB01 PQB02 PQV01 PQV02 PQV03 PQV04 = AON6994_DFN5X6D-8-7
PR3 PR5 PR6 = R_0402: room: BATT
PR4 = R_0402: room: ETY-ROOM
PR32 PR305 PR505 PR1804 PRA02 PRB17 PRB18 PRG03 PRH07 PRI03 PRI23 PRM01 PRV06 PRV23 PRW07 RT33 = R_1206
PR301 PR501 PRV01 PRV21 RA4 RA39 RC169-RC171 RC173 RC174 RE7 RE50 RE66 = R0603_0OHM
PR502 PR503 PR507 PR2501 PRB10 PRB14 PRB16 PRB21 PRB22 PRB28 PRB29 PRB31 PRB34 PRB35 PRH03 PRM08 PRM09 PRV15 PRV20 PRV34 PRV36 PRW01 PRZ03 PRZ07 PRZ14 PRZ18 PRZ22 PRZ34 PRZ47 PRZ53 PRZ59 PRZ63 R8 RA2 RA5 RA6 RA17 RA18 RA36 RA37 RA40 RC97 RC99 RC106 RC107 RD8 RD14 RD16 RD18 RE28 RE37 RE42 RE60 RE61 RE63 RL13 RW9 RW10 = R0402_0OHM
PRA01 PRB04 PRB06 PRB15 PRG01 PRH06 PRI01 PRI21 PRM02 PRM04 PRM05 PRV07 PRV13 PRV24 PRW06 PRZ13 PRZ25 PRZ29 PRZ44 R4 R7 R11-R13 R16 R36 R37 R85 RC149 RC161 RC162 RE2 RE72 RL14 RL15 RL19 RL20 RM1 RM2 RV27 RV30 RV31 RV364 RZ4 = R_0603
PRB01 PRB12 = R_1206_4P-D
PRB08 PRC01 PRC02 PRC03 R3 RW3 RW5 RZ9 RZ10 = R_0805
PRC04 PRC05 PRC06 = SOLDER_PREFORMS_0603-NPM
PU1 UT4 = RT9069-33GB_SOT23-5
PU2 PUS02 U4 UC4 UC5 UC9 UV2 = SN74AHC1G08DCKR_SC70-5
PU301 = SY8286BRAC_QFN20_3X3
PU501 = SY8288CRAC_QFN20_3X3
PU1801 = RT8061AZQW_WDFN10_3X3
PU2501 = RT9059GSP_SO8
PUA01 = NCP81253MNTBG_DFN8_2X2
PUB01 = ISL9538HRTZ-T_TQFN32_4X4
PUB02 = TC7SH08FU_SSOP5
PUG01 PUI01 PUI02 = NCP302045MNTXG_PQFN33_5X5
PUH01 = RT6228AGQUF_UQFN12_3X3
PUM01 = RT8207PGQW_WQFN20_3X3
PUS01 = LM393DGKR_VSSOP8
PUS03 = TC7SH32FU_SSOP5
PUS04 = AP2204R-5P0TRG1_SOT89-3
PUV01 = ISL62771HRTZ-T_TQFN40_5X5
PUW01 = RT6226AGQUF_UQFN12_3X3
PUZ01 = NCP81218MNTXG_QFN48_6X6
Q1 Q12 Q13 QC2 QI1 QT3 = 2N7002K_SOT23-3
Q4 Q24 = L2N7002WT1G_SC-70-3
Q6 Q8 Q9 Q21 Q22 QA1 QT4 QT5 = LN2306LT1G_SOT23-3
Q7 Q18-Q20 = DDTA144VCA-7-F_SOT23-3
Q10 Q11 Q17 Q25 QC1 QI2 QS1 = DMN66D0LDW-7_SOT363-6
Q14 = LMBT3904LT1G_SOT23-3
Q15 = SI2301CDS-T1-GE3_SOT23-3
Q23 = LP2301ALT1G_SOT23-3
QV1 = 2N7002KDWH_SOT363-6
R17 R18 RT41 RT42 RU1 RU2 RU7 RU8 RU13-RU16 = R_0402-NPM
RA1 RA22 = R0805_0OHM
RA10 RA12 RA29 RA30 = R_0402: room: AUDIO
RA13 RA14 = MURAT_BLM15PD600SN1D_2P: room: AUDIO
RA15 RA16 = MURAT_BLM15PD600SN1D_2P
RA35 RA38 = MURAT_BLM15PX330SN1D_2P
RC4-RC7 RC9 RC12 RC14 RC18-RC23 RC25 RC27 RC30 RC44-RC48 RC50 RC52-RC54 RC56-RC61 RC68 RC69 RC72-RC76 RC78 RC80 RC90-RC92 RC95 RC96 = R_0402: room: CPU
RC17 = R0603_0OHM: room: CPU
RC88 = R_0402: room: RTC
RD1-RD3 = R_0402: room: DDR4
RD4-RD6 = R0402_0OHM: room: DDR4
RE84 RT102-RT111 = R_0201
RL1 = R_0603: room: LAN
RL4 RL8 = R_0402: room: LAN
RL5 = R0603_0OHM: room: LAN
RP1 RP2 RP34 RPC1 RPC2 RPE1-RPE7 RPI1 RPI2 RPM1 RPM2 = RP_0804_8P4R
SW1 SW2 = SW_TST71-N-220-T170-S017_2P
SW3 = SW_MSS3N-Q-T-R_3P
T45 T47 TP1-TP33 TP38-TP44 TP46 TP50-TP70 TP72-TP74 TP76 TP77 TP79 TP84-TP90 TPC1-TPC33 TPS1-TPS6 TPS8-TPS11 ZTB01 ZTB02 = TPC12
TL1 TL2 = BOTH_NS0013LF_16P
U1 U3 UL2 UW1 = SY6288C20AAC_SOT23-5
U2 = NCT7718W_MSOP8
UA1 = ALC3246-CG_MQFN48_6X6: room: AUDIO
UC1 = SKL-U_BGA_1356P-T: room: CPU
UC2 = 74AUP1G07GW_TSSOP5: room: CPU
UC3 = W25Q128FVSIQ_SO8
UC6 UC7 UM2 = 74AUP1G07GW_TSSOP5
UE1 = MEC1416-NU-D0_VTQFP128_14X14
UE2 = NL17SZ06DFT2G_SC70-5
UL1 = RTL8106E-CG_QFN32_4X4: room: LAN
UM1 = THGBMBG8D4KBAIRNHDI_VFBGA_153P
US1 = LNG2DMTR_LGA12_2X2
US2 UU1 UU3 = SY6288D20AAC_SOT23-5
UT1 = CYPD4225-40LQXIT_QFN40_6X6
UT2 = TUSB546_QFN40_4X6
UT3 = TS3DS10224RUKR_WQFN20_3X3
UT5 = PS8338BQFN60GTR-A1_QFN60_5X9
UT6 = AP2330W-7_SC59-3
UT7 = SY6861A1AAC_SOT23-5
UU2 = TPS2544RTER_WQFN16_3X3
UV1 = 216-0842024-A11-MAR_FCBGA_631P: room: GPU
UV12-UV15 = H5GC4H24AJR-R0C_BGA_170P
UX1 = NPCT650VB2YX_QFN32_5X5
UZ1 UZ4 UZ7 = TPS22967DSGR_SON8_2X2
UZ2 = TPS22961DNYR_WSON8
UZ3 UZ5 = EM5209VF_DFN14_3X2
YC1 = Y_X3G024000DC1H_4P: room: CPU
YC2 = Y_X1A000141000200_2P: room: CPU
YC3 = Y_X3G024000DC1H_4P
YE1 = Y_X1A000141000200_2P
YL1 = Y_7V25000014_4P: room: LAN
YV1 = Y_7V27000011_4P: room: GPU

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002K_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002KDWH_SOT363-6
  oval 0.356x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
5A_Z150_1210_2P
  rect 0.991x2.997 smd: 1(0,0) 2(2.7,0)
5A_Z150_1210_2P-NPM
  rect 0.991x2.997 smd: 1(0,0) 2(2.7,0)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
216-0842024-A11-MAR_FCBGA_631P
  round 0.406 smd: A3(0.8,0) A30(20.8,0) A32(21.6,0) AB7(3.2,-15) AB8(4,-15) AB9(4.8,-15) AB10(5.6,-15) AB23(16,-15) AB24(16.8,-15) AB25(17.6,-15) AB26(18.4,-15) AC11(6.6,-16) AC13(7.8,-16) AC14(9,-16) AC16(10.2,-16) AC17(11.4,-16) AC19(12.6,-16) AC20(13.8,-16) AC22(15,-16) AD11(6.6,-16.8) AD13(7.8,-16.8) AD14(9,-16.8) AD16(10.2,-16.8) AD17(11.4,-16.8) AD19(12.6,-16.8) AD20(13.8,-16.8) AD22(15,-16.8) AE11(6.6,-17.6) AE13(7.8,-17.6) AE14(9,-17.6) AE16(10.2,-17.6) AE17(11.4,-17.6) AE19(12.6,-17.6) AE20(13.8,-17.6) AE22(15,-17.6) AF11(6.6,-18.4) AF13(7.8,-18.4) AF14(9,-18.4) AF16(10.2,-18.4) AF17(11.4,-18.4) AF19(12.6,-18.4) AF20(13.8,-18.4) AF22(15,-18.4) AK1(0,-20.8) AK3(0.8,-20.8) AK30(20.8,-20.8) AK32(21.6,-20.8) AM1(0,-21.6) AM3(0.8,-21.6) AM30(20.8,-21.6) AM32(21.6,-21.6) C1(0,-0.8) C3(0.8,-0.8) C30(20.8,-0.8) C32(21.6,-0.8) G11(6.6,-3.2) G13(7.8,-3.2) G14(9,-3.2) G16(10.2,-3.2) G17(11.4,-3.2) G19(12.6,-3.2) G20(13.8,-3.2) G22(15,-3.2) H11(6.6,-4) H13(7.8,-4) H14(9,-4) H16(10.2,-4) H17(11.4,-4) H19(12.6,-4) H20(13.8,-4) H22(15,-4) J11(6.6,-4.8) J13(7.8,-4.8) J14(9,-4.8) J16(10.2,-4.8) J17(11.4,-4.8) J19(12.6,-4.8) J20(13.8,-4.8) J22(15,-4.8) K11(6.6,-5.6) K13(7.8,-5.6) K14(9,-5.6) K16(10.2,-5.6) K17(11.4,-5.6) K19(12.6,-5.6) K20(13.8,-5.6) K22(15,-5.6) L7(3.2,-6.6) L8(4,-6.6) L9(4.8,-6.6) L10(5.6,-6.6) L23(16,-6.6) L24(16.8,-6.6) L25(17.6,-6.6) L26(18.4,-6.6) N7(3.2,-7.8) N8(4,-7.8) N9(4.8,-7.8) N10(5.6,-7.8) N23(16,-7.8) N24(16.8,-7.8) N25(17.6,-7.8) N26(18.4,-7.8) P7(3.2,-9) P8(4,-9) P9(4.8,-9) P10(5.6,-9) P23(16,-9) P24(16.8,-9) P25(17.6,-9) P26(18.4,-9) T7(3.2,-10.2) T8(4,-10.2) T9(4.8,-10.2) T10(5.6,-10.2) T23(16,-10.2) T24(16.8,-10.2) T25(17.6,-10.2) T26(18.4,-10.2) U7(3.2,-11.4) U8(4,-11.4) U9(4.8,-11.4) U10(5.6,-11.4) U23(16,-11.4) U24(16.8,-11.4) U25(17.6,-11.4) U26(18.4,-11.4) W7(3.2,-12.6) W8(4,-12.6) W9(4.8,-12.6) W10(5.6,-12.6) W23(16,-12.6) W24(16.8,-12.6) W25(17.6,-12.6) W26(18.4,-12.6) Y7(3.2,-13.8) Y8(4,-13.8) Y9(4.8,-13.8) Y10(5.6,-13.8) Y23(16,-13.8) Y24(16.8,-13.8) Y25(17.6,-13.8) Y26(18.4,-13.8)
  round 0.305 smd: A5(1.6,0) A7(3.2,0) A9(4.8,0) A11(6.4,0) A13(8,0) A15(9.6,0) A17(11.2,0) A19(12.8,0) A21(14.4,0) A23(16,0) A25(17.6,0) A27(19.2,0) A28(20,0) AA1(0,-14.4) AA3(0.8,-14.4) AA5(1.6,-14.4) AA6(2.4,-14.4) AA27(19.2,-14.4) AA29(20.4,-14.4) AA31(21.2,-14.4) AB2(0.4,-15.2) AB4(1.2,-15.2) AB6(2.4,-15.2) AB27(19.2,-15.2) AB28(20,-15.2) AB30(20.8,-15.2) AB32(21.6,-15.2) AC1(0,-16) AC3(0.8,-16) AC5(1.6,-16) AC6(2.4,-16) AC7(3.2,-16) AC8(4,-16) AC9(4.8,-16) AC10(5.6,-16) AC23(16,-16) AC24(16.8,-16) AC25(17.6,-16) AC26(18.4,-16) AC27(19.2,-16) AC29(20.4,-16) AC31(21.2,-16) AD2(0.4,-16.8) AD4(1.2,-16.8) AD6(2.4,-16.8) AD7(3.2,-16.8) AD8(4,-16.8) AD9(4.8,-16.8) AD10(5.6,-16.8) AD23(16,-16.8) AD24(16.8,-16.8) AD25(17.6,-16.8) AD26(18.4,-16.8) AD27(19.2,-16.8) AD28(20,-16.8) AD30(20.8,-16.8) AD32(21.6,-16.8) AE1(0,-17.6) AE3(0.8,-17.6) AE5(1.6,-17.6) AE6(2.4,-17.6) AE7(3.2,-17.6) AE8(4,-17.6) AE9(4.8,-17.6) AE10(5.6,-17.6) AE23(16,-17.6) AE24(16.8,-17.6) AE25(17.6,-17.6) AE26(18.4,-17.6) AE27(19.2,-17.6) AE29(20.4,-17.6) AE31(21.2,-17.6) AF2(0.4,-18.4) AF4(1.2,-18.4) AF6(2.4,-18.4) AF7(3.2,-18.4) AF8(4,-18.4) AF9(4.8,-18.4) AF10(5.6,-18.4) AF23(16,-18.4) AF24(16.8,-18.4) AF25(17.6,-18.4) AF26(18.4,-18.4) AF27(19.2,-18.4) AF28(20,-18.4) AF30(20.8,-18.4) AF32(21.6,-18.4) AG1(0,-19.2) AG3(0.8,-19.2) AG5(1.6,-19.2) AG6(2.4,-19.2) AG7(3.2,-19.2) AG8(4,-19.2) AG9(4.8,-19.2) AG10(5.6,-19.2) AG11(6.4,-19.2) AG12(7.2,-19.2) AG13(8,-19.2) AG14(8.8,-19.2) AG15(9.6,-19.2) AG16(10.4,-19.2) AG17(11.2,-19.2) AG18(12,-19.2) AG19(12.8,-19.2) AG20(13.6,-19.2) AG21(14.4,-19.2) AG22(15.2,-19.2) AG23(16,-19.2) AG24(16.8,-19.2) AG25(17.6,-19.2) AG26(18.4,-19.2) AG27(19.2,-19.2) AG29(20.4,-19.2) AG31(21.2,-19.2) AH1(0,-20) AH3(0.8,-20) AH5(1.6,-20) AH6(2.4,-20) AH8(4,-20) AH10(5.6,-20) AH12(7.2,-20) AH14(8.8,-20) AH16(10.4,-20) AH18(12,-20) AH20(13.6,-20) AH22(15.2,-20) AH24(16.8,-20) AH26(18.4,-20) AH28(20,-20) AH30(20.8,-20) AH32(21.6,-20) AJ7(3.2,-20.4) AJ9(4.8,-20.4) AJ11(6.4,-20.4) AJ13(8,-20.4) AJ15(9.6,-20.4) AJ17(11.2,-20.4) AJ19(12.8,-20.4) AJ21(14.4,-20.4) AJ23(16,-20.4) AJ25(17.6,-20.4) AJ27(19.2,-20.4) AK5(1.6,-20.8) AK6(2.4,-20.8) AK8(4,-20.8) AK10(5.6,-20.8) AK12(7.2,-20.8) AK14(8.8,-20.8) AK16(10.4,-20.8) AK18(12,-20.8) AK20(13.6,-20.8) AK22(15.2,-20.8) AK24(16.8,-20.8) AK26(18.4,-20.8) AK28(20,-20.8) AL7(3.2,-21.2) AL9(4.8,-21.2) AL11(6.4,-21.2) AL13(8,-21.2) AL15(9.6,-21.2) AL17(11.2,-21.2) AL19(12.8,-21.2) AL21(14.4,-21.2) AL23(16,-21.2) AL25(17.6,-21.2) AL27(19.2,-21.2) AM5(1.6,-21.6) AM6(2.4,-21.6) AM8(4,-21.6) AM10(5.6,-21.6) AM12(7.2,-21.6) AM14(8.8,-21.6) AM16(10.4,-21.6) AM18(12,-21.6) AM20(13.6,-21.6) AM22(15.2,-21.6) AM24(16.8,-21.6) AM26(18.4,-21.6) AM28(20,-21.6) B6(2.4,-0.4) B8(4,-0.4) B10(5.6,-0.4) B12(7.2,-0.4) B14(8.8,-0.4) B16(10.4,-0.4) B18(12,-0.4) B20(13.6,-0.4) B22(15.2,-0.4) B24(16.8,-0.4) B26(18.4,-0.4) C5(1.6,-0.8) C7(3.2,-0.8) C9(4.8,-0.8) C11(6.4,-0.8) C13(8,-0.8) C15(9.6,-0.8) C17(11.2,-0.8) C19(12.8,-0.8) C21(14.4,-0.8) C23(16,-0.8) C25(17.6,-0.8) C27(19.2,-0.8) C28(20,-0.8) D6(2.4,-1.2) D8(4,-1.2) D10(5.6,-1.2) D12(7.2,-1.2) D14(8.8,-1.2) D16(10.4,-1.2) D18(12,-1.2) D20(13.6,-1.2) D22(15.2,-1.2) D24(16.8,-1.2) D26(18.4,-1.2) E1(0,-1.6) E3(0.8,-1.6) E5(1.6,-1.6) E7(3.2,-1.6) E9(4.8,-1.6) E11(6.4,-1.6) E13(8,-1.6) E15(9.6,-1.6) E17(11.2,-1.6) E19(12.8,-1.6) E21(14.4,-1.6) E23(16,-1.6) E25(17.6,-1.6) E27(19.2,-1.6) E28(20,-1.6) E30(20.8,-1.6) E32(21.6,-1.6) F2(0.4,-2.4) F4(1.2,-2.4) F6(2.4,-2.4) F7(3.2,-2.4) F8(4,-2.4) F9(4.8,-2.4) F10(5.6,-2.4) F11(6.4,-2.4) F12(7.2,-2.4) F13(8,-2.4) F14(8.8,-2.4) F15(9.6,-2.4) F16(10.4,-2.4) F17(11.2,-2.4) F18(12,-2.4) F19(12.8,-2.4) F20(13.6,-2.4) F21(14.4,-2.4) F22(15.2,-2.4) F23(16,-2.4) F24(16.8,-2.4) F25(17.6,-2.4) F26(18.4,-2.4) F27(19.2,-2.4) F28(20,-2.4) F30(20.8,-2.4) F32(21.6,-2.4) G1(0,-3.2) G3(0.8,-3.2) G5(1.6,-3.2) G6(2.4,-3.2) G7(3.2,-3.2) G8(4,-3.2) G9(4.8,-3.2) G10(5.6,-3.2) G23(16,-3.2) G24(16.8,-3.2) G25(17.6,-3.2) G26(18.4,-3.2) G27(19.2,-3.2) G29(20.4,-3.2) G31(21.2,-3.2) H2(0.4,-4) H4(1.2,-4) H6(2.4,-4) H7(3.2,-4) H8(4,-4) H9(4.8,-4) H10(5.6,-4) H23(16,-4) H24(16.8,-4) H25(17.6,-4) H26(18.4,-4) H27(19.2,-4) H28(20,-4) H30(20.8,-4) H32(21.6,-4) J1(0,-4.8) J3(0.8,-4.8) J5(1.6,-4.8) J6(2.4,-4.8) J7(3.2,-4.8) J8(4,-4.8) J9(4.8,-4.8) J10(5.6,-4.8) J23(16,-4.8) J24(16.8,-4.8) J25(17.6,-4.8) J26(18.4,-4.8) J27(19.2,-4.8) J29(20.4,-4.8) J31(21.2,-4.8) K2(0.4,-5.6) K4(1.2,-5.6) K6(2.4,-5.6) K7(3.2,-5.6) K8(4,-5.6) K9(4.8,-5.6) K10(5.6,-5.6) K23(16,-5.6) K24(16.8,-5.6) K25(17.6,-5.6) K26(18.4,-5.6) K27(19.2,-5.6) K28(20,-5.6) K30(20.8,-5.6) K32(21.6,-5.6) L1(0,-6.4) L3(0.8,-6.4) L5(1.6,-6.4) L6(2.4,-6.4) L27(19.2,-6.4) L29(20.4,-6.4) L31(21.2,-6.4) M2(0.4,-7.2) M4(1.2,-7.2) M6(2.4,-7.2) M27(19.2,-7.2) M28(20,-7.2) M30(20.8,-7.2) M32(21.6,-7.2) N1(0,-8) N3(0.8,-8) N5(1.6,-8) N6(2.4,-8) N27(19.2,-8) N29(20.4,-8) N31(21.2,-8) P2(0.4,-8.8) P4(1.2,-8.8) P6(2.4,-8.8) P27(19.2,-8.8) P28(20,-8.8) P30(20.8,-8.8) P32(21.6,-8.8) R1(0,-9.6) R3(0.8,-9.6) R5(1.6,-9.6) R6(2.4,-9.6) R27(19.2,-9.6) R29(20.4,-9.6) R31(21.2,-9.6) T2(0.4,-10.4) T4(1.2,-10.4) T6(2.4,-10.4) T27(19.2,-10.4) T28(20,-10.4) T30(20.8,-10.4) T32(21.6,-10.4) U1(0,-11.2) U3(0.8,-11.2) U5(1.6,-11.2) U6(2.4,-11.2) U27(19.2,-11.2) U29(20.4,-11.2) U31(21.2,-11.2) V2(0.4,-12) V4(1.2,-12) V6(2.4,-12) V27(19.2,-12) V28(20,-12) V30(20.8,-12) V32(21.6,-12) W1(0,-12.8) W3(0.8,-12.8) W5(1.6,-12.8) W6(2.4,-12.8) W27(19.2,-12.8) W29(20.4,-12.8) W31(21.2,-12.8) Y2(0.4,-13.6) Y4(1.2,-13.6) Y6(2.4,-13.6) Y27(19.2,-13.6) Y28(20,-13.6) Y30(20.8,-13.6) Y32(21.6,-13.6)
  round 0.508 smd: AA11(6.4,-14.2) AA12(7.4,-14.2) AA13(8.4,-14.2) AA15(9.4,-14.2) AA16(10.4,-14.2) AA17(11.2,-14.2) AA18(12.2,-14.2) AA20(13.2,-14.2) AA21(14.2,-14.2) AA22(15.2,-14.2) AB11(6.4,-15.2) AB12(7.4,-15.2) AB13(8.4,-15.2) AB15(9.4,-15.2) AB16(10.4,-15.2) AB17(11.2,-15.2) AB18(12.2,-15.2) AB20(13.2,-15.2) AB21(14.2,-15.2) AB22(15.2,-15.2) L11(6.4,-6.4) L12(7.4,-6.4) L13(8.4,-6.4) L15(9.4,-6.4) L16(10.4,-6.4) L17(11.2,-6.4) L18(12.2,-6.4) L20(13.2,-6.4) L21(14.2,-6.4) L22(15.2,-6.4) M11(6.4,-7.4) M12(7.4,-7.4) M13(8.4,-7.4) M15(9.4,-7.4) M16(10.4,-7.4) M17(11.2,-7.4) M18(12.2,-7.4) M20(13.2,-7.4) M21(14.2,-7.4) M22(15.2,-7.4) N11(6.4,-8.4) N12(7.4,-8.4) N13(8.4,-8.4) N15(9.4,-8.4) N16(10.4,-8.4) N17(11.2,-8.4) N18(12.2,-8.4) N20(13.2,-8.4) N21(14.2,-8.4) N22(15.2,-8.4) R11(6.4,-9.4) R12(7.4,-9.4) R13(8.4,-9.4) R15(9.4,-9.4) R16(10.4,-9.4) R17(11.2,-9.4) R18(12.2,-9.4) R20(13.2,-9.4) R21(14.2,-9.4) R22(15.2,-9.4) T11(6.4,-10.4) T12(7.4,-10.4) T13(8.4,-10.4) T15(9.4,-10.4) T16(10.4,-10.4) T17(11.2,-10.4) T18(12.2,-10.4) T20(13.2,-10.4) T21(14.2,-10.4) T22(15.2,-10.4) U11(6.4,-11.2) U12(7.4,-11.2) U13(8.4,-11.2) U15(9.4,-11.2) U16(10.4,-11.2) U17(11.2,-11.2) U18(12.2,-11.2) U20(13.2,-11.2) U21(14.2,-11.2) U22(15.2,-11.2) V11(6.4,-12.2) V12(7.4,-12.2) V13(8.4,-12.2) V15(9.4,-12.2) V16(10.4,-12.2) V17(11.2,-12.2) V18(12.2,-12.2) V20(13.2,-12.2) V21(14.2,-12.2) V22(15.2,-12.2) Y11(6.4,-13.2) Y12(7.4,-13.2) Y13(8.4,-13.2) Y15(9.4,-13.2) Y16(10.4,-13.2) Y17(11.2,-13.2) Y18(12.2,-13.2) Y20(13.2,-13.2) Y21(14.2,-13.2) Y22(15.2,-13.2)
ACES_50224-00401-001_4P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.194x1.803 smd: 5(4.3,-3.875) 6(-1.3,-3.875)
ACES_50406-02071-001_20P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.194x2.692 smd: 21(-2.4,1.95) 22(11.9,1.95)
  rect 2.311x1.295 smd: 23(0.85,3.9) 24(8.65,3.9)
ACES_50458-00601-001_6P-T
  oval 0.559x1.6 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0)
  rect 1.295x2.057 smd: 7(-3.1,-5.175) 8(13.1,-5.175)
ACES_50458-01001-P01_10P-T
  oval 0.559x1.803 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0) 10(18,0)
  rect 1.295x2.057 smd: 11(-3.1,-5.275) 12(21.1,-5.275)
ACES_50673-0120N-P01_12P
  oval 0.61x1.397 smd: 1(0,0) 2(0,3) 3(-1,0) 4(-1,3) 5(-2,0) 6(-2,3) 7(-3,0) 8(-3,3) 9(-4,0) 10(-4,3) 11(-5,0) 12(-5,3) 13(-6,0) 14(-6,3) 15(-7,0) 16(-7,3) 17(-8,0) 18(-8,3) 19(-9,0) 20(-9,3) 21(-10,0) 22(-10,3) 23(-11,0) 24(-11,3)
  rect 1.702x2.388 smd: 25(-13.25,1.5) 26(2.25,1.5)
ACES_51522-00601-001_6P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 2.489x1.905 smd: 7(-2.15,-3.3) 8(4.65,-3.3)
ACES_51522-00801-001_8P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  rect 2.489x1.905 smd: 9(5.65,-3.3) 10(-2.15,-3.3)
ACES_51524-0080N-001_8P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 2.489x2.21 smd: 9(10,-3.05) 10(-3,-3.05)
ACES_51524-0160N-001_16P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0) 11(10,0) 12(11,0) 13(12,0) 14(13,0) 15(14,0) 16(15,0)
  rect 2.159x2.21 smd: 17(-2.825,-3.05) 18(17.825,-3.05)
ACES_51540-03041-P01_30P-T
  oval 0.305x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0)
  rect 0.787x2.007 smd: 31(-1.7,-3.175) 32(16.2,-3.175)
ACES_51540-04001-P01_40P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 0.787x2.489 smd: 41(21.2,-3.6) 42(-1.7,-3.6)
ACES_51575-00401-001_4P
  oval 0.406x0.838 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 0.787x2.007 smd: 5(-2.2,-3.175) 6(5.2,-3.175)
ACES_51625-01201-001_12P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0)
  rect 0.991x2.489 smd: 13(-1.8,-3.6) 14(7.3,-3.6)
ACES_51625-01601-001_16P-T
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0)
  rect 0.991x2.489 smd: 17(1.8,-3.6) 18(-9.3,-3.6)
ACON_HMRF6-AK120C_19P-T
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(11.75,1.7) 21(13.65,-7.75) 22(-4.65,-6.5) 23(-2.75,1.7)
ACON_TARAN-9R1391_9P
  round 0.991 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(-11.35,-2.38) 12(4.35,-2.38)
  oval 1.397x2.388 hole 0.787x1.803: 11(-11.35,-9.48) 13(4.35,-9.48)
ALC3246-CG_MQFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AO3409_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AON6994_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.665)
  rect 3.988x2.667 smd: 7(1.905,3.63)
AON7409_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AP2204R-5P0TRG1_SOT89-3
  oval 0.889x1.295 smd: 1(0,0) 3(3,0)
  custom 0.433x0.433 smd: 2(1.5,1.775)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AZ5123-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
AZC199-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAS40C_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54C-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAV99W_SC70-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BAW56W_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
BOTH_NS0013LF_16P
  oval 0.762x1.905 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(8.89,8.8) 10(7.62,8.8) 11(6.35,8.8) 12(5.08,8.8) 13(3.81,8.8) 14(2.54,8.8) 15(1.27,8.8) 16(0,8.8)
C_6P3X4P5-NPM
  oval 3.505x1.6 smd: 1(0,0) 2(5.6,0)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.778 smd: 1(0,0) 2(2.667,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_EEFCX1E330R
  rect 2.388x2.794 smd: 1(0,0) 2(-6.4,0)
CYNTE_PCMB104T-1R0MH_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
CYPD4225-40LQXIT_QFN40_6X6
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 9(0,-4) 10(0,-4.5) 21(6.1,-4.5) 22(6.1,-4) 23(6.1,-3.5) 24(6.1,-3) 25(6.1,-2.5) 26(6.1,-2) 27(6.1,-1.5) 28(6.1,-1) 29(6.1,-0.5) 30(6.1,0)
  oval 0.254x0.889 smd: 11(0.8,-5.3) 12(1.3,-5.3) 13(1.8,-5.3) 14(2.3,-5.3) 15(2.8,-5.3) 16(3.3,-5.3) 17(3.8,-5.3) 18(4.3,-5.3) 19(4.8,-5.3) 20(5.3,-5.3) 31(5.3,0.8) 32(4.8,0.8) 33(4.3,0.8) 34(3.8,0.8) 35(3.3,0.8) 36(2.8,0.8) 37(2.3,0.8) 38(1.8,0.8) 39(1.3,0.8) 40(0.8,0.8)
  rect 4.597x4.597 smd: 41(3.05,-2.25)
DC021611210
  round 1.016 smd: 1(0,0) 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(10.16,0)
DDTA144VCA-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DFLS160-7_POWERDI123-2
  rect 2.21x1.397 smd: 1(0,0)
  rect 0.889x1.397 smd: 2(-2.55,0)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
ESD101-B1-02ELS_TSSLP-2-4-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
F_1206L150PR
  rect 0.991x1.803 smd: 1(0,0) 2(2.8,0)
F_MF-NSMF050-2
  rect 0.991x1.6 smd: 1(0,0) 2(3,0)
F_SMD1812P110TF-24
  rect 1.778x3.15 smd: 1(0,0) 2(5.23,0)
F_SMD1812P150TF-24
  rect 1.778x3.15 smd: 1(0,0) 2(5.23,0)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
H5GC4H24AJR-R0C_BGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
H_3P0
  round 3.505 hole 2.997: 1(0,0)
H_3P0-G
  round 3.505 hole 2.997: 1(0,0)
H_3P0X4P0
  oval 3.505x4.496 hole 2.997x3.988: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P2-G
  round 3.708 hole 3.2: 1(0,0)
H_3P3-G
  round 3.81 hole 3.302: 1(0,0)
H_3P5
  round 4.013 hole 3.505: 1(0,0)
H_3P7
  round 4.216 hole 3.708: 1(0,0)
H_3P7X4P0
  oval 4.216x4.496 hole 3.708x3.988: 1(0,0)
H_4P0
  round 4.496 hole 3.988: 1(0,0)
H_4P0X3P7
  oval 4.496x4.216 hole 3.988x3.708: 1(0,0)
H_5P0
  round 5.512 hole 5.004: 1(0,0)
H_5P6N
  round 5.588 hole 5.588 unplated: (0,0)
HEFEN_AFB02-S30F1A-HF_30P-T
  oval 0.229x1.092 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0) 5(-3.2,0) 6(-4,0) 7(-4.8,0) 8(-5.6,0) 9(-6.4,0) 10(-7.2,0) 11(-8,0) 12(-8.8,0) 13(-9.6,0) 14(-10.4,0) 15(-11.2,0) 16(-12,0) 17(-12.8,0) 18(-13.6,0) 19(-14.4,0) 20(-15.2,0) 21(-16,0) 22(-16.8,0) 23(-17.6,0) 24(-18.4,0) 25(-19.2,0) 26(-20,0) 27(-20.8,0) 28(-21.6,0) 29(-22.4,0) 30(-23.2,0)
  rect 0.559x1.295 smd: 31(1.475,-3.45) 32(-24.675,-3.45)
INPAQ_HCM1012GH900BP_4P-NPM
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INPAQ_MCM1012B900F06BP_4P-NPM
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
ISL9538HRTZ-T_TQFN32_4X4
  oval 0.787x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.2,-2.8) 18(4.2,-2.4) 19(4.2,-2) 20(4.2,-1.6) 21(4.2,-1.2) 22(4.2,-0.8) 23(4.2,-0.4) 24(4.2,0)
  oval 0.203x0.787 smd: 9(0.7,-3.5) 10(1.1,-3.5) 11(1.5,-3.5) 12(1.9,-3.5) 13(2.3,-3.5) 14(2.7,-3.5) 15(3.1,-3.5) 16(3.5,-3.5) 25(3.5,0.7) 26(3.1,0.7) 27(2.7,0.7) 28(2.3,0.7) 29(1.9,0.7) 30(1.5,0.7) 31(1.1,0.7) 32(0.7,0.7)
  rect 2.692x2.692 smd: 33(2.1,-1.4)
ISL62771HRTZ-T_TQFN40_5X5
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 21(5.1,-3.6) 22(5.1,-3.2) 23(5.1,-2.8) 24(5.1,-2.4) 25(5.1,-2) 26(5.1,-1.6) 27(5.1,-1.2) 28(5.1,-0.8) 29(5.1,-0.4) 30(5.1,0)
  oval 0.203x0.889 smd: 11(0.75,-4.35) 12(1.15,-4.35) 13(1.55,-4.35) 14(1.95,-4.35) 15(2.35,-4.35) 16(2.75,-4.35) 17(3.15,-4.35) 18(3.55,-4.35) 19(3.95,-4.35) 20(4.35,-4.35) 31(4.35,0.75) 32(3.95,0.75) 33(3.55,0.75) 34(3.15,0.75) 35(2.75,0.75) 36(2.35,0.75) 37(1.95,0.75) 38(1.55,0.75) 39(1.15,0.75) 40(0.75,0.75)
  rect 3.505x3.505 smd: 41(2.55,-1.8)
JAE_DX07S024JJ2R1300_24P
  round 0.711 hole 0.711 unplated: (-0.975,-2.7)
  oval 0.838x0.711 hole 0.838x0.711 unplated: (6.225,-2.635)
  oval 1.194x2.108 hole 0.711x1.702: 1(-1.695,-0.75) 4(6.945,-0.75)
  oval 1.651x1.092 hole 1.295x0.711: 2(-1.395,-1.25) 3(6.645,-1.25)
  oval 1.295x2.489 hole 0.711x1.905: 5(-1.695,-5.75) 6(6.945,-5.75)
  oval 0.279x0.889 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.787 smd: B1(5.25,-1.6) B2(4.75,-1.6) B3(4.25,-1.6) B4(3.75,-1.6) B5(3.25,-1.6) B6(2.75,-1.6) B7(2.25,-1.6) B8(1.75,-1.6) B9(1.25,-1.6) B10(0.75,-1.6) B11(0.25,-1.6) B12(-0.25,-1.6)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X79-NPM
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JUMP_43X118-NPM
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP226H-004S1AM_4P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 0.991x2.007 smd: 5(-2.6,-3.25) 6(5.6,-3.25)
JXT_FP226H-006S1BM_6P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0)
  rect 0.991x2.007 smd: 7(-2.6,-3.25) 8(7.6,-3.25)
JXT_FP241AH-010GAAM_10P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.65) 12(5.5,-2.65)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L05ESDL5V0NA-4_SLP2510P8-10-9
  rect 0.203x0.686 smd: 1(0,0) 2(-0.5,0) 4(-1.5,0) 5(-2,0) 6(-2,-0.875) 7(-1.5,-0.875) 8(-0.5,-0.875) 9(0,-0.875)
  rect 0.406x1.549 smd: 3(-1,-0.437)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_5X5X3_M
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
L_7X7X4_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
LCN_DAN05-67306-0100_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(19.6,-0.775) 77(-1.1,-0.775)
LCN_DAN05-67306-0103_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(19.6,-0.775) 77(-1.1,-0.775)
LED_LTW-295DSKS-5A_4P
  rect 0.508x0.406 smd: 1(0,0) 2(1.2,0) 3(0,0.7) 4(1.2,0.7)
LM393DGKR_VSSOP8
  oval 1.575x0.381 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(4.35,-1.95) 6(4.35,-1.3) 7(4.35,-0.65) 8(4.35,0)
LMBT3904LT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LN2306LT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LNG2DMTR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 4(0,-1.5) 7(1.602,-1.5) 10(1.602,0)
  oval 0.508x0.305 smd: 2(0.051,-0.5) 3(0.051,-1) 8(1.551,-1) 9(1.551,-0.5)
  oval 0.305x0.508 smd: 5(0.551,-1.5) 6(1.051,-1.5) 11(1.051,0) 12(0.551,0)
LOTES_ADDR0205-P001A02_260P
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,16.1) 262(67.175,16.1)
LOTES_ADDR0206-P001A02_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(-67.175,7.9) 262(0.425,7.9)
