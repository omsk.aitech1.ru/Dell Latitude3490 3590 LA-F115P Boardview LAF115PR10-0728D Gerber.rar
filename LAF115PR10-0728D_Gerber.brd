# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DA15: length 34.4
  TOP w0.127: v1(161.92,143.93) 161.91,143.93 161.51,144.33 UV12.U11
  IN1 w0.145: 147.36,141.45 160.36,141.45 161.91,143 161.91,143.92 v1(161.92,143.93) ; 135.31,141.38 135.02,141.38 134.11,140.48 v1(132.53,140.48)
  IN1 w0.147: 147.36,141.45 147,141.45 144.6,143.85 140.2,143.85 139.98,143.63 139.95,143.63 137.7,141.38 135.31,141.38
  BOTTOM w0.102: UV1.F25 132.22,140.2 132.5,140.48 v1(132.53,140.48)
M_DA16: length 21.4
  TOP w0.127: UV12.F4 152.71,138.72 v1(152.31,138.33)
  IN3 w0.142: v1(152.31,138.33) 152.31,140.11 151.66,140.76 149.12,140.76 148.49,141.4 138.47,141.4 137.77,140.7 137,140.7 136.7,140.39 136.44,140.39 v1(135.93,139.88)
  BOTTOM w0.102: UV1.A25 135.04,140.2 135.31,139.93
  BOTTOM w0.14: v1(135.93,139.88) 135.36,139.88 135.31,139.93
M_DA17: length 18.2
  TOP w0.127: v1(149.91,139.13) 149.51,138.73 UV12.B4
  IN3 w0.142: v1(136.7,139.95) 137.32,139.32 139.02,139.32 139.73,140.03 149.01,140.03 v1(149.91,139.13)
  BOTTOM w0.102: UV1.C25 134.11,140.2 134.55,140.64 134.85,140.64
  BOTTOM w0.127: 135.31,140.66 134.87,140.66 134.85,140.64
  BOTTOM w0.14: v1(136.7,139.95) 136.4,140.25 136.34,140.25 135.93,140.66 135.31,140.66
M_DA18: length 23.1
  TOP w0.127: UV12.E4 151.91,138.72 v1(151.51,138.33)
  IN3 w0.142: v1(151.51,138.33) 151.93,138.74 151.93,140.1 151.54,140.49 148.44,140.49 148.22,140.71 138.75,140.71 138.05,140.01 v1(137.58,140.01)
  BOTTOM w0.102: 134.77,141.2 134.11,140.54 133.53,140.54 133.19,140.2 UV1.E25
  BOTTOM w0.127: 135.31,141.39 134.97,141.39 134.77,141.2
  BOTTOM w0.14: v1(137.58,140.01) 136.2,141.39 135.31,141.39
M_DA19: length 17.4
  TOP w0.127: v1(149.11,139.13) 148.71,138.73 UV12.A4
  IN3 w0.142: v1(149.11,139.13) 148.01,139.13 147.79,139.35 147.65,139.35 147.64,139.35 140.01,139.35 139.39,138.73 136.95,138.73 136.69,138.99 136.09,138.99 135.71,139.37 v1(135.26,139.37)
  BOTTOM w0.102: UV1.D24 133.71,139.4 134.09,139.78 135.03,139.78 135.26,139.55 v1(135.26,139.37)
M_DA20: length 18.9
  TOP w0.127: v1(149.11,136.72) 149.51,137.12 UV12.B2
  IN3 w0.142: v1(149.11,136.72) 148.01,135.62 136.06,135.62 134.93,136.75 134.12,136.75 133.75,137.12 133.75,137.87 v1(133.33,138.29)
  BOTTOM w0.102: UV1.E23 133.24,138.29 v1(133.33,138.29)
M_DA21: length 23.5
  TOP w0.127: UV12.E2 151.91,137.12 v1(151.51,136.72)
  IN3 w0.142: v1(151.51,136.72) 151.24,136.45 151.24,135.77 150.43,134.96 135.95,134.96 135.03,135.88 134.15,135.88 132.89,137.14 132.48,137.14 132.18,137.44 132.18,137.78 v1(132.57,138.17)
  BOTTOM w0.102: UV1.F23 v1(132.57,138.17)
M_DA22: length 17.2
  TOP w0.127: UV12.A2 v1(148.3,136.72)
  IN3 w0.142: v1(134.1,138.28) 134.54,137.85 135.31,137.85 135.61,137.55 135.61,136.97 136.46,136.13 147.71,136.13 v1(148.3,136.72)
  BOTTOM w0.127: v1(134.1,138.28) 133.62,137.8 UV1.D22
M_DA23: length 24.9
  TOP w0.127: UV12.F2 152.71,137.08 v1(152.35,136.72)
  IN3 w0.142: v1(152.35,136.72) 152.35,135.04 151.82,134.51 151.64,134.34 136.1,134.34 134.87,135.57 133.98,135.57 132.74,136.81 132.29,136.81 131.95,137.16 v1(131.66,137.16)
  BOTTOM w0.127: UV1.F21 131.98,137.16 v1(131.66,137.16)
M_DA24: length 32.3
  BOTTOM w0.102: UV1.E21 133.24,136.69 135.06,136.69 135.4,137.04
  BOTTOM w0.127: 153.09,147.42 153.09,144.71 UV13.M11 ; 135.4,137.04 135.44,137.07 135.44,137.62 136.58,138.76 136.58,138.9
  BOTTOM w0.14: 153.09,147.42 153.09,147.54 152.76,147.87 152.76,147.89 150.62,150.03 145.59,150.03 v2(143.62,148.06) 140.97,145.41 140.97,142.48 137.6,139.11 136.78,139.11 136.58,138.9
M_DA25: length 28.9
  BOTTOM w0.102: 135.66,136.79 134.78,135.91 134.28,135.91 134.27,135.89 134.01,135.89 133.71,136.2 UV1.D20 ; UV13.M13 152.28,146.36 152.28,147.42
  BOTTOM w0.127: 135.66,136.79 135.66,137.43 136.58,138.34
  BOTTOM w0.14: 136.58,138.34 137.73,138.34 141.48,142.09 141.48,144.18 v2(145.62,148.32) 146.7,149.4 150.57,149.4 152.28,147.69 152.28,147.42
M_DA26: length 28.6
  BOTTOM w0.102: 151.51,147.42 151.49,146.35 151.91,145.94 UV13.N13 ; UV1.F19 132.51,135.4 132.81,135.7 133.87,135.7 133.88,135.69 134.4,135.69 134.41,135.7 134.88,135.7 135.88,136.7 135.88,137 136.58,137.7
  BOTTOM w0.14: 136.58,137.7 136.68,137.8 v2(137.47,137.8) 138.12,137.8 141.99,141.68 141.99,143.79 146.96,148.76 150.17,148.76 151.51,147.42
M_DA27: length 26.7
  BOTTOM w0.102: UV13.N11 151.56,144.67 151.56,145.93 151.09,146.4 150.97,146.4 150.63,146.74 150.63,147.42 ; UV1.A19 134.56,135.42 134.88,135.42 135.94,136.47 136.58,137.11
  BOTTOM w0.14: 136.58,137.11 136.64,137.17 138.54,137.17 v2(139.53,138.16) 142.92,141.55 142.92,143.82 147.22,148.13 149.92,148.13 150.63,147.42
M_DA28: length 21.8
  BOTTOM w0.102: 136.05,134.76 135.74,134.76 135.2,134.22 134.88,134.22 134.76,134.33 134.31,134.33 134.27,134.29 134.01,134.29 133.8,134.51 133.71,134.6 UV1.D18
  BOTTOM w0.127: 148.08,145.52 148.34,145.77 148.56,145.77 UV13.U13
  BOTTOM w0.14: 148.08,145.52 147.89,145.52 145.48,143.11 145.48,140.75 v2(144.35,139.61) 139.5,134.76 136.05,134.76
M_DA29: length 24
  BOTTOM w0.102: UV1.F17 132.51,134.17 133.85,134.17 133.93,134.09 134.35,134.09 134.39,134.13 134.68,134.13 134.8,134.01 135.28,134.01 135.55,134.28 136.41,134.28
  BOTTOM w0.127: 148,144.86 148.37,145.24 148.37,145.27 148.57,145.46 148.6,145.46 148.67,145.53 149.11,145.53 UV13.T13
  BOTTOM w0.14: 136.41,134.28 139.92,134.28 v2(141.68,136.04) 146.12,140.48 146.12,142.98 148,144.86
M_DA30: length 20
  BOTTOM w0.102: UV1.A17 136.16,133.8
  BOTTOM w0.127: UV13.U11 148.37,144.33 148,143.95 148,143.94
  BOTTOM w0.14: 136.16,133.8 140.33,133.8 v2(143.83,137.29) 146.88,140.34 146.88,142.82 148,143.94
M_DA31: length 22.3
  BOTTOM w0.102: 136.04,133.49 136.04,133.49 134.41,133.49 134.41,133.49 134.1,133.8 UV1.C17
  BOTTOM w0.127: 136.58,133.19 136.28,133.49 136.04,133.49 ; 147.36,139.93 147.36,142.76 148.5,143.89 149.08,143.89 UV13.T11
  BOTTOM w0.14: 136.58,133.19 140.63,133.19 v2(146.37,138.94) 147.36,139.93
M_DA32: length 45.1
  IN3 w0.142: v1(132.54,133.52) 136.45,133.52 136.58,133.65 146.73,133.65 147.31,133.08 161.35,133.08 163.02,131.41 163.02,124.73 161.95,123.66 161.95,121.39 161.66,121.1 161.66,120.26 v1(161.11,119.71)
  BOTTOM w0.102: UV1.E17 132.67,133.53 132.53,133.53 132.53,133.53 132.53,133.52 v1(132.54,133.52)
  BOTTOM w0.127: UV15.U13 v1(161.11,119.71)
M_DA33: length 41.3
  IN3 w0.142: v1(135.93,132.75) 136.22,133.05 136.49,133.05 136.58,132.97 146.45,132.97 147.03,132.39 161.07,132.39 162.34,131.13 162.34,125.01 161.67,124.35 161.67,121.8 v1(161.19,121.32)
  BOTTOM w0.102: UV1.D16 133.34,133.18 133.62,133.45 134.16,133.45 134.32,133.29 135.39,133.29 v1(135.93,132.75)
  BOTTOM w0.127: UV15.U11 161.19,121.39 v1(161.19,121.32)
M_DA34: length 39.6
  IN3 w0.142: v1(133.34,131.92) 132.9,132.36 132.9,132.78 133.1,132.98 134.16,132.98 134.65,132.49 134.74,132.49 135.42,131.82 145.67,131.82 146.43,131.06 157.85,131.06 158.73,130.18 158.73,129.95 159.07,129.61 159.07,129.46 159.07,129.46 159.07,129.12 159.07,129.12 159.07,128.19 159.93,127.33 159.93,126.37 160.01,126.29 160.01,123.73 159.89,123.61 159.89,121.69 v1(160.25,121.33)
  BOTTOM w0.102: v1(133.34,131.92) 133.31,131.89 132.53,131.89 132.23,132.2 UV1.F15
  BOTTOM w0.127: v1(160.25,121.33) 160.34,121.33 UV15.T11
M_DA35: length 40.6
  IN3 w0.142: v1(160.31,119.71) 160.78,120.17 160.78,123.84 161.53,124.6 161.53,128.46 161.48,128.5 161.48,129.58 161.58,129.68 161.58,130.91 160.79,131.71 146.74,131.71 146.17,132.29 135.54,132.29 135.37,132.46 v1(135.37,132.78)
  BOTTOM w0.102: v1(135.37,132.78) 135.37,132.66 134.9,132.2 UV1.A15
  BOTTOM w0.127: UV15.T13 v1(160.31,119.71)
M_DA36: length 31.8
  IN3 w0.142: v1(158.62,121.31) 158.31,121.61 158.31,123.84 156.79,125.36 150.06,125.36 147.06,128.36 145.26,128.36 144.56,129.06 136.75,129.06 136.33,129.47 v1(136.33,129.49)
  BOTTOM w0.102: v1(136.33,129.49) 136.31,129.49 136.17,129.63 136.17,130.5 135.78,130.89 134.64,130.89 134.58,130.95 133.79,130.95 UV1.D14
  BOTTOM w0.127: v1(158.62,121.31) 158.62,121.4 UV15.N11
M_DA37: length 34.5
  IN3 w0.142: v1(131.18,130.91) 132.12,129.97 132.12,129.15 132.74,128.54 133.93,128.54 134.89,127.58 139.79,127.58 140.27,127.1 146.54,127.1 147.36,126.29 147.96,126.29 149.72,124.53 154.36,124.53 154.55,124.35 155.54,124.35 156.61,123.28 156.61,121.98 156.68,121.91 156.68,120.14 v1(157.11,119.71)
  BOTTOM w0.127: v1(131.18,130.91) 131.63,130.91 131.94,130.6 UV1.F13 ; UV15.M13 v1(157.11,119.71)
M_DA38: length 30.9
  IN3 w0.142: v1(157.94,121.32) 157.94,121.73 157.89,121.79 157.89,123.88 156.68,125.09 149.95,125.09 148.02,127.01 147.82,127.01 146.89,127.94 143.28,127.94 143.11,128.11 142.44,128.11 142.27,127.94 141.98,127.94 141.82,128.11 141.82,128.41 141.65,128.57 141.31,128.57 141.14,128.41 141.14,128.11 140.98,127.94 140.62,127.94 139.93,128.64 136.21,128.64 135.64,129.21 v1(135.64,129.49)
  BOTTOM w0.102: UV1.A13 134.74,130.39 135.49,130.39 135.64,130.24 v1(135.64,129.49)
  BOTTOM w0.127: UV15.M11 157.89,121.32 157.94,121.32 v1(157.94,121.32)
M_DA39: length 32.6
  IN3 w0.142: v1(157.91,119.71) 157.49,120.12 157.49,121.04 157.53,121.08 157.53,123.85 156.56,124.81 149.83,124.81 148.05,126.59 147.65,126.59 146.71,127.52 140.44,127.52 139.75,128.22 138.22,128.22 138.01,128 137.55,128 137.33,128.22 136.02,128.22 135.66,128.58 135.06,128.58 134.88,128.76 134.88,129.31 v1(135.06,129.49)
  BOTTOM w0.102: v1(135.06,129.49) 135.06,129.9 134.77,130.19 134.15,130.19 UV1.C13
  BOTTOM w0.127: UV15.N13 v1(157.91,119.71)
M_DA40: length 32.1
  TOP w0.127: UV14.B2 161.04,129.24 v1(161.04,129.29)
  IN1 w0.145: v1(133.74,129.52) 134.67,130.46 136.58,130.46
  IN1 w0.147: 136.58,130.46 141.5,130.46 143.62,132.57 158.6,132.57 158.67,132.5 158.96,132.5 160.41,131.06 160.41,130.77 160.66,130.52 160.66,129.67 v1(161.04,129.29)
  BOTTOM w0.102: v1(133.74,129.52) 133.73,129.52 133.46,129.52 UV1.E11
M_DA41: length 38.6
  TOP w0.127: v1(161.05,126.88) 161.48,127.31 UV14.A4
  IN1 w0.145: 162.18,128 v1(161.05,126.88)
  IN1 w0.147: 162.18,128 162.89,128.72 162.89,132.07 160.71,134.25 140.66,134.25 138.1,131.7 138.1,131.34 v1(137.8,131.04)
  BOTTOM w0.127: 136.51,129.09 136.46,129.05 134.59,129.05 UV1.A11
  BOTTOM w0.14: 136.51,129.09 137.8,130.38 v2(137.8,130.42) v1(137.8,131.04)
M_DA42: length 35.1
  TOP w0.127: v1(161.92,129.32) 161.51,128.91 UV14.A2
  IN1 w0.147: v1(161.92,129.32) 162.44,129.84 162.44,130.96 159.8,133.6 140.96,133.6 139.11,131.76 138.81,131.46 138.81,131.32 v1(138.51,131.02)
  BOTTOM w0.102: 136.58,128.57 136.09,128.57 135.87,128.79 134.77,128.79 134.67,128.69 134.41,128.69 134.11,129 UV1.C11
  BOTTOM w0.14: 136.58,128.57 136.82,128.57 v2(137.34,129.08) 138.51,130.25 v1(138.51,131.02)
M_DA43: length 38.8
  TOP w0.127: UV14.B4 160.4,127 160.4,126.96 v1(160.35,126.91)
  IN1 w0.145: v1(160.35,126.91) 160.35,127.67 161.46,128.78 161.46,129.58 161.83,129.95 161.83,130.16
  IN1 w0.147: 161.83,130.16 161.83,130.82 159.51,133.14 141.42,133.14 v1(139.26,130.98)
  BOTTOM w0.102: UV1.F11 132.44,128.69 133.07,128.69 133.17,128.79 133.47,128.79 133.57,128.69 134.13,128.69 134.33,128.49 134.95,128.49 135,128.54 135.83,128.54 136.29,128.08 136.58,128.08
  BOTTOM w0.14: v1(139.26,130.98) v2(139.26,130.28) 139.26,130.14 137.21,128.08 136.58,128.08
M_DA44: length 26.5
  TOP w0.127: v1(158.65,129.28) 158.65,129.25 UV14.E2
  IN1 w0.145: 148,129.76 154.58,129.76 154.85,130.04 155.81,130.04 156.09,129.76 158.16,129.76 v1(158.65,129.28)
  IN1 w0.147: v1(137.59,127.14) 137.59,127.57 138.11,128.09 144.17,128.09 144.36,128.29 144.37,128.29 145.84,129.76 148,129.76
  BOTTOM w0.102: UV1.A9 134.57,127.42 136.29,127.42
  BOTTOM w0.14: 136.29,127.42 137.31,127.42 v1(137.59,127.14)
M_DA45: length 26.6
  TOP w0.127: UV14.F2 157.51,128.95 v1(157.87,129.31)
  IN1 w0.145: v1(157.87,129.31) 156.19,129.31 155.71,129.79 154.98,129.79 154.65,129.46 148.91,129.46 148.57,129.11 148,129.11
  IN1 w0.147: v1(138.37,127.15) 138.86,127.63 144.64,127.63 146.11,129.11 148,129.11
  BOTTOM w0.102: 136.47,126.55 135.93,127.09 134.41,127.09 134.36,127.14 134,127.14 133.74,127.4 UV1.C9
  BOTTOM w0.127: 136.47,126.55 136.58,126.55
  BOTTOM w0.14: v1(138.37,127.15) 137.77,126.55 136.58,126.55
M_DA46: length 29.1
  TOP w0.127: UV14.F4 v1(157.91,127.71)
  IN1 w0.145: v1(157.91,127.71) 157.51,127.31 156.82,127.31 155.18,128.96 149.11,128.96 148.61,128.46 148,128.46
  IN1 w0.147: 148,128.46 146.1,128.46 144.62,126.98 139.78,126.98 139.62,127.14 v1(139.19,127.14)
  BOTTOM w0.102: UV1.F9 132.51,127.4 132.97,126.94 134.28,126.94 134.33,126.89 135.61,126.89 136.44,126.07 136.58,126.07
  BOTTOM w0.14: v1(139.19,127.14) 138.89,126.84 138.89,126.73 138.23,126.07 136.58,126.07
M_DA47: length 30.4
  TOP w0.127: UV14.E4 v1(158.71,127.71)
  IN1 w0.145: v1(135.6,125.91) 136.04,126.35 136.58,126.35 ; v1(158.71,127.71) 158,127 156.78,127 155.68,128.11 148.1,128.11 148,128.01
  IN1 w0.147: 136.58,126.35 146.3,126.35 146.44,126.49 146.44,127.66 146.59,127.8 146.88,127.8 147.02,127.66 147.02,126.87 147.17,126.73 147.52,126.73 147.67,126.87 147.67,127.68 148,128.01
  BOTTOM w0.102: v1(135.6,125.91) 135.03,125.91 134.93,126.01 134.76,126.01 134.48,126.29 134.01,126.29 133.71,126.6 UV1.D8
M_DA48: length 23.4
  TOP w0.127: UV14.M11 v1(152.31,121.31)
  IN3 w0.142: v1(152.31,121.31) 152.5,121.5 152.5,123.12 151.87,123.75 149.38,123.75 148.42,124.71 146.71,124.71 145.92,125.5 139.65,125.5 139.35,125.8 136.8,125.8 136.5,125.5 135.67,125.5 135.66,125.49 v1(133.31,125.49)
  BOTTOM w0.127: UV1.E7 133.25,125.49 v1(133.31,125.49)
M_DA49: length 22
  TOP w0.127: UV14.N11 v1(151.51,121.31)
  IN3 w0.142: v1(151.51,121.31) 151.93,121.72 151.93,123.29 151.75,123.47 148.99,123.47 148.16,124.29 146.53,124.29 145.75,125.08 139.28,125.08 138.97,125.38 137.17,125.38 136.56,124.77 136.52,124.77 136.26,124.51 v1(136.05,124.51)
  BOTTOM w0.127: UV1.A7 134.54,125.65 134.77,125.43 135.23,125.43 136.05,124.61 136.05,124.52 v1(136.05,124.51)
M_DA50: length 17.9
  TOP w0.127: UV14.T11 v1(149.11,122.11)
  IN3 w0.142: v1(149.11,122.11) 149.11,122.22 147.45,123.88 146.36,123.88 145.88,124.35 136.47,124.35 136.22,124.1 136.21,124.1 136.2,124.1 135.67,124.1 135.5,124.27 v1(135.5,124.61)
  BOTTOM w0.127: v1(135.5,124.61) 135.26,124.61 134.07,125.8 UV1.C7
M_DA51: length 27.4
  TOP w0.127: UV14.M13 v1(152.31,119.71)
  IN3 w0.142: v1(152.31,119.71) 151.81,119.2 151.81,118.73 151.04,117.96 146.72,117.96 144.25,120.43 134.17,120.43 132.63,121.97 132.63,122.56 132.92,122.85 132.92,123.12 133.15,123.35 133.15,124.88 v1(132.6,125.43)
  BOTTOM w0.127: v1(132.6,125.43) 132.23,125.8 UV1.F7
M_DA52: length 16
  TOP w0.127: v1(148.28,121.45) 148.45,121.45 UV14.U11
  IN3 w0.142: v1(134.87,123.84) 134.97,123.95 135.44,123.95 135.56,123.82 136.31,123.82 136.32,123.83 136.33,123.83 136.43,123.93 145.71,123.93 146.19,123.46 146.96,123.46 148.28,122.14 v1(148.28,121.45)
  BOTTOM w0.102: v1(134.87,123.84) 134.87,123.87 UV1.A5
M_DA53: length 24
  TOP w0.127: UV14.N13 v1(151.51,119.71)
  IN3 w0.142: v1(151.51,119.71) 151.13,119.32 151.13,118.73 150.8,118.41 146.87,118.41 144.43,120.84 136.36,120.84 136.22,120.98 134.02,120.98 132.91,122.09 132.91,122.44 133.34,122.87 v1(133.34,122.95)
  BOTTOM w0.102: UV1.E5 133.34,123.8 v1(133.34,122.95)
M_DA54: length 17.3
  TOP w0.127: UV14.U13 v1(148.24,119.64)
  IN3 w0.142: v1(148.24,119.64) 148.01,119.41 147.04,119.41 144.75,121.71 136.48,121.71 136.31,121.53 135.1,121.53 134.6,122.04 134.6,122.54 v1(134.15,122.99)
  BOTTOM w0.102: UV1.C3 v1(134.15,122.99)
M_DA55: length 18.7
  TOP w0.127: UV14.T13 v1(149.11,119.71)
  IN3 w0.142: v1(133.32,122.26) 134.33,121.26 144.61,121.26 147,118.87 148.37,118.87 149.11,119.61 v1(149.11,119.71)
  BOTTOM w0.102: v1(133.32,122.26) 133.27,122.26 UV1.E1
M_DA56: length 39.4
  BOTTOM w0.089: 136.49,121.54 136.27,121.33 132.15,121.33 131.95,121.53
  BOTTOM w0.102: UV1.G7 131.74,125.4 131.74,124.84 131.85,124.73 131.85,123.94 131.64,123.73 131.64,123.11 131.71,123.04 131.71,122.94 131.85,122.81 131.85,122.39 131.72,122.26 131.72,121.75 131.95,121.53
  BOTTOM w0.127: 153.91,130.4 153.91,129.6 153.65,129.34 153.39,129.34 153.12,129.06 153.12,127.71 152.71,127.31 UV15.F4
  BOTTOM w0.14: 136.49,121.54 139.27,124.33 139.27,126.48 139.64,126.85 139.64,127.21 v2(144.31,131.88) 146.48,134.05 151.23,134.05 153.78,131.51 153.78,131.12 153.91,130.99 153.91,130.4
M_DA57: length 35.1
  BOTTOM w0.089: 137.19,120.56 137.14,120.5 132,120.5 131.71,120.79
  BOTTOM w0.102: 131.06,121.91 131.04,121.94 131.04,122.73 131.04,122.74 131.04,122.78 131.05,122.79 131.05,123.21 131.04,123.22 131.04,123.27 131,123.31 131,123.61 131.19,123.8 131.42,123.8 131.64,124.02 131.64,124.41 131.34,124.71 UV1.G6
  BOTTOM w0.127: 151.51,130.13 151.51,127.71 151.67,127.55 151.67,127.55 UV15.E4 ; 131.06,121.91 131.06,121.44 131.71,120.79
  BOTTOM w0.14: 137.19,120.56 140.7,124.06 140.7,125.47 v2(143.97,128.74) 147.42,132.19 150.43,132.19 151.52,131.1 151.52,130.47 151.51,130.46 151.51,130.13
M_DA58: length 31.5
  BOTTOM w0.089: 136.94,120.99 136.77,120.82 132.01,120.82 131.81,121.02
  BOTTOM w0.127: 131.81,121.02 131.29,121.54 131.29,122.55 UV1.G1 ; UV15.E2 152.3,129.3 152.3,130.4
  BOTTOM w0.14: 136.94,120.99 140.16,124.21 140.16,125.74 147.31,132.88 v2(148.9,132.88) 150.73,132.88 152.3,131.31 152.3,130.4
M_DA59: length 33.7
  BOTTOM w0.089: 131.84,121.31 132.08,121.07 136.44,121.07 136.58,121.21
  BOTTOM w0.102: 131.52,121.63 131.52,121.65 131.5,121.66 131.5,121.84 131.52,121.86 131.52,122.34 131.64,122.47 131.64,122.72 131.51,122.86 131.51,122.95 131.34,123.12 UV1.G3
  BOTTOM w0.127: UV15.F2 152.71,129.23 153.12,129.64 153.12,130.4 ; 131.52,121.63 131.84,121.31
  BOTTOM w0.14: 136.58,121.21 139.72,124.35 139.72,126.3 140.08,126.67 140.08,126.75 v2(146.18,132.85) 146.85,133.52 150.99,133.52 153.12,131.39 153.12,130.4
M_DA60: length 28.5
  BOTTOM w0.089: 129.92,120.03 129.92,120.31 129.58,120.65 ; 139,119.33 138.58,118.91 130.82,118.91
  BOTTOM w0.102: 129.58,120.65 129.43,120.8 129.43,122.72 129.52,122.81 129.52,123.18 129.42,123.28 129.42,123.51 129.73,123.82 129.81,123.82 130.04,124.05 130.04,124.07 130.04,124.07 130.04,124.34 129.84,124.55 129.84,124.9 UV1.J6
  BOTTOM w0.127: UV15.A4 148.23,127.31
  BOTTOM w0.14: 139,119.33 141.18,121.51 142.43,121.51 v2(144.62,123.7) 148.23,127.31 ; 129.92,120.03 129.92,119.81 130.82,118.91
M_DA61: length 26.3
  BOTTOM w0.089: 129.63,120.91 131.24,119.29 138.33,119.29 139,119.96
  BOTTOM w0.102: 129.63,120.91 129.63,122.49 UV1.J1
  BOTTOM w0.127: 148.39,128.27 148.57,128.45 149.05,128.45 UV15.B2
  BOTTOM w0.14: 148.39,128.27 v2(142.82,122.7) 142.07,121.95 140.99,121.95 139,119.96
M_DA62: length 25.8
  BOTTOM w0.089: 139,120.59 138.02,119.61 131.45,119.61 130.94,120.12 130.94,120.15 130.53,120.55
  BOTTOM w0.102: UV1.J3 129.81,123.33 129.81,123 130.04,122.77 130.04,122.47 129.83,122.26 129.83,121.25 130.53,120.55
  BOTTOM w0.127: UV15.A2 148.04,128.91 148,128.86
  BOTTOM w0.14: 139,120.59 140.81,122.4 141.53,122.4 v2(146.28,127.14) 148,128.86
M_DA63: length 29.2
  BOTTOM w0.089: 129.41,120.18 129.41,120.03 ; 139,118.7 138.76,118.47 130.59,118.47
  BOTTOM w0.102: 147.93,126.37 147.36,125.8 ; 129.22,120.37 129.22,122.4 129.21,122.42 129.21,122.78 129.27,122.85 129.27,123.14 129.2,123.21 129.2,123.6 129.74,124.14 UV1.J5
  BOTTOM w0.127: UV15.B4 149.51,127.31 149.11,126.91 148.47,126.91 147.93,126.37
  BOTTOM w0.14: 139,118.7 141.36,121.06 142.63,121.06 v2(146.4,124.84) 147.36,125.8 ; 129.41,120.03 129.41,119.64 130.59,118.47 ; 129.22,120.37 129.41,120.18
M_DBI0#: length 46.5
  IN3 w0.142: v1(130.26,142.19) 130.56,142.49 130.57,142.49 131.05,142.96 131.05,144.96 131.56,145.47 133.03,145.47 134.67,147.1 136.32,147.1 137.36,148.15 142.3,148.15 143.29,149.14 156.71,149.14 157.63,148.22 159.01,148.22 159.91,147.32 159.91,143.52 159.97,143.46 159.97,142.76 159.68,142.47 159.68,139.87 159.91,139.64 159.91,137.12 v1(159.51,136.72)
  BOTTOM w0.127: v1(130.26,142.19) 130.28,142.19 130.28,142.06 UV1.H27 ; UV13.D2 v1(159.51,136.72)
M_DBI1#: length 28.7
  TOP w0.127: v1(159.51,145.53) 159.51,145.53 159.11,145.93 UV12.P13
  IN1 w0.102: v1(159.51,145.53) 159.51,145.52 159.13,145.14 155.94,145.14 155.8,145.28
  IN1 w0.145: 135.31,142.73 135.23,142.65 135.23,142.28 135.2,142.25 v1(135.2,141.85)
  IN1 w0.147: 155.8,145.28 153.58,145.28 152.88,145.98 146.4,145.98 145.81,146.57 139.2,146.57 139.18,146.55 139.13,146.55 135.31,142.73
  BOTTOM w0.127: v1(135.2,141.85) 135.15,141.8 UV1.A27
M_DBI2#: length 19.5
  TOP w0.127: UV12.D2 151.11,137.12 v1(150.71,136.72)
  IN3 w0.142: v1(134.12,138.89) 134.89,138.89 134.96,138.82 135.85,138.82 136.71,137.96 139.59,137.96 140.29,138.66 148.18,138.66 148.93,137.92 149.74,137.92 149.74,137.93 150.11,137.93 150.31,137.73 150.31,137.12 v1(150.71,136.72)
  BOTTOM w0.127: UV1.C23 133.83,138.6 v1(134.12,138.89)
M_DBI3#: length 25
  BOTTOM w0.102: UV13.P13 150.69,146.34 150.14,146.34 149.84,146.65 149.84,147.01 ; 136.1,136.32 136.08,136.32 134.97,135.21 134.83,135.21 134.7,135.08 134.41,135.08 134.33,135.16 133.98,135.16 UV1.C19
  BOTTOM w0.127: 136.1,136.32 136.15,136.32 ; 149.84,147.01 149.77,147.08 149.77,147.33 149.68,147.42
  BOTTOM w0.14: 149.68,147.42 149.6,147.49 149.31,147.49 149.3,147.5 148.97,147.5 148.97,147.5 148.17,147.5 148.17,147.49 147.49,147.49 143.55,143.55 143.55,141.31 v2(141.58,139.34) 138.66,136.41 136.23,136.41 136.15,136.32
M_DBI4#: length 35.7
  IN3 w0.142: v1(158.71,119.71) 158.71,120.71 159.15,121.15 159.15,125.46 157.93,126.69 157.12,126.69 154.84,128.96 148.18,128.96 148.11,129.04 145.54,129.04 144.84,129.73 137.06,129.73 136.88,129.91 136.86,129.91 136.71,130.06 136.11,130.06 136.08,130.1 134.35,130.1 134.02,130.42 134.02,131.8 v1(134.12,131.9)
  BOTTOM w0.127: UV15.P13 v1(158.71,119.71) ; UV1.C15 133.82,132.2 v1(134.12,131.9)
M_DBI5#: length 29.6
  TOP w0.127: v1(159.49,129.29) 159.49,129.29 UV14.D2
  IN1 w0.145: 135.89,127.28 133.73,127.28 v1(133.33,127.68) ; v1(159.49,129.29) 158.73,130.05 158.73,130.31 158.64,130.4
  IN1 w0.147: 135.89,127.28 136.38,127.28 137.84,128.74 143.89,128.74 144.09,128.94 144.1,128.94 145.94,130.79 158.25,130.79 158.64,130.4
  BOTTOM w0.102: v1(133.33,127.68) 133.23,127.68 UV1.E9
M_DBI6#: length 20.9
  TOP w0.127: UV14.P13 v1(150.71,120.51)
  IN3 w0.142: v1(135.87,122.48) 135.87,122.56 136.57,123.26 145.43,123.26 145.91,122.78 146.36,122.78 148.13,121.01 148.4,121.01 148.52,120.89 150.33,120.89 v1(150.71,120.51)
  BOTTOM w0.102: v1(135.87,122.48) 135.87,123.7 134.86,124.71 134.33,124.71 133.82,124.2 UV1.C5
M_DBI7#: length 30.5
  BOTTOM w0.089: 131.62,120.56 132,120.18 137.28,120.18 137.32,120.23
  BOTTOM w0.102: 130.83,121.87 130.83,122.82 130.84,122.82 130.84,122.86 130.84,122.87 130.84,123.12 130.84,123.13 130.84,123.18 130.54,123.48 UV1.H4
  BOTTOM w0.127: 130.83,121.87 130.83,121.54 130.83,121.35 131.62,120.56 ; UV15.D2 150.69,129.32
  BOTTOM w0.14: 150.69,129.32 150.65,129.37 150.65,129.85 150.61,129.89 150.61,130.29 150.6,130.3 150.6,130.44 150.6,130.44 150.6,131 150.09,131.51 147.83,131.51 v2(146.1,129.78) 143.78,127.45 143.78,127.44 141.39,125.05 141.39,124.29 137.32,120.23
M_EDC_0: length 52
  IN3 w0.142: v1(160.31,136.72) 160.71,137.13 160.71,147.63 159.23,149.12 157.97,149.12 157.06,150.03 142.42,150.03 142.11,149.71 142.11,149.21 141.93,149.04 141.58,149.04 141.41,149.21 141.41,149.75 141.23,149.93 140.88,149.93 140.71,149.75 140.71,149.21 140.53,149.04 140.18,149.04 140,149.21 140,149.74 139.83,149.91 139.48,149.91 139.3,149.74 139.3,149.21 139.13,149.04 138.78,149.04 138.6,149.21 138.6,149.76 138.43,149.94 138.06,149.94 137.87,149.75 137.87,149.21 137.7,149.04 136.99,149.04 135.95,147.99 133.49,147.99 130.53,145.03 130.53,143.27 v1(130.24,142.97)
  BOTTOM w0.127: UV13.C2 v1(160.31,136.72) ; v1(130.24,142.97) 130.54,142.67 UV1.H28
M_EDC_1: length 33.9
  TOP w0.102: v1(159.51,146.33) 159.51,146.33 159.91,145.93 UV12.R13
  IN1 w0.102: 148,146.76 148.13,146.76 148.18,146.72 148.56,146.72 148.66,146.61 148.66,146.31 148.76,146.21 148.96,146.21 149.07,146.31 149.07,146.61 149.17,146.72 149.37,146.72 149.47,146.61 149.47,146.31 149.57,146.21 149.78,146.21 149.88,146.31 149.88,146.61 149.98,146.72 150.23,146.72 150.34,146.61 150.34,146.31 150.44,146.21 150.64,146.21 150.74,146.31 150.74,146.61 150.84,146.72 151.05,146.72 151.15,146.61 151.15,146.31 151.25,146.21 151.45,146.21 151.55,146.31 151.55,146.61 151.66,146.72 151.9,146.72 152,146.61 152,146.59 152.1,146.49 152.31,146.49 152.41,146.59 152.41,146.61 152.51,146.72 152.98,146.72 153.77,145.93 159.12,145.93 159.51,146.32 v1(159.51,146.33)
  IN1 w0.145: v1(134.26,142.19) 134.52,142.45 134.52,143.05 134.69,143.21 134.69,143.57 135.06,143.94
  IN1 w0.147: 148,146.76 146.83,146.76 146.23,147.36 138.83,147.36 137.81,146.34 137.61,146.34 137.58,146.37 137.37,146.37 137.12,146.11 137.12,145.9 137.14,145.88 137.14,145.67 136.89,145.41 136.68,145.41 136.65,145.44 136.44,145.44 136.19,145.18 136.19,144.98 136.22,144.95 136.22,144.74 135.41,143.94 135.06,143.94
  BOTTOM w0.127: v1(134.26,142.19) 134.24,142.17 134.11,142.17 UV1.C27
M_EDC_2: length 17.6
  TOP w0.127: UV12.C2 150.31,137.12 v1(149.91,136.72)
  IN3 w0.142: v1(135.61,138.36) 136.12,137.85 136.12,137.29 136.34,137.07 139.96,137.07 140.38,137.49 149.14,137.49 v1(149.91,136.72)
  BOTTOM w0.102: v1(135.61,138.36) 135.17,138.8 134.74,138.8 UV1.A23
M_EDC_3: length 24.5
  BOTTOM w0.102: UV1.E19 132.94,135.02 133.04,134.91 134.29,134.91 134.34,134.86 134.76,134.86 134.88,134.98 135.45,134.98
  BOTTOM w0.127: UV13.R13 150.05,145.93 149.71,146.26 148.43,146.26 ; 135.45,134.98 136.06,135.59
  BOTTOM w0.14: 136.06,135.59 v2(138.08,135.59) 138.93,135.59 139.29,135.95 139.59,135.95 139.9,136.26 139.9,136.56 140.21,136.87 140.5,136.87 140.81,137.17 140.81,137.47 144.62,141.28 144.62,143.41 147.69,146.49 148.2,146.49 148.43,146.26
M_EDC_4: length 38.9
  IN3 w0.142: v1(159.51,119.71) 159.84,120.03 159.84,120.77 159.55,121.05 159.55,125.45 158.04,126.96 157.24,126.96 154.87,129.33 150.51,129.33 150.18,129.66 149.81,129.66 149.48,129.33 148.5,129.33 147.58,130.26 146.1,130.26 145.85,130.51 145.02,130.51 144.83,130.69 144.83,130.85 144.67,131.02 144.33,131.02 144.16,130.85 144.16,130.69 144,130.53 143.51,130.53 143.35,130.69 143.35,130.85 143.18,131.02 142.84,131.02 142.68,130.85 142.68,130.69 142.51,130.53 142.17,130.53 142,130.69 142,130.85 141.84,131.02 141.49,131.02 141.33,130.85 141.33,130.69 141.16,130.53 140.82,130.53 140.66,130.69 140.66,130.85 140.49,131.02 140.15,131.02 139.98,130.85 139.98,130.69 139.82,130.53 137.5,130.53 137.23,130.8 137.09,130.94 136.65,130.94 136.09,131.5 135.16,131.5 134.98,131.69 134.92,131.69 134.09,132.52 v1(133.36,132.52)
  BOTTOM w0.102: UV1.E15 133.26,132.52 v1(133.36,132.52)
  BOTTOM w0.127: UV15.R13 v1(159.51,119.71)
M_EDC_5: length 32.1
  TOP w0.127: UV14.C2 v1(160.32,129.32)
  IN1 w0.145: v1(134.13,127.69) 135,128.56 136.39,128.56 136.58,128.74 ; v1(160.32,129.32) 159.55,130.1 159.55,130.4
  IN1 w0.147: 136.58,128.74 137.43,129.6 143.54,129.6 143.74,129.8 143.74,129.8 144.28,130.34 144.28,130.54 143.89,130.93 143.89,131.14 144.09,131.34 144.3,131.34 144.69,130.95 144.89,130.95 145.58,131.64 158.61,131.64 159.55,130.7 159.55,130.4
  BOTTOM w0.102: UV1.D10 133.54,128.2 134.05,127.69 v1(134.13,127.69)
M_EDC_6: length 22.9
  TOP w0.127: UV14.R13 v1(150.69,119.73)
  IN3 w0.142: v1(135.22,122.48) 135.22,122.19 135.54,121.87 135.95,121.87 136.57,122.48 145.11,122.48 147.47,120.12 150.29,120.12 v1(150.69,119.73)
  BOTTOM w0.102: UV1.D6 133.2,124.86 133.2,124.36 133.44,124.12 133.44,124.07 133.61,123.89 133.87,123.89 134.24,124.26 134.24,124.32 134.41,124.5 134.77,124.5 135.27,124 135.27,122.53 v1(135.22,122.48)
M_EDC_7: length 30.7
  BOTTOM w0.089: 130.05,121.71 131.76,119.99 137.6,119.99 137.65,120.05
  BOTTOM w0.102: UV1.G5 131.24,124.1 130.41,124.1 130.1,123.79 130.1,123 130.25,122.86 130.25,122.39 130.05,122.19 130.05,121.71
  BOTTOM w0.127: 149.77,130.4 149.77,129.97 149.96,129.78 149.96,129.25 UV15.C2
  BOTTOM w0.14: 137.65,120.05 v2(139.89,122.28) 140.78,123.17 141.21,123.17 143.56,125.52 143.56,126.07 148.18,130.69 149.52,130.69 149.77,130.43 149.77,130.4
M_RAS#0: length 32.9
  TOP w0.102: v1(153.02,138.32) 153.03,138.33 153.03,138.86 152.69,139.2 152.57,139.2 152.25,139.52 152.25,139.72 151.67,140.31 148.95,140.31 148.38,139.73 148.38,138.48 148.19,138.29
  TOP w0.127: 148,138.1 148.19,138.29 ; UV12.G3 153.42,137.93 v1(153.02,138.32) ; v1(130.93,137.96) 130.65,137.68 130.27,137.68 129.63,137.04 129.63,135.65 130.21,135.08 132.21,135.08 132.38,135.25 133.06,135.25 133.33,134.99 135.69,134.99 135.96,135.18 136.49,135.18
  TOP w0.14: 148,138.1 147.76,137.87 146.6,137.87 v2(144.56,135.82) 143.92,135.18 136.49,135.18
  BOTTOM w0.127: UV1.G22 130.98,137.96 v1(130.93,137.96) ; v1(153.02,138.32) 153.42,137.93 UV12.G3
M_RAS#1: length 32.4
  TOP w0.127: v1(131.74,133.53) 131.83,133.53 132.29,133.99 132.73,133.99 133.06,133.66 136.28,133.66 136.58,133.36 ; 154.73,129.95 154.73,128.7 154.92,128.51 156.3,128.51 v1(156.33,128.49) UV14.G3
  TOP w0.14: 154.73,129.95 154.73,130.06 154.74,130.06 154.74,130.39 154.73,130.4 154.73,130.45 152.97,132.21 152.97,132.41 153.58,133.02 153.58,133.14 153.34,133.38 153.11,133.38 152.56,132.83 152.36,132.83 152.02,133.17 v2(148.78,133.17) 141.67,133.17 141.46,133.38 140.94,133.38 140.73,133.17 140.21,133.17 140,133.38 139.47,133.38 139.26,133.17 138.85,133.17 138.64,133.38 138.29,133.38 138.08,133.17 137.81,133.17 137.6,133.38 137.25,133.38 137.04,133.17 136.77,133.17 136.58,133.36
  BOTTOM w0.102: v1(131.74,133.53) 131.68,133.53 131.34,133.87 UV1.G17
  BOTTOM w0.127: v1(156.33,128.49) UV14.G3
M_WCKA0_0: length 39.2
  TOP w0.112: UV12.P4 159.11,138.73 159.51,139.12 v1(159.51,139.13)
  IN1 w0.13: v1(140.46,143.2) 140.46,142.96 140.78,142.64 140.78,140.92 140.91,140.79 141.46,140.79 141.59,140.92 141.59,142.3 141.85,142.56 142.42,142.56 142.68,142.3 142.68,140.92 142.81,140.79 143.19,140.79 143.32,140.92 143.32,142.3 143.58,142.56 144.15,142.56 144.41,142.3 144.41,140.92 144.54,140.79 158.89,140.79 159.3,140.39 159.3,139.34 159.51,139.13 v1(159.51,139.13)
  BOTTOM w0.112: UV1.E32 133.06,144.32 133.06,144.79 133.94,145.67 135.29,145.67 135.3,145.66 135.31,145.66 ; UV12.P4 159.11,138.73 159.51,139.12 v1(159.51,139.13)
  BOTTOM w0.122: 135.31,145.66 137.72,145.66 138.96,144.42 138.99,144.42 139.58,143.83 139.58,143.8 140.17,143.21 140.22,143.21 140.23,143.2 v1(140.46,143.2)
M_WCKA0_0#: length 39.6
  TOP w0.112: UV12.P5 159.11,139.52 158.71,139.13 v1(158.7,139.13)
  IN1 w0.13: v1(158.7,139.13) 158.86,139.13 159.08,139.34 159.08,140.3 158.8,140.57 144.45,140.57 144.19,140.83 144.19,142.21 144.06,142.34 143.67,142.34 143.54,142.21 143.54,140.83 143.28,140.57 142.71,140.57 142.46,140.83 142.46,142.21 142.33,142.34 141.94,142.34 141.81,142.21 141.81,140.83 141.55,140.57 140.82,140.57 140.56,140.83 140.56,142.55 140.32,142.79 v1(140.05,142.79)
  BOTTOM w0.112: 135.31,145.44 135.21,145.44 135.19,145.46 134.03,145.46 133.27,144.7 133.27,144.22 133.26,144.22 133.26,143.72 UV1.E30 ; UV12.P5 159.11,139.52 158.71,139.13 v1(158.7,139.13)
  BOTTOM w0.122: 135.31,145.44 137.62,145.44 138.67,144.4 v4(139.06,144) 140.05,143.02 140.05,142.79 v1(140.05,142.79)
M_WCKA0_1: length 20
  TOP w0.112: v1(151.51,139.13) 151.11,138.73 UV12.D4
  IN1 w0.13: v1(151.51,139.13) 151.23,138.85 151.23,138.68 150.69,138.14 149.86,138.14 149.15,137.42 135.86,137.42 135.54,137.74 134.89,137.74 134.76,137.61 134.76,137.5 v1(135.04,137.21)
  BOTTOM w0.102: v1(135.04,137.21) 134.81,137.11 134.77,137.13 134.56,137.04 UV1.A21
  BOTTOM w0.112: UV12.D4 151.11,138.73 v1(151.51,139.13)
M_WCKA0_1#: length 20.1
  TOP w0.112: UV12.D5 151.11,139.52 v1(150.71,139.13)
  IN1 w0.13: v1(134.15,137.29) 134.39,137.29 134.54,137.44 134.54,137.7 134.8,137.96 135.63,137.96 135.95,137.64 149.06,137.64 149.77,138.36 150.6,138.36 151.01,138.77 151.01,139 150.89,139.13 v1(150.71,139.13)
  BOTTOM w0.102: UV1.C21 133.86,137 v1(134.15,137.29)
  BOTTOM w0.112: v1(150.71,139.13) 151.11,139.52 UV12.D5
M_WCKA1_0: length 35.2
  TOP w0.112: UV14.D4 158.88,127.31 158.71,127.14 v1(158.71,126.91)
  IN1 w0.13: v1(133.37,130.28) 133.16,130.07 133.16,129.98 133.08,129.9 133.08,129.67 133.25,129.5 133.25,128.31 132.93,127.99 132.93,127.09 134.63,125.39 136.08,125.39 137.38,124.1 147.32,124.1 147.93,124.7 157.54,124.7 158.51,125.67 158.51,125.91 159.05,126.45 159.05,126.75 158.89,126.91 v1(158.71,126.91)
  BOTTOM w0.112: v1(133.37,130.28) 133.44,130.35 133.44,130.51 133.16,130.79 132.96,130.79 132.94,130.77 UV1.E13 ; v1(158.71,126.91) 158.66,126.96 158.66,127.14 158.86,127.34 159.08,127.34 UV14.D4
M_WCKA1_0#: length 34.7
  TOP w0.112: v1(159.41,126.91) 159.41,126.81 UV14.D5
  IN1 w0.13: v1(159.41,126.91) 159.37,126.91 159.27,126.81 159.27,126.36 158.73,125.82 158.73,125.58 157.63,124.49 148.02,124.49 147.42,123.88 137.29,123.88 135.99,125.17 134.54,125.17 132.72,127 132.72,128.08 133.03,128.4 133.03,129.41 132.86,129.58 132.86,130.06 v1(132.77,130.14)
  BOTTOM w0.102: UV1.D12 v1(132.77,130.14)
  BOTTOM w0.112: UV14.D5 159.41,126.81 v1(159.41,126.91)
M_WCKA1_1: length 26
  TOP w0.112: UV14.P4 v1(150.71,126.91)
  IN1 w0.13: v1(138.08,124.95) 138.29,125.16 138.29,125.37 138.6,125.68 143.51,125.68 144.18,125.02 146.79,125.02 147.3,125.53 150.6,125.53 150.82,125.75 150.82,126.8 v1(150.71,126.91)
  BOTTOM w0.089: 138.3,124.54 138.3,124.32 135.8,121.83 133.27,121.83 133.23,121.87 133.22,121.87
  BOTTOM w0.112: UV1.E3 132.98,123.44 132.98,123.7 132.87,123.81 132.69,123.81 132.58,123.7 132.58,123.3 132.66,123.21 132.66,122.78 132.63,122.75 132.63,122.45 132.9,122.18 132.9,121.95 132.98,121.87 133.22,121.87 ; UV14.P4 v1(150.71,126.91)
  BOTTOM w0.122: v1(138.08,124.95) 138.3,124.72 138.3,124.54
M_WCKA1_1#: length 26.3
  TOP w0.112: UV14.P5 v1(151.51,126.91)
  IN1 w0.13: v1(151.51,126.91) 151.37,126.91 151.04,126.58 151.04,125.66 150.69,125.31 147.39,125.31 146.88,124.8 144.09,124.8 143.42,125.47 138.69,125.47 138.5,125.28 138.5,125.1 v1(138.66,124.95)
  BOTTOM w0.089: 138.52,124.54 138.52,124.27 135.88,121.64 133.19,121.64
  BOTTOM w0.112: 133.19,121.64 133.19,121.63 132.88,121.63 132.66,121.85 132.66,122.08 132.42,122.32 132.42,122.84 132.45,122.87 132.45,123.13 132.14,123.44 UV1.F4 ; UV14.P5 v1(151.51,126.91)
  BOTTOM w0.122: v1(138.66,124.95) 138.52,124.81 138.52,124.54
M_WE#0: length 32.3
  TOP w0.102: 157.44,143.86 157.63,143.86 157.83,143.66 157.83,143.31 156.25,141.73 147.8,141.73
  TOP w0.127: 157.44,143.86 157.11,144.19 157.11,144.71 v1(157.1,144.73) 157.1,144.74 156.71,145.13 UV12.L12 ; 135.31,139.87 134.54,139.87 133.55,138.87 v1(133.34,138.87) ; 147.8,141.73 147.36,141.73
  TOP w0.14: 135.31,139.87 135.32,139.87 135.42,139.77 135.43,139.77 135.66,139.54 135.66,139.53 135.83,139.36 v2(139.84,139.36) 142.34,139.36 144.7,141.73 147.36,141.73
  BOTTOM w0.127: UV12.L12 156.71,145.12 v1(157.1,144.73) ; UV1.G25 131.82,139.71 132.49,139.71 v1(133.34,138.87)
M_WE#1: length 31.9
  TOP w0.102: v1(153.11,121.31) 153.11,121.81 152.82,122.1 152.66,122.1 152.38,122.37 152.38,123.16 152.28,123.26 148.93,123.26 148.38,122.72 148.38,122.16 147.88,121.65
  TOP w0.127: 136.58,123.65 135.77,123.65 134.74,124.68 134.74,124.98 132.79,126.92 132.37,126.92 131.9,127.39 130.91,127.39 130.61,127.68 130.61,128.2 130.1,128.71 v1(130.07,128.71) ; v1(153.11,121.31) UV14.L12 ; 147.88,121.65 147.88,121.27
  TOP w0.14: 136.58,123.65 137.81,122.42 v2(142.71,122.42) 143.69,122.42 145.26,120.84 147.74,120.84 147.88,120.98 147.88,121.27
  BOTTOM w0.102: v1(130.07,128.71) 130.42,128.37 130.42,128.32 UV1.H10
  BOTTOM w0.127: UV14.L12 v1(153.11,121.31)
MASK_BASE_LEDS#: length 304.3
  TOP w0.089: v1(69.64,28.86) v2(69.64,28.14) ; Q17.5 43.82,96.5 R71.2 43.5,96.75 U4.4 v1(42.12,96.75)
  TOP w0.102: Q21.2 56.45,33.43 56.22,33.2 v1(55.16,33.2) ; R70.2 219.11,67.47 218.83,67.75 v1(218.83,67.99) ; Q17.5 Q17.2
  IN1 w0.089: v1(42.12,96.75) 42.09,96.72 v1(37.7,96.72)
  IN2 w0.089: v1(218.83,67.99) 218.83,67.75 218.41,67.33 218.41,64.92 215.68,62.19 215.68,60.84 214.16,59.32 214.16,57.4 214.9,56.67 214.9,45.14 215.59,44.44 215.59,39.68 215.24,39.33 215.24,33.34 214.64,32.74 213,32.74 212.87,32.88 211.44,32.88 210.33,31.77 196.73,31.77 195.73,32.76 193.24,32.76 192.39,31.92 188.28,31.92 187.6,32.6 180.7,32.6 179.39,31.28 178.42,31.28 177.15,30.01 174.99,30.01 174.37,29.39 173.24,29.39 172.83,29.79 169.2,29.79 168.87,30.13 165.95,30.13 165.72,29.91 155.92,29.91 155.62,29.91 155.06,29.35 148.59,29.35 145.81,32.13 144.9,32.13 143.27,33.76 135.94,33.76 133.14,30.97 116.9,30.97 115.99,30.05 113.19,30.05 112.04,28.9 108.05,28.9 107.28,29.68 105.54,29.68 104.02,28.16 94.11,28.16 93.59,27.64 76.71,27.64 75.74,28.61 69.99,28.61 69.73,28.86 v1(69.64,28.86)
  BOTTOM w0.089: v1(37.7,96.72) 37.12,96.14 37.12,92.05 36.11,91.04 36.11,89.24 35.41,88.54 35.41,87.97 33.81,86.36 32.81,86.36 31.59,85.15 31.59,83.75 32.88,82.47 32.88,78.58 32.39,78.1 32.39,66.13 31.68,65.42 31.68,63.84 33.34,62.19 33.34,60.46 33.81,59.98 33.81,57.47 35.14,56.14 35.14,51.81 36.29,50.67 36.29,45.36 39.68,41.97 41.37,41.97 42.19,41.16 42.19,39.46 47.32,34.33 53.54,34.33 54.71,33.16 55.12,33.16 v1(55.16,33.2) 56.97,31.39 65.02,31.39 65.94,30.48 68.73,30.48 69.64,29.56 v1(69.64,28.86)
MASK_SATA_LED#: length 36.1
  TOP w0.089: RC224.1 48.02,101.44 Q22.2 ; v2(55.33,82.8) 54.6,82.07 R23.2
  TOP w0.102: UE1.56 50.6,78.61 50.42,78.61 v1(50.12,78.9) ; v1(53.83,81.77) R23.2 ; Q22.2 v1(51.55,101.44)
  BOTTOM w0.089: v1(53.83,81.77) 53.83,89.71 53.11,90.43 53.11,93.21 53.79,93.89 53.79,99.2 v1(51.55,101.44)
  BOTTOM w0.102: v1(50.12,78.9) 50.73,78.29 53.13,78.29 54.06,79.22 54.06,81.54 v1(53.83,81.77)
MCT: length 6.9
  TOP w0.089: v2(17.62,78.34) RL15.1
  TOP w0.254: RL15.1 RL14.1 16.35,77.88 16.34,77.9 v1(16.34,77.95)
  BOTTOM w0.254: CL13.1 18.13,77.19 RL15.1 RL14.1 16.34,77.2 v1(16.34,77.95)
MCT0: length 11.6
  TOP w0.089: v2(15.6,78.34) 15.6,76.54 RL14.2
  TOP w0.254: v1(16.76,76.51) 16.76,76.2 RL14.2 ; TL2.3 v1(18.31,70.59)
  IN1 w0.254: v1(16.76,76.51) 16.76,76.34 18.31,74.79 v1(18.31,70.59)
MCT1: length 12.8
  TOP w0.254: v1(17.36,76.51) 17.36,76.06 RL15.2 ; TL2.6 v1(18.47,66.78)
  IN1 w0.254: v1(17.36,76.51) 18.77,75.1 18.77,70.28 18.47,69.98 v1(18.47,66.78)
MCT2: length 12.5
  IN3 w0.254: v1(14.89,67.9) 14.89,68.33 15.78,69.22 15.78,76.12 v1(16.18,76.51)
  BOTTOM w0.254: v1(16.18,76.51) 16.18,75.97 RL19.2 ; v1(14.89,67.9) 16.01,66.78 TL1.3
MCT3: length 18.7
  TOP w0.089: v2(19.15,76.79) 18.87,76.51 v1(18.03,76.51)
  IN3 w0.254: v1(14.05,68.03) 14.05,68.11 15.38,69.43 15.38,76.55 15.82,77 17.55,77 v1(18.03,76.51)
  BOTTOM w0.254: TL1.6 15.85,70.59 14.05,68.79 v1(14.05,68.03) ; v1(18.03,76.51) 18.03,76.2 RL20.2
MDO0+: length 12.9
  IN1 w0.203: JLAN1.1 13.89,78.66 14.47,78.66 15.59,77.54 15.59,75.66 16.35,74.9 v1(16.75,74.9)
  BOTTOM w0.267: v1(16.75,74.9) 16.54,74.9 16.34,74.7 15.66,74.7 14.96,74 14.96,72.28 15.37,71.86 TL1.7
MDO0-: length 12.9
  IN1 w0.203: v1(16.75,74.32) 16.68,74.32 16.43,74.57 16.21,74.57 15.26,75.52 15.26,77.4 14.33,78.33 14.03,78.33 13.93,78.23 13.93,77.81 14.4,77.34 14.4,77.05 JLAN1.2
  BOTTOM w0.267: v1(16.75,74.32) 15.81,74.32 15.34,73.84 15.34,72.43 15.53,72.24 15.82,72.24 15.99,72.41 15.99,72.94 16.17,73.13 TL1.8
MDO1+: length 18.1
  IN2 w0.165: JLAN1.3 14.38,75.68 14.52,75.54 15.68,75.54 16.02,75.2 16.02,66.36 14.4,64.74 14.13,64.74 v1(13.97,64.57)
  BOTTOM w0.267: TL1.1 15.96,64.24 15.77,64.44 14.11,64.44 v1(13.97,64.57)
MDO1-: length 18.1
  IN2 w0.165: v1(13.97,65.16) 14.09,65.03 14.28,65.03 15.72,66.48 15.72,75.08 15.56,75.24 15.22,75.24 14.94,74.96 14.94,73.51 JLAN1.6
  BOTTOM w0.267: v1(13.97,65.16) 14.08,65.16 14.42,64.82 15.41,64.82 16.11,65.51 TL1.2
MDO2+: length 15.4
  TOP w0.267: TL2.8 16.32,64.24 16.01,64.55 15.33,64.55 14.79,65.09 14.79,66.2 14.52,66.46 14.28,66.46 14.23,66.41 14.12,66.41 v1(14.03,66.32)
  IN1 w0.203: v1(14.03,66.32) 14.17,66.46 15.18,66.46 16,67.28 16,73.22 15.05,74.18 14.53,74.18 JLAN1.4
MDO2-: length 15.4
  TOP w0.267: TL2.7 16.51,65.51 15.93,64.93 15.49,64.93 15.17,65.24 15.17,66.35 14.68,66.84 14.08,66.84 v1(14.03,66.9)
  IN1 w0.203: JLAN1.5 14.19,73.64 14.4,73.85 14.91,73.85 15.67,73.09 15.67,67.42 15.04,66.79 14.17,66.79 14.06,66.9 v1(14.03,66.9)
MDO3+: length 8.8
  TOP w0.267: TL2.2 16.11,71.86 16.05,71.8 15.4,71.15 15.4,69.4 14.83,68.83 v4(14.41,68.83) 13.49,68.83 12.95,69.37 JLAN1.7
MDO3-: length 8.7
  TOP w0.267: JLAN1.8 13.46,70.58 13.33,70.45 13.33,69.53 13.65,69.21 14.67,69.21 15.02,69.56 15.02,71.33 15.53,71.84 15.53,72.86 15.79,73.13 TL2.1
ME_FWP: length 165.2
  TOP w0.089: RE539.2 42.17,88.74 42.17,88 ; RE539.2 RC223.1 ; RE539.2 RE19.1 ; v2(127.22,31.57) 127.48,31.82 129.46,31.82 v1(129.9,32.26)
  TOP w0.102: UE1.80 43.75,85.27 43.43,85.59 43.36,85.59 43,85.94 43,87.16 v1(42.25,87.92) 42.17,88
  IN1 w0.089: v1(42.25,87.92) 42.25,88.12 41.74,88.63 36.05,88.63 v1(35.96,88.54)
  IN2 w0.089: v1(35.96,88.54) 35.28,87.86 35.28,87.23 38.2,84.31 38.2,83.37 38.87,82.7 38.87,78.89 39.1,78.66 39.1,77.81 41.54,75.36 41.54,69.04 44.45,66.14 44.45,65.88 45.78,64.55 45.78,63.11 46.14,62.75 46.14,61.55 46.67,61.03 46.67,60.9 46.67,60.9 46.67,54.15 45.58,53.05 45.58,50.56 46.16,49.99 46.16,48.06 45.75,47.65 45.75,44.06 48.25,41.56 48.25,40.28 52.46,36.07 56.19,36.07 63.13,29.13 66.85,29.13 67.71,29.99 70.22,29.99 70.6,29.62 76.02,29.62 76.15,29.49 76.95,29.49 77.16,29.28 78.15,29.28 78.87,28.55 92.75,28.55 93.99,29.8 98.95,29.8 99.67,29.07 102.65,29.07 104.17,30.59 107.7,30.59 107.85,30.44 112.28,30.44 112.81,30.97 115.59,30.97 116.89,32.26 v1(129.9,32.26)
  BOTTOM w0.089: v1(129.9,32.26) 130.79,32.26 131.4,31.66 SW3.1
ME_FWP_PCH: length 238.9
  TOP w0.089: v1(44.45,55.53) 44.45,55.86 v2(45.4,56.82) 47.02,58.44 49.32,58.44 50.92,60.04 53.73,60.04 v1(54.32,59.45) ; v1(42.45,90.71) 42.11,90.71 41.72,90.32 RC223.2 ; v1(103.25,47.4) 102.61,47.4 RC126.1
  IN1 w0.089: v1(103.25,47.4) 101.28,47.4 99.13,45.25 96.47,45.25 96.3,45.08 95.34,44.12 84.82,44.12 83.58,42.88 81.74,42.88 81.39,42.53 77.01,42.53 75.81,41.33 74.51,41.33 74.1,41.74 72.91,41.74 69.51,45.14 67.68,45.14 65.7,47.12 65.17,47.12 65.16,47.12 59.83,47.12 57.55,49.4 57.55,53.92 57.25,54.22 56.79,54.22 55.93,55.09 55.93,56.45 54.32,58.05 v1(54.32,59.45) ; v1(39.2,91.47) 39.49,91.18 41.98,91.18 v1(42.45,90.71)
  IN2 w0.089: v1(128.43,29.12) 127.97,28.66 125.29,28.66 124.19,27.55 117.79,27.55 117.28,28.06 113.99,28.06 113.36,27.44 105.11,27.44 104.35,26.67 99.71,26.67 99.14,26.1 97.71,26.1 97.15,26.66 94.68,26.66 94.2,26.18 76.1,26.18 75.36,26.91 60.12,26.91 59.02,28.01 59.02,30.08 57.25,31.85 56.96,31.85 56.02,32.79 54.73,32.79 53.55,33.97 51.71,33.97 44.81,40.87 44.81,42.14 43.1,43.85 43.1,45.11 43.56,45.57 43.56,53.88 44.45,54.77 v1(44.45,55.53)
  BOTTOM w0.089: v1(39.2,91.47) 38.93,91.21 38.17,91.21 37.82,90.85 37.82,89.43 37.5,89.11 37.5,85.58 37.93,85.15 37.93,83.05 36.16,81.28 36.16,80.15 36.57,79.74 36.57,70.75 35.66,69.84 35.66,67.72 35.66,67.72 35.66,67.7 35.82,67.53 35.82,65.28 35.78,65.24 35.78,64.4 36.58,63.6 36.58,62.92 37.48,62.02 37.7,62.02 38.9,60.81 42.7,60.81 44.56,58.96 44.56,56.7 44.83,56.43 44.83,55.91 v1(44.45,55.53) ; SW3.2 131.05,28.66 130.59,29.12 v1(128.43,29.12)
MEC_XTAL1: length 2.9
  TOP w0.112: YE1.1 31.07,70.76 32.02,69.82 CE3.1 RE47.2
MEC_XTAL1_R: length 2.9
  TOP w0.112: RE47.1 33.39,70.73 v2(34.05,71.39) 34.72,71.39 34.73,71.41 UE1.123
MEC_XTAL2: length 6.3
  TOP w0.112: YE1.2 31.5,68.26 CE4.1 RE45.1 33.16,68.95 33.66,69.45 33.66,69.68 v2(34.08,70.09) 34.59,70.61 UE1.125
MEM_SMBCLK: length 58.5
  TOP w0.112: v1(127.28,42.43) 127.28,42.43 127.28,42.44 127.52,42.44 127.6,42.37 127.6,41.98 126.48,40.86 124.47,40.86 123.39,39.79 122.74,39.79 121.91,38.95 121.91,37.61 121.09,36.8 119.86,36.8 119.75,36.91 119.75,37.14 v1(119.94,37.33)
  IN1 w0.119: v1(105.26,36.34) 105.26,36.57 104.97,36.86 104.97,37.4 105.7,38.12 106.77,38.12 108.7,40.05 108.7,40.83 111.67,43.8 114.45,43.8 116.89,41.36 116.89,40.37 118.54,38.72 118.54,38.49 119.09,37.94 119.46,37.94 119.72,37.68 119.72,37.55 v1(119.94,37.33)
  IN3 w0.076: v1(128.18,53.02) 128.18,53.04 128.47,53.33 128.68,53.33 128.77,53.23 128.77,52.76 128.52,52.51 128.52,52.09 128.3,51.87 128.3,51.42 127.15,50.26 127.15,48.93 127.19,48.89 127.19,48.68
  IN3 w0.135: 127.19,48.68 127.19,48 127.64,47.55 127.64,46.62 126.51,45.48 126.51,43.39 127.28,42.62 127.28,42.43 v1(127.28,42.43)
  BOTTOM w0.076: UC1.R7 128.21,53.16 v1(128.18,53.02)
  BOTTOM w0.112: CC94.1 105.26,35.6 v1(105.26,36.34) 105.26,36.58 105.13,36.7 104.98,36.7 104.47,36.2 102.26,36.2 102.15,36.09 101.73,36.09 101.29,35.65 101,35.64 100.95,35.64 100.88,35.71 100.8,35.71 100.09,35.01 QC1.6 ; RC29.1 128.83,41.63 128.54,41.92 128,41.92 127.48,42.44 127.28,42.44 127.28,42.43 v1(127.28,42.43)
MEM_SMBDATA: length 56.4
  TOP w0.112: v1(119.36,37.31) 119.51,37.15 119.51,36.81 119.76,36.56 121.19,36.56 122.14,37.51 122.14,38.85 122.84,39.55 123.49,39.55 124.57,40.63 126.58,40.63 127.83,41.88 127.83,42.46 127.68,42.62 v1(127.68,42.86)
  IN1 w0.119: v1(105.67,36.75) 105.43,36.75 105.22,36.96 105.22,37.29 105.8,37.87 106.87,37.87 108.95,39.95 108.95,40.72 111.78,43.55 114.35,43.55 116.64,41.26 116.64,40.27 118.29,38.62 118.29,38.39 118.99,37.7 119.36,37.7 119.48,37.58 119.48,37.42 v1(119.36,37.31)
  IN3 w0.076: v1(128.18,53.66) 128.18,53.66 128.18,53.66 128.34,53.5 128.74,53.5 128.94,53.3 128.94,52.69 128.69,52.44 128.69,52.03 128.47,51.81 128.47,51.35 127.32,50.2 127.32,49 127.36,48.96 127.36,48.79 127.46,48.69 127.46,48.68
  IN3 w0.135: 127.46,48.68 127.46,48.11 127.91,47.66 127.91,46.51 126.77,45.37 126.77,43.5 127.41,42.86 v1(127.68,42.86)
  BOTTOM w0.089: UC1.R8 128.54,54.02 128.18,53.66 v1(128.18,53.66)
  BOTTOM w0.112: v1(127.68,42.86) 127.68,42.57 128.1,42.16 128.59,42.16 RC30.1 ; v1(105.67,36.75) 105.43,36.75 105.23,36.94 104.88,36.94 104.37,36.44 102.16,36.44 102.05,36.33 101.63,36.33 101.19,35.88 101.04,35.88 101.01,35.91 100.99,36.08 100.98,36.14 QC1.3
MIC_CAP: length 5.7
  TOP w0.203: v2(25.73,17.96) 26.54,17.16 UA1.19
  TOP w0.254: v2(25.73,17.96) 25.73,18.14 25.55,18.32 24.34,18.32 24.06,18.6 24.06,19.39 23.6,19.85 CA26.1
MODEL_ID: length 20.9
  TOP w0.089: v2(34.2,76.81) 34.4,77.01 UE1.109
  TOP w0.102: RE3.2 31.74,86.33 RE4.2 32.55,86.32 CE1.1 32.57,85.79 v1(33,85.36) ; v1(38.18,76.57) 37.75,77.01 UE1.109
  IN3 w0.102: v1(38.18,76.57) 38.58,76.97 38.58,78.42 38.32,78.68 38.32,81.47 37.82,81.97 34.04,81.97 32.66,83.35 32.66,84.23 32.44,84.45 32.44,84.8 v1(33,85.36)
MSCLK: length 10.2
  TOP w0.089: v2(39.32,96.3) 39.61,96.01 39.61,95.64 RE55.2
  TOP w0.102: v1(40.5,95.36) RE55.2
  BOTTOM w0.089: 42.69,93.06 43.3,92.45 43.3,91.28 42.87,90.85 42.87,90.13 42.74,90 42.74,89.55
  BOTTOM w0.102: JDEG1.6 42.74,89.55 ; 42.69,93.06 42.69,93.95 41.29,95.36 v1(40.5,95.36)
MSDATA: length 9
  TOP w0.089: v3(41,93.61) 41,94.09 v1(40.5,94.59)
  TOP w0.102: RE62.1 RE56.2 v1(40.5,94.59)
  BOTTOM w0.102: JDEG1.7 42.24,89.43 41.52,90.14 41.52,92.06 40.88,92.7 40.88,94.21 v1(40.5,94.59)
MUX_A_EN: length 15.2
  TOP w0.089: v1(28.22,132.2) v2(27.46,132.2)
  IN3 w0.102: v1(32.53,123.42) 33.46,123.42 33.82,123.78 33.82,127.61 29.23,132.2 v1(28.22,132.2)
  BOTTOM w0.102: v1(32.53,123.42) 32.65,123.55 UT1.26 ; v1(28.22,132.2) UT3.16
MUX_B_EN: length 16.3
  TOP w0.089: v1(27.76,128.58) 27.76,131.14 28.84,132.22 v2(29.14,132.22) v1(29.75,132.22)
  IN1 w0.089: v1(35.53,127.13) 30.45,132.22 v1(29.75,132.22)
  BOTTOM w0.102: UT1.36 36.64,126.78 36.28,127.13 v1(35.53,127.13) ; v1(27.76,128.58) 27.76,127.83 27.86,127.73 28.11,127.73 28.22,127.84 UT3.10
MUX_DPEQ0: length 4
  TOP w0.089: RT24.1 RT25.1 22.2,122.48 v1(22.82,123.1)
  BOTTOM w0.102: RT23.2 23.35,123.03 23.29,123.1 v1(22.82,123.1) 22.59,122.86 UT2.14
MUX_DPEQ1: length 4.9
  TOP w0.089: RT22.1 RT21.1 18.29,126.34 v1(18.02,126.61) 17.92,126.71 v2(17.92,127.2)
  BOTTOM w0.102: RT20.2 17.79,127.1 18.02,126.87 18.02,126.61 ; 18.02,126.61 v1(18.02,126.61) ; 18.02,126.61 18.02,126.6 18.07,126.6 18.56,126.11 UT2.2
MUX_I2C_CLK: length 26
  IN3 w0.135: v1(22.1,118.16) 21.94,118.01 21.94,117.76 22.11,117.6 22.77,117.6 24.16,118.99 24.16,126.63 25.59,128.06 26.67,128.06 28.1,126.63 28.1,125.79 28.51,125.38 28.9,125.38 29.07,125.55 v1(29.08,125.55)
  BOTTOM w0.112: v1(29.08,125.55) 29.26,125.38 v4(30.45,125.38) 32.15,125.38 32.61,124.91 32.86,124.91 32.99,125.05 UT1.29 ; UT2.21 20.96,119.23 20.89,119.17 20.89,119.03 21.03,118.89 21.62,118.89 21.93,118.59 21.93,118.34 v1(22.1,118.16) 21.94,118.01 21.94,117.69 RT52.2
MUX_I2C_DATA: length 26.4
  IN3 w0.135: v1(29.08,124.96) 28.93,125.12 28.4,125.12 27.83,125.69 27.83,126.52 26.56,127.8 25.7,127.8 24.43,126.52 24.43,118.89 22.88,117.34 22,117.34 21.68,117.66 21.68,118 v1(21.52,118.16)
  BOTTOM w0.112: UT2.22 20.56,119.23 20.65,119.14 20.65,118.93 20.93,118.65 21.52,118.65 21.69,118.49 21.69,118.34 v1(21.52,118.16) 21.7,117.98 21.7,117.64 RT53.2 ; UT1.28 32.98,124.55 32.85,124.68 32.51,124.68 32.05,125.14 29.26,125.14 v1(29.08,124.96)
MUX_I2C_EN: length 4.3
  TOP w0.102: RT11.2 RT12.1 RT13.1 22.67,120.88 v1(22.86,121.06)
  BOTTOM w0.102: v1(22.86,121.06) 22.26,121.66 UT2.17
MUX_SBU1: length 45.1
  TOP w0.102: v1(8.19,120.3) 8.19,120.3 8.1,120.3 8.08,120.32 JUSBC1.A8
  IN1 w0.089: v1(8.19,120.3) 7.7,120.78 7.7,122.59 9.81,124.7 9.81,129.6 v1(12.21,132)
  IN1 w0.102: v1(21.62,132.36) 20.45,132.36 18.42,130.33 18.42,129.4 19.49,128.33 20.54,128.33 21.29,127.58 21.29,126.69 20.21,125.6 19.75,125.6 17.7,123.55 v1(17.7,118.8)
  BOTTOM w0.089: v1(12.21,132) v2(12.75,132.54) 13.01,132.8 18.93,132.8 19.37,132.36 EU4001.5
  BOTTOM w0.102: UT2.27 18.56,119.23 18.13,118.8 v1(17.7,118.8) ; v1(21.62,132.36) EU4001.6 EU4001.5
MUX_SBU2: length 48.7
  TOP w0.102: v1(6.47,122.13) 6.47,122.13 6.42,122.07 5.75,122.07 JUSBC1.B8
  IN1 w0.089: v1(22.34,118.96) 22.34,121.29 22.54,121.5 23.2,121.5 24,122.3 24,123.01 24.82,123.83 26.9,123.83 v1(27.01,123.93)
  IN2 w0.102: v1(22.34,118.96) 22.06,119.24 13.71,119.24 12.92,118.45 10.79,118.45 10.35,118.89 8.26,118.89 7.08,120.07 7.08,121.7 6.65,122.13 v1(6.47,122.13)
  IN3 w0.089: v1(22.79,118.37) 22.79,119.07 22.5,119.36 19.1,119.36 v1(17.81,118.07)
  BOTTOM w0.089: v1(27.01,123.93) 26.88,123.8 EU4002.1 ; 18.45,118.83 17.81,118.19 v1(17.81,118.07) ; v1(22.79,118.37) 22.79,116.72 23.24,116.28 24.46,116.28 v2(25.45,117.27) 26.7,118.52 26.7,121.01 26.88,121.19 26.88,122.22
  BOTTOM w0.102: UT2.26 18.96,119.2 18.77,119.01 18.63,119.01 18.45,118.83 ; EU4002.1 EU4002.9 26.88,122.22
