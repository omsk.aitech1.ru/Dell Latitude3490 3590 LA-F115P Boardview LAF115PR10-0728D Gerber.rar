# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_DATA0#_R_C: length 15.5
  TOP w0.112: RI4.2 16.07,96.6 LI2.1 15.66,96.43 15.5,96.27 15.23,96.27 RI6.1 14.57,96.22 14.43,96.22 14.21,96.44 14.21,97.21 14.2,97.22 14.2,98.27 13.98,98.49 v4(13.99,98.49) 13.75,98.73 13.75,100.85 12.94,101.66 12.26,101.66 11.68,101.08 11.68,96.08 11.56,95.96 11.44,95.96 JHDMI1.9
HDMI_DATA0_R: length 4.4
  TOP w0.112: RI5.1 16.98,95.76 LI2.3 17.47,95.93 17.6,96.07 17.74,96.07 v1(17.92,95.89) 18.14,96.1 18.54,96.1 CI4.2
  BOTTOM w0.112: RPI2.7 19.15,95.24 19,95.39 18.78,95.39 18.47,95.69 18.47,95.81 18.23,96.06 18.09,96.06 v1(17.92,95.89)
HDMI_DATA0_R_C: length 15.5
  TOP w0.112: JHDMI1.7 11.44,95.74 11.65,95.74 11.9,95.99 11.9,100.99 12.36,101.44 12.84,101.44 13.53,100.75 13.53,98.62 13.98,98.18 v4(13.98,96.82) 13.98,96.36 14.33,96 14.58,96 RI6.2 15.31,96.05 15.53,96.05 15.64,95.93 LI2.4 16.07,95.76 RI5.2
HDMI_DATA1: length 155.6
  TOP w0.112: CI6.1 19.83,91.84 20.16,92.17 21.04,92.17 v1(21.35,91.86)
  IN3 w0.076: v1(133.47,83.26) 133.47,83.15 133.7,82.93 134.2,82.93 134.58,83.32 134.58,88.09 132.68,89.99 132.68,91.97 132.59,92.06 132.52,92.06 132.35,92.24
  IN3 w0.135: 132.35,92.24 130.73,93.86 129.89,93.86 128.77,94.98 128.77,99.79 125.61,102.95 125.03,102.95 122.19,105.79 121.54,105.79 117.65,109.67 116.75,109.67 116.09,110.33 100.3,110.33 99.73,109.76 96.07,109.76 89.49,116.34 82.28,116.34 79.84,118.77 77.74,118.77 76.98,118.02 72.14,118.02 71.44,117.31 68.07,117.31 66.91,118.48 66.26,118.48 65.42,117.64 62.11,117.64 61.8,117.33 54.77,117.33 52.21,114.77 50.28,114.77 49.15,113.64 47.24,113.64 45.77,112.16 44.94,112.16 42.55,109.77 42.12,109.77 41.7,109.36 41.7,108.64 41.03,107.97 32.89,107.97 26.34,101.42 26.34,96.99 25.84,96.49 25.84,94.57 24.28,93.01 23.92,93.01 23.11,92.2 21.7,92.2 21.36,91.86 v1(21.35,91.86)
  BOTTOM w0.076: v1(133.47,83.26) 133.57,83.16 133.57,82.99 133.41,82.83 UC1.F58
HDMI_DATA1#: length 155.5
  TOP w0.112: CI5.1 20.01,92.44 v1(21.35,92.44)
  IN3 w0.076: 132.69,92.24 132.85,92.08 132.85,90.06 134.75,88.16 134.75,83.25 134.27,82.77 133.8,82.77 133.57,82.54 v1(133.57,82.35)
  IN3 w0.135: v1(21.35,92.44) 23.01,92.44 23.82,93.25 24.18,93.25 25.6,94.67 25.6,96.59 26.09,97.09 26.09,101.52 32.79,108.22 40.93,108.22 41.46,108.74 41.46,109.46 42.02,110.02 42.45,110.02 44.84,112.41 45.67,112.41 47.14,113.88 49.05,113.88 50.18,115.01 52.11,115.01 54.67,117.57 61.7,117.57 62.01,117.88 65.32,117.88 66.16,118.72 67.01,118.72 68.17,117.56 71.34,117.56 72.04,118.26 76.88,118.26 77.64,119.02 79.94,119.02 82.38,116.58 89.59,116.58 96.17,110 99.63,110 100.2,110.57 116.19,110.57 116.85,109.91 117.75,109.91 121.64,106.03 122.29,106.03 125.13,103.19 125.71,103.19 129.01,99.89 129.01,95.08 129.99,94.1 130.83,94.1 132.69,92.24
  BOTTOM w0.076: v1(133.57,82.35) 133.57,82.58 UC1.E58
HDMI_DATA1#_R: length 4.2
  TOP w0.112: RI11.1 16.98,92.6 LI4.2 17.47,92.43 17.61,92.29 17.74,92.29 17.92,92.47 v1(17.92,92.47) 17.93,92.47 18.14,92.26 18.54,92.26 CI5.2
  BOTTOM w0.112: RPI1.8 19.26,92.03 19.15,91.92 19,91.92 18.66,92.27 18.13,92.27 v1(17.92,92.47)
HDMI_DATA1#_R_C: length 5.7
  TOP w0.112: RI11.2 16.07,92.6 LI4.1 15.68,92.43 15.55,92.29 15.27,92.29 RI12.1 14.58,92.29 14.3,92.29 13.91,92.68 13.89,92.68 13.56,93.01 13.56,94.21 13.32,94.45 13,94.45 JHDMI1.6
HDMI_DATA1_R: length 4.2
  TOP w0.112: RI10.1 16.98,91.76 LI4.3 17.47,91.93 17.6,92.07 17.75,92.07 17.92,91.89 ; 17.92,91.89 v1(17.92,91.89) ; 17.92,91.89 18.07,92.04 18.55,92.04 CI6.2
  BOTTOM w0.112: RPI1.7 19.23,91.53 19.06,91.7 18.9,91.7 18.56,92.04 18.08,92.04 17.92,91.89 v1(17.92,91.89)
HDMI_DATA1_R_C: length 5.7
  TOP w0.112: RI10.2 16.07,91.76 LI4.4 15.69,91.93 15.55,92.07 15.27,92.07 RI12.2 14.58,92.07 14.19,92.07 v4(13.93,92.33) 13.34,92.92 13.34,94.12 13.23,94.23 12.98,94.23 JHDMI1.4
HDMI_DATA2: length 154
  TOP w0.112: v1(21.35,89.95) 21.16,90.13 20.19,90.13 CI8.1
  IN3 w0.076: 128.08,92.24 128.08,91.62 128.38,91.31 128.38,91.24 128.38,86.3 129.14,85.54 129.58,85.54 132.13,83 132.13,81.24 132.43,80.93 133.41,80.93 133.41,80.92 133.48,80.84 v1(133.46,80.53)
  IN3 w0.135: v1(21.35,89.95) 21.52,90.12 21.52,90.12 21.7,90.3 22.19,90.3 24.1,92.21 24.44,92.21 26.6,94.37 26.6,96.24 27.85,97.48 27.85,99.83 32.4,104.39 33.07,104.39 35.49,106.82 40.89,106.82 42.19,108.11 42.43,108.11 45.8,111.48 46.05,111.48 47.53,112.96 49.43,112.96 50.56,114.09 52.57,114.09 55.14,116.65 61.52,116.65 61.79,116.39 64.31,116.39 64.88,116.95 67.19,116.95 67.51,116.63 71.72,116.63 72.43,117.33 77.29,117.33 78.05,118.09 79.51,118.09 81.95,115.65 89.01,115.65 95.59,109.08 100.21,109.08 100.78,109.65 104.68,109.65 105.23,109.1 111.14,109.1 111.57,108.66 117.7,108.66 121.25,105.11 121.91,105.11 124.75,102.27 125.32,102.27 128.09,99.5 128.09,95 128.09,94.7 128.14,94.64 128.14,92.95 128.14,92.95 128.14,92.85 128.08,92.79 128.08,92.24
  BOTTOM w0.076: UC1.F55 133.46,80.71 v1(133.46,80.53)
HDMI_DATA2#: length 153.9
  TOP w0.112: v1(21.35,90.55) 21.15,90.35 20.19,90.35 CI7.1
  IN3 w0.076: 128.32,92.24 128.32,92.14 128.24,92.06 128.24,91.69 128.55,91.38 128.55,91.18 128.55,91.17 128.55,86.37 129.21,85.71 129.65,85.71 132.29,83.07 132.29,81.31 132.5,81.09 133.34,81.09 133.51,81.24 v1(133.53,81.47)
  IN3 w0.135: 128.32,92.24 128.32,92.69 128.38,92.75 128.38,93.05 128.38,94.74 128.33,94.8 128.33,94.9 128.33,95 128.33,99.6 125.42,102.51 124.85,102.51 122.01,105.35 121.35,105.35 117.8,108.91 111.67,108.91 111.24,109.34 105.33,109.34 104.78,109.89 100.68,109.89 100.11,109.32 95.69,109.32 89.11,115.9 82.05,115.9 79.61,118.34 77.95,118.34 77.19,117.58 72.33,117.58 71.62,116.87 67.61,116.87 67.29,117.19 64.78,117.19 64.21,116.63 61.89,116.63 61.62,116.89 55.04,116.89 52.47,114.33 50.46,114.33 49.33,113.2 47.43,113.2 45.95,111.73 45.7,111.73 42.33,108.35 42.09,108.35 40.79,107.06 35.39,107.06 32.97,104.63 32.3,104.63 27.61,99.93 27.61,97.58 26.36,96.34 26.36,94.47 24.34,92.45 24,92.45 22.09,90.55 v1(21.35,90.55)
  BOTTOM w0.076: v1(133.53,81.47) 133.82,81.18 UC1.E55
HDMI_DATA2#_R: length 4.4
  TOP w0.112: CI7.2 18.91,90.58 18.67,90.34 18.13,90.34 v1(17.92,90.54) 17.72,90.34 17.54,90.34 17.42,90.46 LI3.2 16.98,90.63 RI8.1
  BOTTOM w0.112: RPI1.6 19.15,91.03 18.92,90.81 18.74,90.81 18.29,90.36 18.12,90.36 17.94,90.54 v1(17.92,90.54)
HDMI_DATA2#_R_C: length 7.2
  TOP w0.112: JHDMI1.3 11.05,93.07 11.16,92.96 11.56,92.96 11.9,92.62 11.9,92.26 12.22,91.95 12.53,91.95 v4(13.34,91.14) 14.29,90.2 14.58,90.2 RI9.1 15.17,90.29 15.5,90.29 15.67,90.46 LI3.1 16.07,90.63 RI8.2
HDMI_DATA2_R: length 4.3
  TOP w0.112: CI8.2 18.91,89.91 18.7,90.12 18.08,90.12 v1(17.92,89.96) 17.76,90.12 17.51,90.12 17.35,89.96 LI3.3 16.98,89.79 RI7.1
  BOTTOM w0.112: RPI1.5 19.06,90.53 19.01,90.58 18.83,90.58 18.38,90.13 18.1,90.13 v1(17.92,89.96)
HDMI_DATA2_R_C: length 7.2
  TOP w0.112: RI7.2 16.07,89.79 LI3.4 15.67,89.96 15.56,90.07 15.37,90.07 RI9.2 14.58,89.97 14.19,89.97 13.42,90.75 13.4,90.75 12.99,91.16 12.99,91.18 12.44,91.73 12.12,91.73 11.68,92.17 11.68,92.53 11.47,92.74 11.16,92.74 11.05,92.63 JHDMI1.1
HDMI_HPD_B: length 36.2
  TOP w0.089: v1(22.21,113.84) 22.79,114.42 v2(23.59,114.42) 24.61,114.42 24.96,114.07 QI3.1
  IN2 w0.102: v1(14.84,110.68) 14.84,110.19 14.61,109.96 14.61,107.95 15.55,107.01 21.85,107.01 22.87,108.03 22.87,110.74 23.49,111.36 23.49,112.91 22.56,113.84 v1(22.21,113.84)
  BOTTOM w0.089: JHDMI1.19 11.59,101.35 12.16,101.92 13.61,101.92 14.56,102.87 14.56,105.21 13.82,105.95 13.82,110.21 RI16.1 14.28,110.68 v1(14.84,110.68)
HDMI_PLL_GND: length 11.6
  TOP w0.127: QI1.1 29.16,92.85 v2(29.45,93.14)
  TOP w0.254: v1(27.83,91.79) 27.54,92.08 QI1.1
  IN3 w0.254: v1(27.83,91.79) 26.67,91.79 25.38,90.51 24.55,90.51 24.23,90.19 23,90.19 22.18,89.38 20.95,89.38 v1(20.61,89.72)
HOST_DEBUG_TX: length 83.1
  TOP w0.102: v1(40.85,81) 41.93,81 43.35,82.42 UE1.81 ; RE57.2 40.29,93.07 40.5,93.28 v1(40.5,93.98)
  IN2 w0.102: v1(50.07,116.48) 49.46,117.09 47.71,117.09 44.89,114.27 44.89,112.02 43.21,110.35 43.21,101.24 40.05,98.08 40.05,94.43 v1(40.5,93.98) ; v1(40.85,81) 40.85,85.92 40.01,86.76 40.01,87.61 39.69,87.94 39.69,88.41 40.33,89.04 40.33,89.43 39.38,90.38 v1(38.9,90.38)
  IN3 w0.102: v1(38.9,90.38) 39.58,90.38 39.98,90.78 39.98,93.45 v1(40.5,93.98)
  BOTTOM w0.102: JDEG1.8 41.74,89.64 41.32,90.06 41.32,91.99 40.5,92.81 v1(40.5,93.98)
  BOTTOM w0.254: RW10.1 RW6.1 67.19,117.11 66.94,117.37 66.94,121.31 65.21,123.03 60.12,123.03 56.85,119.77 56.85,118.65 54.95,116.75 v2(53.95,116.75) 50.34,116.75 v1(50.07,116.48)
HPD_P1: length 49.5
  TOP w0.089: RT8.2 34.9,119.73 v1(34.9,119.31)
  TOP w0.102: v2(33.54,115.6) 33.54,115.65 v1(33.97,116.09) ; UT5.38 37.94,104.37 38.91,103.4 v1(38.91,102.78)
  IN2 w0.089: v1(38.91,102.78) 38.91,103.56 39,103.65
  IN2 w0.102: 39,103.65 39,109.34 38.69,109.65 30.67,109.65 29.87,110.45 29.87,112.6 29.18,113.29 29.18,114.22 30.43,115.47 33.35,115.47 v1(33.97,116.09)
  BOTTOM w0.089: RT101.2 22.51,115.68 22.6,115.77 RT114.1 23.05,115.77 23.88,114.93 28.25,114.93 30.78,117.46 32.74,117.46 33.97,116.24 v1(33.97,116.09)
  BOTTOM w0.102: v1(33.97,116.09) 34.88,116.09 35.29,116.49 35.29,117.27 35.07,117.49 35.07,119.14 v1(34.9,119.31) 34.9,119.45 35.14,119.69 UT1.18
HPOUT_L: length 36.6
  TOP w0.305: RA36.2 17.93,12.28 v1(17.93,12.78) ; v1(18.2,16.7) 18.04,16.85 v3(18.04,17.38) 18.22,17.56 18.22,17.86 19.52,19.16 19.52,20.31 19.85,20.65 19.85,22.85 20.51,23.51 DA4.2 21.01,22.76 20.3,22.06 20.3,20.49 20,20.18 20,20.04 20,19.31 v1(20.29,19.02)
  IN2 w0.305: JHP1.1 12.91,8.16 14.51,8.16 16.16,9.81 16.16,14.66 v1(18.2,16.7)
  BOTTOM w0.305: RA30.1 16.57,11.64 17.2,11.64 17.93,12.37 v1(17.93,12.78) 17.93,13.61 19.88,15.56 19.88,18.61 v1(20.29,19.02)
  BOTTOM w0.381: CA35.1 RA30.1
HPOUT_R: length 37.1
  TOP w0.305: v1(12.68,19.41) 12.68,18.93 12.38,18.62 11.3,18.62 10.99,18.32 8.89,18.32 7.96,17.4 JHP1.2 ; v1(15.03,14.74) 15.63,14.74 16.34,14.03 RA37.2 ; v1(21.01,19.55) 21.27,19.81 21.27,21.65 21.64,22.02 22.22,22.02 22.94,22.73 DA4.3 22.52,23.51 20.82,21.82 v2(20.82,20.96) 20.82,20.24 v1(20.65,20.06)
  IN2 w0.305: v1(12.68,19.41) 15.26,19.41 16.48,20.63 18.21,20.63 18.78,20.06 v1(20.65,20.06)
  BOTTOM w0.305: v1(21.01,19.55) 19.96,19.55 19.38,18.97 19.38,15.77 17.75,14.15 RA34.1
  BOTTOM w0.381: v1(15.03,14.74) 15.5,14.28 CA34.1 RA34.1
HW_ACAV_IN: length 284.3
  TOP w0.089: v2(174.14,28.88) 173.94,29.07 v1(173.94,29.79) ; DZ1.1 96.83,44.49 96.83,42.64 97.9,41.56 97.9,40.33 98.36,39.87 98.36,38.66 97.72,38.02 97.72,36.94 v1(97.47,36.69)
  TOP w0.102: UE1.128 34.93,69.41 34.82,69.3 34.82,68.85 35.24,68.44 v1(35.24,68.18) 34.83,67.78 34.83,66.8 34.76,66.72 CE32.2
  TOP w0.254: PR31.1 175.08,32.18 175.62,31.63 175.62,30.96 174.46,29.79 v1(173.94,29.79) ; PRB42.2 167.86,30.95 168.31,30.49 168.31,30.5 v1(168.33,30.5) ; v1(60.55,126.44) PUS02.2
  IN2 w0.089: 97.02,28.34 95.72,28.34 v1(95.5,28.56) ; 97.02,28.34 96.37,28.98 94.21,28.98 93.05,27.82 76.78,27.82 75.81,28.79 70.39,28.79 69.92,29.26 68.05,29.26 67.17,28.38 62.84,28.38 57.85,33.37 57.63,33.37 55.66,35.34 52.15,35.34 46.09,41.4 46.09,42.68 45.01,43.76 45.01,47.94 45.43,48.36 45.43,49.67 44.84,50.25 44.84,53.35 45.57,54.08 45.94,54.45 45.94,59.88 43.72,62.09 43.72,65.82 42.05,67.48 35.94,67.48 v1(35.24,68.18) ; 97.02,28.34 103.95,28.34 105.46,29.86 107.35,29.86 108.13,29.09 111.97,29.09 113.12,30.23 115.91,30.23 116.82,31.15 133.02,31.15 135.81,33.94 143.35,33.94 144.98,32.31 145.88,32.31 148.67,29.53 154.98,29.53 155.54,30.09 156,30.09 165.65,30.09 166.04,30.48 168.28,30.48 168.29,30.49 168.31,30.49 168.31,30.5 v1(168.33,30.5)
  IN2 w0.254: v1(173.94,29.79) 173.46,29.79 173.19,30.06 169.31,30.06 168.87,30.5 v1(168.33,30.5)
  BOTTOM w0.089: v1(35.24,68.18) 35.24,69.7 36.38,70.84 ; v1(97.47,36.69) 97.08,36.3 97.08,35.32 96.56,34.81 96.56,33.59 95.74,32.77 95.74,29.48 95.5,29.24 v1(95.5,28.56)
  BOTTOM w0.102: 36.38,70.84 36.38,79.67 35.98,80.07 35.98,81.2 35.97,81.2 35.97,81.36 37.74,83.13 37.74,85.07 37.31,85.5 37.31,89.23 37.57,89.49 37.57,91.03 38.17,91.62 38.17,92.8 38.58,93.21 38.58,95.57 39.47,96.46 39.47,100.55 40.28,101.37 41.23,101.37 42.99,103.12 42.99,109.57 43.71,110.29 43.71,115.16 44.94,116.39 44.94,121.24 46.05,122.35 48.04,122.35 49.35,123.66 50.64,123.66 52.36,125.37 53.67,125.37 53.91,125.61 56.19,125.61 57.03,126.44 v1(60.55,126.44)
HW_ACAVIN_NB: length 293.2
  TOP w0.089: v1(46.64,65.69) 46.64,66.38 46.55,66.47
  TOP w0.102: v1(46.64,65.69) 46.8,65.54 46.8,64.82 CE34.2 ; v1(42.13,71.52) 42.49,71.17 44.89,71.17 45.14,70.92 45.99,70.92 46.75,70.16 46.75,68.84 46.55,68.64 UE1.24 46.55,66.47
  TOP w0.254: v1(48.74,119.58) 49.07,119.25 PRS39.2 PRS40.1 50.36,119.38 51.02,119.38 PRS23.1 51.94,120.29 PR52.1 ; PRB40.1 163.55,36.95 163.17,36.57 v2(162.99,36.57) 162.63,36.57 162.12,36.06 v1(162.12,35.9) ; PU2.2 v1(94.69,148.38) 92.91,148.38 PR46.1
  IN2 w0.089: v1(46.64,65.69) 46.81,65.53 46.81,63.02 46.51,62.73 46.51,61.71 47.08,61.14 47.08,54.04 46.54,53.49 46.54,48.31 46.55,48.3 46.55,47.93 46.12,47.5 46.12,44.21 48.84,41.49 48.84,40.36 52.76,36.44 56.42,36.44 61.2,31.66 65.59,31.66 66.2,31.05 70.66,31.05 71.04,30.68 76.09,30.68 76.68,31.27 78.86,31.27 79.84,30.29 90.32,30.29 91.49,31.46 96.29,31.46 97.28,32.46 100.55,32.46 101.08,33 107.11,33 107.83,33.72 112.08,33.72 112.89,32.91 113.86,32.91 114.33,33.38 115.3,33.38 116.58,34.66 129.09,34.66 129.69,35.26 132.85,35.26 134.19,36.6 144.66,36.6 145.31,35.94 146.97,35.94 147.08,35.83 151.47,35.83 152.99,34.31 155.4,34.31 155.94,34.85 158.74,34.85 159.78,35.9 v1(162.12,35.9)
  IN2 w0.254: v1(80.73,147.93) 80.48,147.67 80.48,145.23 76.44,141.2 73.38,141.2 72.33,140.15 56.3,140.15 51.68,135.54 51.68,130.68 49.97,128.96 49.97,127.54 49.28,126.86 49.28,123.77 48.74,123.22 v1(48.74,119.58) 49.77,118.55 50.8,118.55 51.35,117.99 51.35,115.26 50.59,114.5 50.59,107.41 50.22,107.04 50.22,101.09 v1(49.04,99.91)
  IN3 w0.102: v1(49.04,99.91) 48.22,99.08 48.22,95.68 47.46,94.92 47.46,92.92 46.62,92.08 46.62,87.1 43.55,84.02 43.23,84.02 41.44,82.22 41.44,72.22 v1(42.13,71.52)
  IN3 w0.254: v1(80.73,147.93) 85.92,147.93 86.67,147.18 87.96,147.18 89.74,148.96 93.02,148.96 93.34,148.64 94.43,148.64 v1(94.69,148.38)
I2C0_SCL_TCH_PAD: length 31
  TOP w0.112: Q10.1 119.04,29.21 v2(119.45,29.62) 119.45,30.13 119.22,30.37 R34.2 119.24,30.72 122.15,30.72 122.26,30.83 122.26,31.12 121.7,31.68 121.7,32.58 v1(121.52,32.77)
  IN3 w0.076: 124.92,48.68 124.92,48.89 124.86,48.94 124.86,49.51 126.78,51.42 126.78,51.82 127.01,52.05 v1(127.01,52.23)
  IN3 w0.135: 124.92,48.68 124.92,48.45 124.92,46.57 124.02,45.67 124.02,43.72 123.43,43.13 123.43,41.26 122.63,40.46 122.63,39.65 122.29,39.31 122.29,37.59 123.03,36.86 123.03,34.71 121.69,33.38 121.69,32.94 v1(121.52,32.77)
  BOTTOM w0.076: v1(127.01,52.23) 127.01,52.23 UC1.U6
I2C0_SDA_TCH_PAD: length 32
  TOP w0.112: Q10.4 121.13,27.14 121.59,26.69 R33.2 121.98,26.69 122.5,27.22 122.5,31.22 121.94,31.78 121.94,32.6 v1(122.1,32.77)
  IN3 w0.076: 125.18,48.68 125.18,48.69 125.08,48.79 125.08,48.96 125.03,49.01 125.03,49.44 126.95,51.35 126.95,51.75 127.07,51.87 127.16,51.87 127.36,52.08 127.36,52.17 127.36,52.47 127.02,52.81 v1(126.91,52.81)
  IN3 w0.135: 125.18,48.68 125.18,48.34 125.18,46.46 124.28,45.56 124.28,43.61 123.69,43.02 123.69,41.15 122.89,40.35 122.89,39.54 122.55,39.2 122.55,37.7 123.29,36.97 123.29,34.6 121.95,33.27 121.95,32.92 v1(122.1,32.77)
  BOTTOM w0.076: UC1.U7 127.01,52.88 126.98,52.88 v1(126.91,52.81)
I2C_CTL_EN: length 3.6
  TOP w0.089: RT77.1 RT78.1
  TOP w0.102: RT78.1 43.11,112.6 43.11,111.59 v2(43.03,111.5) 42.34,110.81 UT5.2
I2C_SCL_TP: length 4.9
  TOP w0.112: R46.2 121.84,28.44 Q10.6 120.67,28.44 120.18,28.94 v1(120.18,29.1) 120.18,29.45 120.51,29.78 v2(120.95,29.78)
  BOTTOM w0.112: JTP1.6 120.05,29.23 v1(120.18,29.1)
I2C_SDA_TP: length 6.4
  TOP w0.112: v1(119.59,29.1) 119.59,27.37 119.37,27.14 Q10.3 118.43,27.14 v2(118.13,27.44) 117.65,27.44 117.22,27.87 R47.2
  BOTTOM w0.112: v1(119.59,29.1) 119.05,29.65 JTP1.7
I_ADP: length 5.4
  TOP w0.089: CE25.1 31.2,78.13 RE51.1
  TOP w0.102: UE1.110 34.76,76.61 34.6,76.45 34.07,76.45 33.37,77.15 33.37,77.34 v2(33.08,77.63) 32.52,77.63 RE51.1
I_ADP_R: length 237.6
  TOP w0.089: v1(34.46,75.63) 33.96,75.63 33.3,76.29 v2(32.06,76.29) 32.02,76.33 RE51.2
  IN2 w0.089: v1(34.46,75.63) 35.31,74.79 35.31,68.97 36.42,67.86 42.21,67.86 44.08,65.99 44.08,62.25 46.3,60.03 46.3,54.3 45.21,53.21 45.21,50.4 45.79,49.82 45.79,48.21 45.37,47.79 45.37,43.91 46.46,42.83 46.46,41.55 52.3,35.7 55.96,35.7 57.84,33.82 57.92,33.82 62.99,28.74 66.98,28.74 67.86,29.62 70.07,29.62 70.54,29.16 75.97,29.16 76.14,28.98 76.94,28.19 92.9,28.19 94.06,29.35 96.53,29.35 97.17,28.71 102.8,28.71 104.32,30.22 107.55,30.22 107.7,30.07 112.43,30.07 112.96,30.6 115.76,30.6 116.67,31.51 132.02,31.51 134.81,34.31 143.5,34.31 145.13,32.68 146.04,32.68 148.77,29.94 154.87,29.94 155.41,30.48 155.7,30.48 156.44,31.22 157.13,31.22 157.29,31.06 164.07,31.06 164.65,31.64 167.22,31.64 167.27,31.69 168.11,31.69 168.99,32.58 172.22,32.58 172.46,32.34 177.21,32.34 179.42,34.55 181.27,34.55 182.01,35.29 186.06,35.29 186.72,35.96 191.74,35.96 192.12,35.58 194.4,35.58 194.52,35.46 198.4,35.46 199.09,34.77 202.49,34.77 202.92,34.34 204.1,34.34 204.61,34.85 208.05,34.85 209.01,35.8 209.01,36.19 210.09,37.27 210.09,40.92 211.92,42.76 211.92,45.14 v1(211.23,45.82)
  BOTTOM w0.089: v1(211.23,45.82) 210.79,45.38 PRB35.2
I_BATT: length 4.9
  TOP w0.102: UE1.114 34.93,75.01 34.72,75.22 33.94,75.22 v2(33.51,75.65) 33.26,75.65 33.09,75.48 32.27,75.48 CE30.1 32.07,74.47 RE54.1
I_BATT_R: length 243.7
  TOP w0.089: v2(30.08,74.43) 30.32,74.2 v1(30.56,74.2)
  TOP w0.102: RE54.2 30.92,74.2 v1(30.56,74.2)
  IN2 w0.089: v1(34.46,74.82) 35.12,74.16 35.12,68.89 36.35,67.66 42.13,67.66 43.9,65.89 43.9,62.17 46.12,59.95 46.12,54.37 45.76,54.01 45.02,53.27 45.02,50.33 45.61,49.74 45.61,48.28 45.19,47.87 45.19,43.84 46.27,42.76 46.27,41.48 52.23,35.52 55.77,35.52 57.74,33.55 57.93,33.55 62.92,28.56 67.05,28.56 67.94,29.44 70,29.44 70.46,28.97 75.89,28.97 76.07,28.8 76.86,28.01 92.98,28.01 94.14,29.17 96.45,29.17 97.09,28.52 102.88,28.52 104.39,30.04 107.43,30.04 108.2,29.27 111.89,29.27 113.04,30.42 115.83,30.42 116.75,31.33 132.1,31.33 134.89,34.12 143.42,34.12 145.05,32.5 145.96,32.5 148.74,29.71 154.9,29.71 155.49,30.29 155.77,30.29 156.51,31.03 157.05,31.03 157.21,30.87 164.15,30.87 164.73,31.46 167.29,31.46 167.34,31.5 168.17,31.5 169.05,32.38 172.16,32.38 172.42,32.13 177.25,32.13 179.49,34.36 181.33,34.36 182.08,35.11 186.13,35.11 186.4,35.38 190.28,35.38 190.83,34.83 192.4,34.83 192.84,35.27 198.33,35.27 199.02,34.59 202.41,34.59 202.85,34.15 204.22,34.15 204.73,34.67 207.23,34.67 207.91,33.99 209.23,33.99 209.62,34.39 209.62,36.54 210.27,37.19 210.27,40.76 212.12,42.62 212.12,45.54 v1(211.26,46.41)
  IN3 w0.102: v1(34.46,74.82) 34.43,74.86 31.23,74.86 v1(30.56,74.2)
  BOTTOM w0.102: v1(211.26,46.41) 211.26,46.41 211.61,46.05 211.61,45.59 211.21,45.18 211.21,44.83 PRB34.2
I_SYS: length 58.1
  TOP w0.089: v1(179.68,53.63) 179.86,53.46 v2(180.34,53.46)
  TOP w0.254: v1(179.68,53.63) 179.43,53.63 179.02,54.04 PRZ11.2
  IN2 w0.254: v1(179.68,53.63) 184.12,53.63 185.26,54.78 185.26,58.22 187.04,60 195.23,60 196.53,58.71 201.06,58.71 202.18,57.59 202.8,57.59 205.06,55.33 205.89,55.33 206.75,56.19 208.92,56.19 210.35,54.77 210.35,52.03 209,50.68 209,43.25 209.88,42.37 v1(209.88,42.1)
  BOTTOM w0.203: v1(179.68,53.63) 179.69,53.63 179.53,53.79 179.53,53.86 179.14,54.25 179.13,54.25 178.99,54.39 178.95,54.39 178.95,54.4 178.85,54.4 178.76,54.5 PUZ01.46
  BOTTOM w0.254: v1(209.88,42.1) 209.88,42.57 209.47,42.98 209.47,43.92 209.03,44.36 PRB31.2
ICCMAX_1A_CPU: length 3.1
  TOP w0.089: v2(170.39,55.91) 170.68,56.2 v1(171.07,56.2)
  TOP w0.254: PRZ67.1 171.32,56.05 171.22,56.05 v1(171.07,56.2)
  BOTTOM w0.203: v1(171.07,56.2) 171.17,56.1 PUZ01.19
ICCMAX_1B_CPU: length 3.1
  TOP w0.089: v1(171.07,56.78) 170.87,56.78 v2(170.42,57.23)
  TOP w0.254: v1(171.07,56.78) 171.48,56.78 PRZ68.1
  BOTTOM w0.203: PUZ01.20 171.55,56.5 171.26,56.78 v1(171.07,56.78)
ICCMAX_2PH_CPU: length 4.1
  TOP w0.089: v1(171.07,55.61) 170.75,55.61 170.39,55.25 v2(170.39,54.59)
  TOP w0.254: v1(171.07,55.61) 171.28,55.4 171.28,55.2 PRZ66.1
  BOTTOM w0.203: v1(171.07,55.61) 171.15,55.7 PUZ01.18
ICSP_CLK: length 3.7
  TOP w0.089: 34.32,80.91 34.6,80.62 34.6,80.46 34.86,80.21 UE1.101
  TOP w0.102: 34.32,80.91 v2(33.67,81.56) 33.67,81.57 33.67,81.57 33.67,82.21 RE60.2
ICSP_CLR: length 4
  TOP w0.102: UE1.87 40.95,84.76 41.65,85.46 v2(41.65,85.52) 41.3,85.87 40.78,85.87 RE61.2
ICSP_DAT: length 4.3
  TOP w0.089: UE1.102 34.74,79.81 v2(34.17,80.38) 33.86,80.69
  TOP w0.102: 33.86,80.69 33.12,81.42 RE63.2
ILIM_1A_CPU: length 4.8
  TOP w0.254: v1(173.22,60.55) 172.93,60.27 v2(172.93,59.8) 173.31,59.41 PRZ56.1 174.68,59.41 PCZ32.1
  BOTTOM w0.203: v1(173.22,60.55) 173.43,60.34 173.43,59.98 174.03,59.38 PUZ01.27
ILIM_1B_CPU: length 2.9
  TOP w0.254: PRZ05.1 PCZ05.1 179.62,56.24 v1(179.76,56.1)
  BOTTOM w0.203: v1(179.76,56.1) PUZ01.42
ILIM_2PH_CPU: length 3.5
  TOP w0.089: v1(176.57,51.23) 176.4,51.4 v2(176.03,51.4)
  BOTTOM w0.203: PRZ28.2 176.57,51.07 v1(176.57,51.23) 176.57,51.85 176.03,52.4 PUZ01.5
ILMT_+1VALW: length 3.9
  TOP w0.089: PRH04.1 164.87,48.92 v2(165.36,48.42)
  TOP w0.254: PRH04.1 164.37,49.46 v1(164.25,49.59)
  BOTTOM w0.254: PUH01.12 163.81,50.25 164.25,49.82 v1(164.25,49.59) 164.55,49.28 PRH03.2
IMON_VGA: length 5
  TOP w0.089: v2(67.06,129.07) 67.6,128.53 PRV16.1
  TOP w0.203: PUV01.10 71.24,127.9 71.14,128 69.7,128 69.17,128.53 PCV20.1
  TOP w0.254: PCV20.1 PRV16.1
IMVP_VR_ON: length 73.1
  TOP w0.089: v1(157.16,99.75) 156.85,100.06 v2(156.85,100.44)
  IN1 w0.254: v1(146.71,94.49) 147.27,95.05 147.27,98 147.97,98.71 148.54,98.71 149.76,99.92 149.99,99.92 150.38,100.31 156.6,100.31 v1(157.16,99.75)
  IN2 w0.254: v1(180.91,60.31) 180.56,60.65 180.56,61.17 178.44,63.29 176.59,63.29 175.97,63.92 175.97,64.83 172.99,67.81 172.99,69.75 170.22,72.52 170.22,82.25 169.07,83.41 169.07,86.57 169.33,86.84 169.33,88.89 169.33,88.91 169.33,88.95 169.23,90.41 169.2,90.85 169.02,93.67 164.54,98.15 159.95,98.15 158.35,99.75 v1(157.16,99.75)
  BOTTOM w0.254: PRZ22.2 180.91,59.46 v1(180.91,60.31) ; RC107.2 148.35,94.24 148.1,94.49 v1(146.71,94.49)
INT_TP#: length 9.2
  TOP w0.089: R39.2 123.62,27.39 Q9.3 123.62,28.62 124.1,29.1 ; v2(126.02,30.03) 125.03,30.03 v1(124.1,29.11)
  TOP w0.102: v1(124.1,29.11) 124.1,29.1
  BOTTOM w0.089: JTP1.4 122.05,29.81 122.26,29.6 123.61,29.6 v1(124.1,29.11)
INTRUDER#: length 33
  TOP w0.089: RC91.1 98.76,43.1 v2(98.12,43.1) 97.98,43.24 97.98,43.72 98.16,43.91 v1(98.37,43.91)
  IN3 w0.135: v1(98.37,43.91) 98.37,48.17 100.59,50.39 105.63,50.39 107.01,51.77 107.01,53.2 108.23,54.42 110.63,54.42 112.82,56.62 113.79,56.62 114.91,57.74 114.91,57.94 116.06,59.09 118.18,59.09 v1(118.61,59.51)
  BOTTOM w0.102: v1(118.61,59.51) UC1.AP16
IO_CBL_DET#: length 107.8
  TOP w0.089: v1(132.9,43.04) 132.14,42.27 v1(132.14,41.4) 133.14,40.39 133.14,39.65 133.58,38.22 133.61,38.18 133.68,38.12 133.95,37.72 134.07,37.51 134.36,37.16 135.56,35.96 136.19,35.96 136.42,35.72 144.37,35.72 144.56,35.53 146.95,35.53 147.06,35.42 v3(147.86,35.42) 148.4,35.42 149.72,34.1 149.72,32.59 151.27,31.05 v1(151.27,30.36)
  IN1 w0.089: v1(205.8,37.74) 205.8,36.22 203.67,34.08 201.56,34.08 200.3,35.34 198.21,35.34 196.94,36.62 192.64,36.62 192.27,36.24 186.4,36.24 186.18,36.03 183.85,36.03 183.27,36.6 178.53,36.6 177.39,35.47 173.91,35.47 173.42,34.98 167.9,34.98 167.86,35.02 163.99,35.02 163.07,34.09 161.68,34.09 161.59,34.18 157.71,34.18 154.5,30.97 153.27,30.97 153.01,30.71 151.58,30.71 151.27,30.4 v1(151.27,30.36)
  BOTTOM w0.076: UC1.U3 127.52,51.29 127.32,51.1 127.32,50.82 127.26,50.76 127.26,50.53 127.32,50.47 127.32,50.17 127.29,50.13 127.29,49.49 128.1,48.68 129.6,48.68
  BOTTOM w0.089: v1(132.14,41.4) 133.09,40.44 133.09,38.3 RC206.1 ; v1(205.8,37.74) 205.58,37.74 205.24,37.4 JIOB1.9 ; 129.6,48.68 130.16,48.11 131.23,48.11 132.22,47.12 132.22,43.26 132.44,43.04 v1(132.9,43.04)
IOUT_1A_CPU: length 5.2
  TOP w0.089: PRZ50.1 177.21,60.16 v2(177.83,60.16)
  TOP w0.254: PRZ50.1 175.68,59.41 PCZ25.1 175.6,59.47 175,60.06 v1(175,60.35)
  BOTTOM w0.203: PUZ01.30 175.23,59.52 175,59.75 v1(175,60.35)
IOUT_1B_CPU: length 4.7
  TOP w0.089: v1(179.72,57.5) 179.72,58.86 v2(179.55,59.04)
  TOP w0.254: PCZ12.1 PRZ15.1 179.35,57.13 v1(179.72,57.5)
  BOTTOM w0.203: v1(179.72,57.5) 179.31,57.5 179.11,57.3 PUZ01.39
IOUT_2PH_CPU: length 4.2
  TOP w0.089: v2(175.61,52.66) 175.98,52.29 PCZ14.1
  TOP w0.254: PCZ14.1 177.2,52.29 177.23,52.32 PRZ23.1 v1(178.42,52.32)
  BOTTOM w0.203: v1(178.42,52.32) 177.8,52.32 177.63,52.5 PUZ01.1
IR_CAM_DETECT#: length 121.5
  TOP w0.089: v1(146.77,38.34) v2(147.48,38.34) 149.25,36.57 149.25,36.38 151.58,34.04 151.58,32.72 153.46,30.84 v1(153.46,30.5)
  TOP w0.102: v1(128.15,43.29) 128.15,43.29 128.7,43.29 RC200.1
  IN2 w0.089: v1(210.64,47.39) 209.79,46.55 209.79,44.43 211.13,43.08 211.13,42.3 209.9,41.07 209.9,37.87 207.96,35.92 206.55,35.92 205.8,35.18 201.93,35.18 201.71,34.95 199.17,34.95 197.9,36.22 194.67,36.22 194.28,35.83 192.12,35.83 191.81,36.14 186.65,36.14 186.05,35.55 182,35.55 181.26,34.81 179.41,34.81 177.2,32.6 172.46,32.6 172.28,32.77 168.66,32.77 167.83,31.94 167.25,31.94 167.14,31.82 164.58,31.82 163.99,31.24 157.36,31.24 157.21,31.4 155.91,31.4 155.43,30.92 153.88,30.92 v1(153.46,30.5) ; v1(128.15,43.29) 128.3,43.29 129.41,42.18 133.1,42.18 133.64,42.72 133.64,43.4 134.05,43.81 134.56,43.81 134.82,44.07 134.82,44.6 134.83,44.61 134.83,44.62 v1(134.85,44.62) 135.14,44.92 135.57,44.92 136.25,44.23 138.32,44.23 141.13,41.42 141.13,39.85 141.86,39.11 145.14,39.11 145.44,38.82 146.29,38.82 v1(146.77,38.34)
  BOTTOM w0.076: 131.93,48.76 131.93,48.82 131.71,49.04 130.56,49.04 129.47,50.13 129.47,50.21 129.47,50.22 129.47,50.47 129.47,50.48 129.47,50.73 129.22,50.99 128.86,50.99 128.75,51.1 128.75,51.72 128.97,51.94 UC1.P4
  BOTTOM w0.102: 131.93,48.76 133.28,47.41 133.28,45.65 134.3,44.64 134.82,44.64 134.83,44.62 v1(134.85,44.62)
  BOTTOM w0.305: v1(210.64,47.39) 211.2,47.95 JEDP1.26
IR_GND:
  vias: v1(213.47,48.79) v1(213.52,48.21)
ISEN1_VGA: length 13.1
  TOP w0.089: v1(69.62,119.25) v2(69.62,118.33)
  TOP w0.203: PCV23.1 71.01,125.79 71.23,126 72.48,126 73.18,126.7 PUV01.13
  TOP w0.254: v1(70.27,126.41) 70.27,126.18 70.66,125.8 PCV23.1 ; PRV22.2 69.71,119.34 v1(69.62,119.25)
  BOTTOM w0.254: v1(70.27,126.41) 69.62,125.76 v1(69.62,119.25)
ISEN2_VGA: length 14.7
  TOP w0.089: v2(66.85,118.65) 66.85,119.82 67.36,120.33 67.67,120.33 PRV03.2
  TOP w0.203: PUV01.12 72.78,126.73 72.39,126.35 71.28,126.35 70.79,126.84 69.92,126.84 v1(69.71,126.63) PCV22.1
  TOP w0.254: v1(69.01,121.05) 68.4,121.05 PRV03.2
  BOTTOM w0.254: v1(69.01,121.05) 68.77,121.29 68.77,123.62 69.21,124.06 69.21,125.89 69.71,126.39 v1(69.71,126.63)
ISOLATE#: length 5.5
  TOP w0.089: v2(25.7,88.76) 24.95,88.01 RL4.1 24.14,87.52 24.14,86.76 RL3.2
  TOP w0.102: UL1.20 24.4,84.84 24.6,85.03 RL3.2
JACK_PLUG: length 15
  TOP w0.254: RA39.2 16.97,17.88 17.92,18.83 17.92,20.43 18.71,21.23 DA7.3 19.06,20.78 18.56,20.27 v3(18.56,19.19) 18.56,18.88 17.56,17.89 17.56,17.38 16.42,16.24 15.76,16.24 14.59,17.41 13.41,17.41 13.41,17.4 JHP1.5
JACK_PLUG_DET: length 11.7
  TOP w0.254: JHP1.6 10.66,17.4 10.66,17.41 10.76,17.41 11.5,18.14 12.7,18.14 13.8,19.24 v3(14.51,19.24) 14.8,19.24 16.38,20.81 16.38,20.98 16.65,21.24 17.12,21.24 DA7.2 17.13,20.89 15.71,19.46 RA40.2
JTAG_CLK: length 7.4
  TOP w0.089: v2(44.19,94.57) 43.81,94.19 v1(43.81,94.06) 43.81,93.91 43.57,93.67 RPE7.3
  BOTTOM w0.089: 43.81,93.52 44.24,93.09 44.24,90.87 43.89,90.52
  BOTTOM w0.102: 43.81,93.52 v1(43.81,94.06) ; 43.89,90.52 43.89,89.82 43.74,89.67 JDEG1.4
JTAG_TCK: length 10.5
  TOP w0.089: RV369.1 125,119.36 v3(124.84,119.53)
  TOP w0.102: RV369.1 126.65,118.73 126.65,117.71 126.84,117.53 127.67,117.53 v1(127.86,117.72)
  BOTTOM w0.102: v1(127.86,117.72) 127.97,117.82 127.97,121.45 127.75,121.67 127.75,122.67 128.14,123.06 UV1.L3
JTAG_TDI: length 28.5
  TOP w0.102: v1(45.24,93.7) 44.87,93.7 44.57,93.4 RPE7.1 ; v1(33.44,84.64) 34.15,84.64 v3(34.25,84.54) 34.25,83.7 RE60.1
  IN1 w0.102: v1(45.24,93.7) 44.47,94.47 42.99,94.47 42.62,94.11 42.62,93.72 41.8,92.9 35.95,92.9 v1(35.57,92.51)
  IN2 w0.102: v1(35.57,92.51) 35.57,92.47 33.78,90.68 33.78,85.61 33.44,85.26 v1(33.44,84.64)
  BOTTOM w0.102: v1(45.24,93.7) 45.24,92 45.53,91.71 45.53,90.17 44.74,89.38 JDEG1.2
JTAG_TDI_GPU: length 10.1
  TOP w0.089: v1(128.46,117.13) v3(129.98,117.13)
  BOTTOM w0.102: UV1.L5 128.44,123.89 128.44,123.22 128.43,123.21 128.43,122.79 128.44,122.77 128.44,122.47 128.21,122.23 128.21,121.77 128.46,121.51 v1(128.46,117.13) 128.46,117.08 127.86,116.48 RP34.7
JTAG_TDO: length 25.7
  TOP w0.089: v1(36.15,92.51) 36.18,92.51 v3(36.89,93.23) ; RPE7.4 43.07,93.88 v1(43.18,93.99)
  TOP w0.102: RE63.1 33.12,83.7 v1(33.44,84.01)
  IN1 w0.102: v1(43.18,93.99) 41.84,92.65 36.29,92.65 v1(36.15,92.51)
  IN2 w0.102: v1(33.44,84.01) 34.22,84.79 34.22,90.58 v1(36.15,92.51)
  BOTTOM w0.089: v1(43.18,93.99) 43.18,93.3 43.77,92.7 43.77,91.07 43.41,90.71 43.41,90.02 43.24,89.85 JDEG1.5
JTAG_TDO_GPU: length 9.2
  TOP w0.089: v1(128.91,117.53) 128.91,117.66 v3(128.35,118.22)
  BOTTOM w0.102: UV1.K4 128.71,123.57 128.71,123.2 128.63,123.12 128.63,122.87 128.65,122.86 128.65,122.39 128.44,122.18 128.44,121.82 128.66,121.6 128.66,117.94 128.91,117.69 v1(128.91,117.53) 128.91,117.03 128.36,116.47 RP34.8
JTAG_TMS: length 16.6
  TOP w0.089: v1(40.53,91.65) 40.53,91.59 v2(41.04,91.08)
  TOP w0.102: RE61.1 40.89,87.81 v1(40.97,87.81) ; v1(44.29,93.71) 44.07,93.48 RPE7.2
  IN1 w0.102: v1(40.53,91.65) 41.32,92.44 41.97,92.44 43.04,93.51 44.09,93.51 v1(44.29,93.71)
  IN2 w0.102: v1(40.97,87.81) 40.74,88.04 40.74,88.71 40.72,88.73 40.72,90.19 40.99,90.47 40.99,91.19 v1(40.53,91.65)
  BOTTOM w0.102: v1(44.29,93.71) 44.74,93.26 44.74,89.99 44.24,89.49 JDEG1.3
JTAG_TMS_GPU: length 7.8
  TOP w0.089: v1(127.86,117.12) v3(127.29,116.54)
  BOTTOM w0.102: RP34.6 127.36,116.62 v1(127.86,117.12) 128.27,117.52 128.27,121.43 127.98,121.72 127.98,122.44 UV1.L1
JTAG_TRSTB: length 11.2
  TOP w0.089: v3(126.27,118.27) 126.27,117.56 126.69,117.14 v1(127.15,117.14)
  BOTTOM w0.102: UV1.L6 128.14,124.67 127.71,124.25 127.71,122.92 127.52,122.73 127.52,121.62 127.71,121.43 127.71,118.11 127.48,117.88 127.48,117.47 v1(127.15,117.14) 126.86,116.85 RP34.5
KB_BL_CTRL#: length 24.4
  TOP w0.254: Q8.1 85.78,47.8 EC3001.1 86.13,48.14 v3(87.22,48.14) 87.52,47.84 87.52,45.3 89.2,43.62 89.91,43.62 92.11,41.42 92.11,37.85 91.72,37.45 90.39,37.45 89.89,36.94 89.89,35.79 v1(90.09,35.58)
  BOTTOM w0.254: JKBBL1.4 91.15,34.52 v1(90.09,35.58)
KB_DET#: length 88.2
  TOP w0.089: v1(90.57,36.78) 90.94,37.14 91.84,37.14 92.38,37.68 92.38,41.03 v1(92.59,41.24) ; v1(123.12,47.3) 122.96,47.3 122.22,46.56 RC45.1 122.22,45.84 122.7,45.35 v3(124.16,45.35)
  IN2 w0.102: v1(92.59,41.24) 93.45,40.38 96.05,40.38 98.58,42.91 105.27,42.91 105.49,42.69 107.83,42.69 111.14,46 113.27,46 113.7,46.43 117.53,46.43 117.8,46.7 118.88,46.7 119.48,46.1 121,46.1 121.23,46.33 123.5,46.33 123.61,46.43 123.61,47.05 123.35,47.3 v1(123.12,47.3)
  BOTTOM w0.076: 124.3,48.68 124.3,49.28 124.01,49.57 124.01,50.09 123.99,50.12 123.99,50.41 124.16,50.92 124.16,51.51 123.75,51.92 UC1.AD4
  BOTTOM w0.089: v1(90.57,36.78) 90.57,37.06 89.51,38.13 84.85,38.13 83.96,37.23 82.61,37.23 81.8,36.42 81.8,33.21 81.45,32.86 80.25,32.86 79.83,32.44 75.81,32.44 75.64,32.62 69.08,32.62 68.35,33.35 59.94,33.35 59.75,33.54 JKB1.1
  BOTTOM w0.102: v1(123.12,47.3) 123.67,47.3 123.91,47.54 123.91,47.82 124.3,48.21 124.3,48.68
KB_LED_BL_DET: length 67
  IN1 w0.089: v1(125.67,42.24) 125.31,42.24 125.04,42.52 125.04,43.81 126.02,44.79 126.02,45.97 127.69,47.65 127.69,48.67 128.81,49.79 128.81,50.22 128.58,50.45 127.16,50.45 126.29,51.32 126.29,53.37 v1(125.83,53.83)
  IN2 w0.089: v1(125.67,42.24) 123.69,40.27 122.46,40.27 121.95,39.76 121.5,39.76 120.72,40.54 119.65,40.54 119.05,41.15 118.47,41.15 117.64,40.31 117,40.31 114.36,42.95 112.14,42.95 109.38,40.19 109.38,39.52 109.32,39.45 107.66,37.79 105.71,37.79 105.63,37.71 98.78,37.71 98.31,38.17 97.3,38.17 96.6,37.47 95.16,37.47 v1(94.95,37.27)
  BOTTOM w0.089: v1(94.95,37.27) 95.21,37.02 95.21,36.29 94.5,35.57 94.5,34.26 93.44,33.21 89.56,33.21 88.18,34.58 88.18,35.96 R26.1 87.42,35.99 R27.1 ; v2(126.22,42.73) 125.73,42.24 v1(125.67,42.24) ; v1(125.83,53.83) 126.05,53.83 126.25,54.02 UC1.W8
KB_LED_DET_C: length 9.1
  BOTTOM w0.127: v3(94.41,36.23) 94.41,36 94.05,35.64 JKBBL1.2
  BOTTOM w0.254: JKBBL1.2 94.05,34.26 93.51,33.71 89.99,33.71 89.07,34.63 R26.2
KB_LED_PWM: length 87.6
  TOP w0.089: v2(91.02,40.67) 91.13,40.67 91.61,41.16 v1(91.61,41.25) 91.61,41.38 89.75,43.25 89.01,43.25 85.43,46.83 Q8.2 ; v1(49.91,74) 50.1,73.81 UE1.44
  IN2 w0.089: v1(49.91,74) 50.01,73.89 50.01,71.85 50.33,71.53 50.33,69.48 51.48,68.33 51.48,65.27 51.54,65.21 51.54,60.82 51.26,60.53 51.26,56.61 51.71,56.15 51.71,51.15 52.38,50.49 52.38,48.55 52.99,47.94 52.99,43.48 55.36,41.11 58.27,41.11 58.5,40.88 61.52,37.86 70.54,37.86 70.98,37.42 73.1,37.42 73.6,37.92 79.55,37.92 81.99,40.36 81.99,40.91 82.73,41.65 91.2,41.65 v1(91.61,41.25)
KBLR_XTAL_IN: length 12.4
  BOTTOM w0.076: 136.48,48.68 136.32,48.82 134.94,49.7 134.81,49.7 134.56,49.95 134.56,51.65 134.48,51.72 134.24,51.72 134.16,51.65 134.16,51.4 UC1.E3
  BOTTOM w0.112: 136.48,48.68 136.9,48.32 138.47,47.19 v2(139.64,46.44) 141.89,45 RC25.1
KBLR_XTAL_IN_R: length 3.5
  BOTTOM w0.112: YC3.3 144.97,44.38 144.43,44.38 RC22.2 144.32,44.49 143.7,44.49 RC25.2 143.66,44.52 143.66,44.37 144.35,43.67 CC17.1
KBLR_XTAL_OUT: length 12.6
  BOTTOM w0.076: 137.25,48.68 137.24,48.68 136.27,49.19 135.39,49.75 135.34,49.8 135.29,49.88 135.15,50.45 135.14,50.61 135.14,50.64 135.15,50.77 135.3,51.77 135.32,51.82 135.43,51.99 135.52,52.19 135.52,52.33 135.49,52.39 135.42,52.49 135.3,52.76 135.25,53.11 UC1.C7
  BOTTOM w0.112: 137.25,48.68 140.2,46.71 v2(141.3,45.97) 141.69,45.71 142.42,45.29 RC26.1
KBLR_XTAL_OUT_R: length 5.1
  BOTTOM w0.112: YC3.1 146.37,45.06 144.67,45.06 RC22.1 144.32,45.25 143.7,45.25 RC26.2 143.66,45.65 CC18.1
KSI0: length 78.8
  TOP w0.089: RPE1.4 35.29,64.59 35.39,64.69
  TOP w0.102: UE1.98 36.58,81.41 36.69,81.52 37.22,81.52 37.49,81.25 v1(37.49,80.75) ; 35.39,64.69 v2(35.94,65.24) 36.15,65.45 36.15,68.26 v1(36.77,68.88)
  IN2 w0.089: v1(37.49,80.75) 36.51,80.75 36.06,80.31 36.06,69.58 v1(36.77,68.88)
  BOTTOM w0.089: JKB1.9 66.15,34.56 66.05,34.67 65.72,34.67 65.4,35 65.17,35 64.94,35.23 63.63,35.23 63.37,35.49 62.35,35.49 61.67,36.17 60.48,36.17 60.26,36.39 56.12,36.39 54.8,37.71 48.52,37.71 45.84,40.39 45.84,47.75 46.2,48.11 46.2,50.6 45.68,51.12 45.68,51.75 46.33,52.4 46.33,57 46.02,57.31 46.02,59.64 43.37,62.29 43.12,62.29 43.12,62.29 42.96,62.29 42.96,62.29 41.43,62.29 40.89,62.83 40.89,63.77 37.68,66.98 37.68,67.97 v1(36.77,68.88)
KSI1: length 76.6
  TOP w0.102: UE1.99 36.85,81.01 v1(36.98,81.14) ; RPE1.3 35.79,64.41 36.61,65.23 v2(36.61,66.38) 36.61,68.08 v1(36.77,68.24)
  IN2 w0.089: v1(36.77,68.24) 35.88,69.13 35.88,80.52 36.5,81.14 v1(36.98,81.14)
  BOTTOM w0.089: JKB1.7 64.55,34.64 64.32,34.86 63.48,34.86 63.21,35.13 62.2,35.13 61.97,35.36 61.52,35.8 60.33,35.8 60.11,36.03 55.97,36.03 54.69,37.3 48.41,37.3 45.48,40.24 45.48,47.9 45.83,48.26 45.83,50.44 45.31,50.96 45.31,51.9 45.96,52.55 45.96,56.85 45.65,57.15 45.65,59.47 43.2,61.92 41.28,61.92 40.52,62.68 40.52,63.62 39.88,64.26 39.05,64.26 37.97,65.34 37.08,65.34 36.8,65.62 36.8,68.21 v1(36.77,68.24)
KSI2: length 59.9
  TOP w0.089: v1(45.03,48.55) 44.22,48.55 v3(44.18,48.59)
  TOP w0.102: v1(36.71,64.78) 36.29,64.35 RPE1.2 ; UE1.6 39.35,66.13 v1(39.72,65.76)
  IN1 w0.102: v1(36.71,64.78) 37.28,65.35 38.98,65.35 39.39,65.76 v1(39.72,65.76)
  BOTTOM w0.089: v1(36.71,64.78) 37.81,64.78 38.37,64.22 38.37,62.88 38.76,62.5 40.18,62.5 41.13,61.56 43.03,61.56 45.29,59.3 45.29,57 45.6,56.69 45.6,52.7 44.95,52.06 44.95,50.81 45.47,50.29 45.47,48.98 v1(45.03,48.55) 44.97,48.48 44.97,47.29 45.11,47.15 45.11,40.08 48.3,36.89 54.58,36.89 55.81,35.66 59.95,35.66 60.18,35.44 61.37,35.44 62.06,34.75 62.82,34.75 62.95,34.62 JKB1.5
KSI3: length 61.6
  TOP w0.089: v2(37.91,66.19) 37.61,66.19 v1(37.22,65.79) ; 39.75,66.46 v1(39.85,66.36)
  TOP w0.102: RPE1.1 36.79,64.23 37.11,64.55 37.11,65.68 v1(37.22,65.79) ; UE1.7 39.75,66.46
  IN1 w0.102: v1(39.85,66.36) 39.84,66.36 38.78,66.36 38.22,65.79 v1(37.22,65.79)
  BOTTOM w0.089: JKB1.8 65.35,34.56 64.86,35.05 63.55,35.05 63.29,35.31 62.27,35.31 61.6,35.98 60.41,35.98 60.18,36.21 56.04,36.21 54.75,37.5 48.47,37.5 45.66,40.31 45.66,47.83 46.02,48.18 46.02,50.52 45.5,51.04 45.5,51.83 46.14,52.48 46.14,56.92 45.84,57.23 45.84,59.56 43.29,62.11 41.35,62.11 40.71,62.75 40.71,63.69 39.92,64.47 39.14,64.47 37.82,65.79 v1(37.22,65.79)
KSI4: length 80.4
  TOP w0.102: RPE2.1 30.96,83.75 31.01,83.7 31.01,83.41 30.83,83.23 30.83,82.7 v2(30.92,82.61) 30.92,79.99 32.98,77.94 33.79,77.94 34.22,78.37 34.22,78.74 34.49,79.01 UE1.104 36.56,79.01 36.89,79.33 37.8,79.33 38.2,78.94 v1(38.2,78.21)
  BOTTOM w0.089: v1(38.2,78.21) 39.32,77.09 39.32,72.4 36.2,69.29 36.2,68.01 36.38,67.83 36.38,65.06 36.33,65.01 36.33,64.63 36.58,64.38 36.92,64.38 38.19,63.11 38.19,62.81 38.7,62.3 40.12,62.3 41.05,61.37 42.94,61.37 45.11,59.2 45.11,56.92 45.41,56.62 45.41,52.78 44.71,52.08 44.71,50.48 44.57,50.33 44.57,47.29 44.93,46.93 44.93,40.01 48.24,36.69 54.52,36.69 55.74,35.48 59.88,35.48 60.1,35.25 61.29,35.25 62.15,34.4 JKB1.4
KSI5: length 82.9
  TOP w0.102: v1(37.61,78.92) 36.77,78.92 36.46,78.61 UE1.105 ; v1(32.07,79.45) v2(31.34,80.17) 31.15,80.37 31.15,82.14 31.23,82.22 31.23,83.98 30.95,84.25 RPE2.2
  IN3 w0.102: v1(32.07,79.45) 34.21,79.45 34.74,78.92 v1(37.61,78.92)
  BOTTOM w0.089: JKB1.6 63.75,34.48 63.57,34.65 63.43,34.65 63.15,34.93 62.13,34.93 61.45,35.62 60.25,35.62 60.03,35.84 55.89,35.84 54.63,37.1 48.35,37.1 45.29,40.16 45.29,47.98 45.65,48.34 45.65,50.37 45.13,50.89 45.13,51.98 45.78,52.63 45.78,56.77 45.47,57.08 45.47,59.38 43.11,61.74 41.2,61.74 40.26,62.68 38.83,62.68 38.56,62.96 38.56,64.29 37.75,65.1 36.94,65.1 36.58,65.45 36.58,67.89 36.39,68.08 36.39,69.22 39.5,72.33 39.5,77.73 38.3,78.92 v1(37.61,78.92)
KSI6: length 82.3
  TOP w0.089: v1(32.07,80.03) 32.1,80.03 32.69,80.62 v2(32.69,80.72)
  TOP w0.102: UE1.107 37.53,77.81 v1(37.6,77.74) ; RPE2.3 30.99,84.75 31.42,84.32 31.42,82.09 31.35,82.02 31.35,80.75 v1(32.07,80.03)
  IN3 w0.102: v1(32.07,80.03) 31.69,79.65 31.69,79.2 31.96,78.93 34.03,78.93 35.22,77.74 v1(37.6,77.74)
  BOTTOM w0.089: JKB1.3 61.35,34.67 60.95,35.07 60.03,35.07 59.8,35.29 55.66,35.29 54.47,36.49 48.19,36.49 44.74,39.93 44.74,46.85 44.39,47.21 44.39,50.41 44.53,50.55 44.53,52.16 45.23,52.86 45.23,56.54 44.92,56.85 44.92,59.13 42.87,61.18 40.01,61.18 39.91,61.29 39.91,61.95 39.75,62.12 38.62,62.12 38.01,62.73 38.01,63.03 36.88,64.17 36.53,64.17 36.15,64.55 36.15,65.09 36.2,65.14 36.2,67.69 36.02,67.87 36.02,69.37 39.13,72.48 39.13,76.83 38.23,77.74 v1(37.6,77.74)
KSI7: length 82.1
  TOP w0.102: v1(38.18,77.22) 37.56,77.22 37.37,77.41 UE1.108 ; v1(32.08,80.93) 31.91,80.93 31.67,81.17 v2(31.67,81.52) 31.67,84.68 31.1,85.25 RPE2.4
  IN3 w0.102: v1(32.08,80.93) 31.48,80.33 31.48,79.12 31.87,78.73 32.78,78.73 34.29,77.22 v1(38.18,77.22)
  BOTTOM w0.089: v1(38.18,77.22) 38.95,76.45 38.95,72.56 35.84,69.44 35.84,67.8 36.01,67.63 36.01,65.2 35.97,65.16 35.97,64.47 36.76,63.68 36.76,63 37.56,62.2 37.78,62.2 38.98,61 42.78,61 44.74,59.03 44.74,56.77 45.05,56.47 45.05,52.93 44.35,52.23 44.35,50.63 43.73,50.02 43.73,43.6 44.56,42.77 44.56,39.86 48.13,36.28 54.41,36.28 55.59,35.11 59.73,35.11 59.95,34.89 60.27,34.89 60.55,34.6 JKB1.2
KSO0: length 67.9
  TOP w0.089: v3(67.42,38.21) 67.66,37.97 v1(67.66,36.33)
  TOP w0.102: v1(40.8,71.26) 39.14,69.59 38.03,69.59 37.75,69.31 UE1.2 ; RPE3.8 44.64,62.97 v1(44.78,63.1)
  IN3 w0.102: v1(44.78,63.1) 44.15,63.73 44.15,66.18 41.72,68.61 41.72,70.33 v1(40.8,71.26)
  BOTTOM w0.089: v1(44.78,63.1) 44.79,63.1 45.8,63.1 47.67,61.23 47.67,58.03 48,57.7 48,57.15 49.3,55.85 49.3,48.46 52.85,44.91 52.85,41.55 53.88,40.52 54.9,39.49 55.34,39.49 56.8,38.04 60.94,38.04 61.14,37.83 66.16,37.83 v1(67.66,36.33) 70.87,36.33 72.22,34.98 73.11,34.98 73.35,34.74 JKB1.18
KSO1: length 63
  TOP w0.089: v3(66.2,36.94) 66.33,36.81 v1(66.33,36.34)
  TOP w0.102: UE1.14 42.55,69.27 v1(42.1,69.72) ; v1(45.16,62.6) 45.14,62.58 RPE3.7
  IN3 w0.102: v1(45.16,62.6) 45.16,62.6 45.16,63.6 44.37,64.39 44.37,66.23 42.1,68.5 v1(42.1,69.72)
  BOTTOM w0.089: JKB1.16 71.75,34.73 70.71,35.77 67.37,35.77 67.2,35.95 66.72,35.95 v1(66.33,36.34) 66.33,36.53 65.39,37.47 60.99,37.47 60.79,37.67 56.65,37.67 55.21,39.11 48.93,39.11 47.72,40.32 47.72,44.77 48.48,45.53 48.48,46.85 47.61,47.73 47.61,57.58 47.3,57.88 47.3,60.46 v1(45.16,62.6)
KSO2: length 65.2
  TOP w0.089: v1(67.08,36.32) 67.08,35.73 v3(67.29,35.52)
  TOP w0.102: v1(42.1,70.3) 42.19,70.3 42.95,69.54 UE1.15 ; RPE3.6 45.64,62.47 v1(45.77,62.59)
  IN3 w0.102: v1(45.77,62.59) 45.4,62.96 45.4,63.64 44.57,64.47 44.57,66.31 42.49,68.39 42.49,70 42.19,70.3 v1(42.1,70.3)
  BOTTOM w0.089: JKB1.17 72.55,34.63 72.41,34.77 72.17,34.77 70.98,35.96 67.45,35.96 67.08,36.32 v1(67.08,36.32) 65.75,37.65 61.07,37.65 60.87,37.85 56.72,37.85 55.27,39.31 48.99,39.31 47.91,40.39 47.91,44.65 48.68,45.42 48.68,46.92 47.79,47.81 47.79,57.65 47.48,57.96 47.48,60.88 v1(45.77,62.59)
KSO3: length 69.4
  TOP w0.089: v3(64.42,36.94) 65.13,36.94 v1(65.73,36.34)
  TOP w0.102: v1(46.22,63.23) 46.22,62.27 46.14,62.19 RPE3.5 ; UE1.16 43.35,69.72 v1(42.13,70.94)
  IN3 w0.102: v1(46.22,63.23) 44.76,64.69 44.76,66.4 42.69,68.47 42.69,70.38 v1(42.13,70.94)
  BOTTOM w0.089: JKB1.15 70.95,34.76 70.12,35.59 67.3,35.59 67.12,35.77 66.3,35.77 v1(65.73,36.34) 65.73,36.47 64.92,37.29 60.92,37.29 60.71,37.49 56.57,37.49 55.16,38.91 48.88,38.91 47.54,40.24 47.54,44.08 46.94,44.68 46.94,47.29 47.42,47.78 47.42,57.5 47.12,57.81 47.12,60.11 44.28,62.95 44.28,63.26 44.5,63.48 45.97,63.48 v1(46.22,63.23)
KSO4: length 68
  TOP w0.089: RPE4.8 53.58,68.9 v2(52.64,67.95)
  TOP w0.102: v1(47.68,71.65) 47.73,71.71 49.94,71.71 50.65,71.01 UE1.37 52.17,71.01 52.41,70.77 52.41,70.06 53.27,69.2 RPE4.8
  BOTTOM w0.089: JKB1.11 67.75,34.63 67.65,34.73 67.12,34.73 66.82,35.03 65.88,35.03 65.55,35.36 65.32,35.36 65.09,35.6 63.78,35.6 63.52,35.86 62.5,35.86 61.83,36.53 60.63,36.53 60.41,36.76 56.27,36.76 54.91,38.11 48.63,38.11 46.21,40.54 46.21,47.6 46.69,48.08 46.69,57.2 46.39,57.5 46.39,59.81 45.67,60.52 43.46,62.73 43.46,64.98 46.5,68.02 46.5,70.47 v1(47.68,71.65)
KSO5: length 68.3
  TOP w0.089: v1(46.14,51.65) 46.14,52.73 v3(46.58,53.17)
  TOP w0.102: RPE4.7 53.27,69.7 52.69,70.29 52.69,70.83 52.11,71.41 UE1.38 50.65,71.41 50.06,72 48.63,72 48.4,72.22 v1(47.81,72.22)
  BOTTOM w0.089: v1(47.81,72.22) 47.6,72.22 46.31,70.94 46.31,68.12 43.26,65.07 43.26,62.66 46.2,59.72 46.2,57.38 46.51,57.08 46.51,52.01 v1(46.14,51.65) 46.14,51.07 46.38,50.83 46.38,48.03 46.02,47.67 46.02,40.46 48.58,37.91 54.86,37.91 56.19,36.57 60.33,36.57 60.56,36.35 61.75,36.35 62.42,35.68 63.44,35.68 63.7,35.41 65.01,35.41 65.25,35.18 65.47,35.18 65.8,34.85 66.74,34.85 66.95,34.64 JKB1.10
KSO6: length 69.6
  TOP w0.089: v1(69.01,34.81) 69.12,34.7 v3(69.12,34.22)
  TOP w0.102: v1(48.07,70.54) 47.23,71.37 47.23,72.55 47.38,72.7 48.19,72.7 48.71,72.19 50.18,72.19 50.56,71.81 UE1.39 52.11,71.81 52.94,70.98 52.94,70.49 53.23,70.2 RPE4.6
  BOTTOM w0.089: JKB1.13 69.35,34.47 v1(69.01,34.81) 68.72,35.1 67.27,35.1 66.97,35.4 66.03,35.4 65.7,35.73 65.55,35.73 65.32,35.96 63.93,35.96 63.67,36.23 62.65,36.23 61.96,36.92 60.76,36.92 60.56,37.12 56.42,37.12 55.02,38.52 48.74,38.52 46.57,40.69 46.57,47.45 47.06,47.93 47.06,57.35 46.75,57.65 46.75,59.96 43.87,62.84 43.87,64.82 46.95,67.89 46.95,69.42 v1(48.07,70.54)
KSO7: length 80.9
  TOP w0.089: v1(52.73,75.81) 52.76,75.79 v2(53.41,75.79) ; UE1.50 50.38,76.21 49.91,76.67 45.38,76.67 v1(44.99,76.28)
  TOP w0.102: v1(52.84,71.62) 53.2,71.26 53.2,70.8 53.29,70.7 RPE4.5 ; UE1.50 52.11,76.21 52.51,75.81 v1(52.73,75.81)
  IN1 w0.089: v1(52.84,71.62) 52.84,71.67 52.23,72.27 52.23,75.31 v1(52.73,75.81)
  BOTTOM w0.089: v1(44.99,76.28) 44.99,75.76 46.3,74.46 46.3,73.86 47.56,72.6 47.97,72.6 48.19,72.38 48.19,71.22 46.68,69.71 46.68,67.91 43.67,64.9 43.67,62.79 46.57,59.89 46.57,57.58 46.88,57.27 46.88,48.01 46.39,47.52 46.39,40.61 48.69,38.32 54.97,38.32 56.34,36.94 60.49,36.94 60.71,36.72 61.9,36.72 62.58,36.04 63.59,36.04 63.86,35.78 65.24,35.78 65.47,35.55 65.62,35.55 65.95,35.22 66.89,35.22 67.2,34.91 68.38,34.91 68.55,34.74 JKB1.12
KSO8: length 89.5
  TOP w0.089: v3(62.06,36.46) 62.23,36.62 v1(62.78,36.62)
  TOP w0.102: UE1.46 50.58,74.61 49.56,75.63 v1(45.74,75.63) ; v1(45.2,86.21) 45.02,86.21 44.81,86.42 RPE6.8
  BOTTOM w0.089: v1(45.2,86.21) 44.87,86.55 43.29,86.55 43.07,86.33 43.07,85.85 43.29,85.63 43.58,85.63 43.81,85.4 43.81,83.45 42.95,82.58 42.95,79.61 45.74,76.82 v1(45.74,75.63) 46.52,74.86 46.52,73.9 47.64,72.78 48.04,72.78 48.44,72.38 48.44,70.31 48.1,69.97 47.85,69.97 47.23,69.35 47.23,67.88 44.07,64.73 44.07,62.9 46.94,60.04 46.94,57.73 47.24,57.42 47.24,47.86 46.76,47.37 46.76,44.61 47.35,44.01 47.35,40.17 48.82,38.7 55.1,38.7 56.5,37.31 60.64,37.31 60.84,37.1 62.31,37.1 v1(62.78,36.62) 62.82,36.62 63.18,36.97 64.97,36.97 65.32,36.62 65.32,36.21 65.63,35.91 65.78,35.91 66.11,35.58 67.05,35.58 67.22,35.41 69.54,35.41 70.15,34.79 JKB1.14
KSO9: length 79
  TOP w0.102: v1(47.68,80.46) 48.55,81.34 UE1.68 48.55,85.01 v3(48.44,85.12) 48.44,85.75 RE15.1
  BOTTOM w0.089: JKB1.24 78.15,34.74 77.79,35.1 76.3,35.1 74.57,36.83 72.01,36.83 70.4,38.45 68.42,38.45 67.94,38.93 61.6,38.93 61.4,39.13 57.26,39.13 55.8,40.59 55.4,40.59 53.95,42.05 53.95,45.37 50.4,48.92 50.4,52.1 51.13,52.83 51.13,58.6 50.05,59.68 50.05,65.38 50.71,66.04 50.71,74.55 45.77,79.49 45.77,80.1 46.13,80.46 v1(47.68,80.46)
KSO10: length 79.7
  TOP w0.089: v1(51.11,62.41) 50.43,62.41 v3(50.24,62.23)
  TOP w0.102: v1(47.64,79.88) 46.86,80.65 46.86,82.53 46.95,82.61 UE1.72 46.95,84.52 47.79,85.36 RPE5.8
  BOTTOM w0.089: JKB1.26 79.75,34.94 79.22,35.47 76.45,35.47 74.72,37.2 72.17,37.2 70.55,38.81 68.57,38.81 68.09,39.3 61.75,39.3 61.55,39.5 57.41,39.5 55.95,40.96 55.8,40.96 55.55,40.96 54.31,42.2 54.31,45.52 50.77,49.07 50.77,51.94 51.51,52.69 51.51,58.74 50.42,59.83 50.42,61.72 v1(51.11,62.41) 51.11,74.72 47.3,78.53 47.3,79.54 v1(47.64,79.88)
KSO11: length 78.1
  TOP w0.102: v1(46.25,79.85) 46.15,79.95 UE1.74 46.15,84.72 v3(46.65,85.22) 47.29,85.87 RPE5.7
  BOTTOM w0.089: v1(46.25,79.85) 46.25,79.27 50.89,74.63 50.89,65.97 50.24,65.31 50.24,59.76 51.31,58.68 51.31,52.75 50.58,52.02 50.58,48.99 54.13,45.45 54.13,42.12 55.48,40.78 55.87,40.78 57.33,39.32 61.47,39.32 61.68,39.11 68.01,39.11 68.5,38.63 70.48,38.63 72.09,37.02 74.64,37.02 76.38,35.28 78.49,35.28 78.95,34.82 JKB1.25
KSO12: length 75.7
  TOP w0.089: v1(49.21,56.47) v3(49.21,55.84)
  TOP w0.102: v1(44.78,78.74) 45.75,79.71 UE1.75 45.75,85.23 46.79,86.27 RPE5.6
  BOTTOM w0.089: v1(44.78,78.74) 45.19,78.74 46.72,77.2 46.72,73.96 47.71,72.96 48.15,72.96 48.62,72.49 48.62,69.17 47.88,68.43 47.88,58.14 49.21,56.82 v1(49.21,56.47) 49.49,56.2 49.49,48.53 53.03,44.99 53.03,41.63 54.98,39.68 55.42,39.68 56.88,38.22 61.02,38.22 61.22,38.02 67.33,38.02 67.81,37.53 69.92,37.53 72.29,35.16 73.8,35.16 74.15,34.81 JKB1.19
KSO13: length 78
  TOP w0.089: v1(49.09,60.08) 50,60.08 v3(50.12,59.95)
  TOP w0.102: v1(44.74,79.8) 45.47,80.53 45.47,82.48 45.35,82.6 UE1.76 45.35,85.33 46.3,86.28 RPE5.5
  BOTTOM w0.089: JKB1.22 76.55,34.62 76.43,34.74 75.96,34.74 74.99,35.71 72.62,35.71 70.25,38.08 68.27,38.08 67.78,38.57 61.45,38.57 61.25,38.77 57.1,38.77 55.65,40.23 55.25,40.23 53.58,41.89 53.58,45.22 50.03,48.76 50.03,56.84 48.54,58.34 48.54,59.53 v1(49.09,60.08) 49.49,60.48 49.49,64.29 49.17,64.61 49.17,72.77 48.43,73.51 47.94,73.51 47.31,74.15 47.31,77.39 44.9,79.8 v1(44.74,79.8)
KSO14: length 78.7
  TOP w0.089: v3(48.37,59.04) 48.83,59.49 v1(49.08,59.49)
  TOP w0.102: RPE6.6 43.81,86.33 44.03,86.11 44.03,85.77 44.95,84.84 UE1.77 44.95,82.56 45.25,82.27 45.25,81.16 44.77,80.69 v1(44.74,80.69)
  BOTTOM w0.089: v1(44.74,80.69) 45.41,80.02 45.41,79.55 47.54,77.41 47.54,75.47 50.33,72.68 50.33,68.64 49.35,67.66 49.35,64.69 49.67,64.37 49.67,60.09 v1(49.08,59.49) 49.49,59.09 49.49,57.65 50.22,56.92 50.22,48.84 53.76,45.29 53.76,41.97 55.32,40.41 55.72,40.41 57.18,38.95 61.32,38.95 61.52,38.75 67.86,38.75 68.34,38.27 70.32,38.27 71.94,36.65 74.49,36.65 76.22,34.92 76.99,34.92 77.35,34.55 JKB1.23
KSO15: length 83.7
  TOP w0.089: v1(49.11,60.67) 48.77,60.67 v3(48.52,60.92)
  TOP w0.102: UE1.86 41.35,84.87 41.37,84.89 41.37,84.91 41.54,85.08 41.99,85.08 42.11,85.2 v1(42.11,85.3) ; v1(44.68,85.94) 44.31,86.31 RPE6.7
  IN1 w0.102: v1(44.68,85.94) 44.15,86.47 43.21,86.47 42.11,85.37 v1(42.11,85.3)
  BOTTOM w0.089: JKB1.21 75.75,34.6 74.83,35.53 72.45,35.53 70.07,37.9 68.19,37.9 67.71,38.38 61.37,38.38 61.17,38.59 57.03,38.59 55.57,40.04 55.17,40.04 53.4,41.82 53.4,45.14 49.85,48.69 49.85,56.69 48.36,58.19 48.36,59.92 v1(49.11,60.67) 49.28,60.85 49.28,64.24 48.99,64.53 48.99,72.7 48.36,73.33 47.87,73.33 47.13,74.07 47.13,77.32 45.11,79.33 44.24,79.33 43.31,80.26 43.31,82.39 44.24,83.32 44.24,85.5 v1(44.68,85.94)
KSO16: length 88.7
  TOP w0.089: 43.31,86.19 v1(43.47,86.03) ; v3(47.79,62.67) 47.97,62.49 v1(48.43,62.49)
  TOP w0.102: UE1.92 38.95,81.59 v1(40.01,80.53) ; RPE6.5 43.31,86.19
  IN3 w0.102: v1(43.47,86.03) 42.19,86.03 40.01,83.85 v1(40.01,80.53)
  BOTTOM w0.089: JKB1.20 74.95,34.85 74.45,35.34 72.37,35.34 70,37.72 67.89,37.72 67.4,38.2 61.3,38.2 61.09,38.4 56.95,38.4 55.49,39.86 55.1,39.86 53.21,41.74 53.21,45.07 49.67,48.61 49.67,56.62 48.17,58.11 48.17,62.23 v1(48.43,62.49) 48.64,62.7 48.64,63.65 48.08,64.21 48.08,68.35 48.81,69.07 48.81,72.59 48.25,73.15 47.79,73.15 46.92,74.01 46.92,77.26 45.03,79.15 44.16,79.15 43.13,80.18 43.13,82.47 44.04,83.38 44.04,85.46 v1(43.47,86.03)
L_BKLT_CTRL: length 205.1
  TOP w0.102: v1(179.39,70.65) 178.55,70.65 R8.1
  IN1 w0.089: v1(168.21,28.12) 168.59,27.74 172.75,27.74 173.57,28.56 176.77,28.56 177.19,28.14 179.37,28.14 180.18,28.95 180.18,30.08 182.07,31.97 183.23,31.97 183.24,31.97 184.58,31.97 185.27,31.28 192.96,31.28 193.43,30.81 210.07,30.81 212.26,33 214.56,33 215.26,33.7 215.26,35.75 217.2,37.69 217.2,37.7 218.09,38.59 218.09,39.55 219.81,41.27 219.81,46.76 220.29,47.24 220.29,54.99 218.54,56.74 215.73,56.74 214.33,58.14 208.78,58.14 208.4,57.76 203.57,57.76 203.11,58.22 196.97,58.22 193.97,61.22 192.42,61.22 191.95,61.7 191.95,62.33 190.57,63.7 183.83,63.7 180.39,67.14 180.39,69.65 v1(179.39,70.65)
  IN3 w0.089: v1(129.17,55.73) 129.62,55.27 129.62,54.21 129.78,54.06 130.27,54.06 130.65,53.68 130.65,52.68 130.74,52.58 130.74,52.03 130.36,51.65 130.36,51.11 130.5,50.97 130.5,49.62 130.55,49.57 130.55,46.42 129.94,45.81 129.94,42.7 129.79,42.55 129.79,42.22 128.83,41.27 128.83,40.52 128.35,40.04 127.85,40.04 127.71,40.18 126.54,40.18 126.16,39.8 126.16,39.44 125.86,39.14 125.86,38.49 126.08,38.28 126.08,37.85 v1(125.7,37.47)
  BOTTOM w0.102: v1(125.7,37.47) 125.68,37.44 125.68,36.7 126.86,35.52 128.11,35.52 129.54,34.09 135.06,34.09 135.32,33.83 135.63,33.83 135.86,33.6 135.86,32.77 134.1,31.01 134.1,30.57 134.52,30.15 136.47,30.15 139.95,33.63 v2(141.16,33.63) 143.15,33.63 148.52,28.25 155.65,28.25 157.83,26.07 166.16,26.07 v1(168.21,28.12) ; v1(129.17,55.73) 128.81,55.73 UC1.R11
