# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_ODT0: length 67.7
  IN3 w0.175: v1(107,73.87) 107.31,73.87 107.46,73.73 107.46,73.72 107.65,73.52 107.65,73.15 107.35,72.84 105.15,72.84 103.16,70.85 102.86,70.85
  IN3 w0.183: 102.86,70.85 101.23,70.85 100.67,70.29 92.58,70.29 91.29,69 83.35,69 82.82,69.53 79.79,69.53 79.77,69.51 79.07,69.51 78.89,69.33 78.89,69.07 78.7,68.89 78.34,68.89 78.16,69.07 78.16,69.33 77.97,69.51 77.02,69.51 77.02,69.51 72.32,69.51 72.14,69.33 72.14,69.07 71.96,68.89 71.59,68.89 71.41,69.07 71.41,69.33 71.23,69.51 65.82,69.51 65.52,69.22 65.52,68.71 64.88,68.07 64.38,68.07 64.2,68.25 64.2,68.72 v1(63.86,69.06)
  BOTTOM w0.076: UC1.BA42 114.42,73.42 114.28,73.27 114.27,73.27 114.27,73.27 114.02,73.15 114.02,73.15 113.63,73.15 113.52,73.25 112.86,73.25 112.8,73.31 111.88,73.31 111.46,73.73 111.18,73.73 v2(110.5,73.05) 110.34,72.89 105.14,72.89 105.06,72.97 105.06,73.44 105.14,73.52 106.93,73.52 107,73.6 v1(107,73.87)
  BOTTOM w0.183: v1(63.86,69.06) 63.37,69.55 63.37,69.9 63.55,70.07 65.01,70.07 65.16,69.92 65.16,69.66 65.33,69.49 JDIMM2.155
DDR_B_ODT1: length 68.4
  IN3 w0.076: 103.35,69.67 103.35,69.99 105.22,71.86 109.43,71.86 109.8,72.22 110.43,72.22 110.8,71.85 112.35,71.85 112.9,72.39 112.9,73.93 112.82,74 v1(112.09,74)
  IN3 w0.175: 64.03,66.49 63.86,66.67 v1(63.86,66.89)
  IN3 w0.183: 64.03,66.49 64.17,66.36 65.93,66.36 66.12,66.54 66.12,67.19 66.3,67.37 66.94,67.37 66.99,67.41 68.5,67.41 68.56,67.47 70.07,67.47 70.17,67.37 70.47,67.07 71.37,67.07 71.78,67.47 72.79,67.47 73,67.25 73.69,67.25 73.9,67.47 74.77,67.47 74.93,67.31 75.74,67.31 75.9,67.47 77.33,67.47 77.73,67.07 79.22,67.07 80.29,68.15 82.24,68.15 82.78,67.61 91.87,67.61 92.28,68.03 93.15,68.9 101.25,68.9 101.81,69.46 102.27,69.46 102.37,69.36 102.37,69.36 102.53,69.19 103.04,69.19 103.35,69.51 103.35,69.67
  BOTTOM w0.076: v1(112.09,74) 112.22,74.13 112.52,74.13 113.08,73.58 113.56,73.58 113.66,73.68 113.82,73.68 113.82,73.68 114.02,73.68 114.11,73.65 114.13,73.63 114.35,73.63 114.46,73.68 114.67,73.68 114.82,73.61 114.91,73.63 115.14,73.86 115.26,73.86 115.43,73.69 115.52,73.69 115.59,73.63 115.59,73.48 115.52,73.4 115.52,73.11 115.59,73.03 115.79,73.03 115.87,73.11 UC1.AW42
  BOTTOM w0.183: v1(63.86,66.89) 63.39,67.36 62.92,67.36 62.75,67.53 62.75,67.99 62.92,68.16 63.79,68.16 64.59,67.36 64.92,67.36 65.55,67.99 JDIMM2.161
DDR_B_PAR: length 71.5
  IN3 w0.175: v1(68.69,74.63) 68.69,74.31 68.86,74.14 69.6,74.14 69.97,74.51 ; 103.37,75.11 103.75,75.49 104.71,75.49 105.45,76.23 111.05,76.23 111.22,76.06 111.22,75.29 111.07,75.14 110.19,75.14 110.02,74.97 110.02,74.55 110.19,74.37 111.93,74.37 112.1,74.55 112.1,75.85 112.28,76.03 112.63,76.03 112.8,75.85 112.8,74.68 112.98,74.51 113.33,74.51 113.5,74.68 113.5,75.27 113.68,75.45 114.18,75.45 114.36,75.27 114.36,74.15 114.53,73.98 116.11,73.98 116.25,74.12 116.25,74.48 116.39,74.62 117.51,74.62 117.78,74.34 118.29,74.34 118.63,74.68 v1(118.63,75.03)
  IN3 w0.183: 103.37,75.11 87.87,75.11 87.54,75.44 87.13,75.44 86.94,75.62 86.94,76.04 86.76,76.22 85.34,76.22 85.15,76.04 85.15,75.62 84.97,75.44 84.6,75.44 84.42,75.62 84.42,76.04 84.24,76.22 83.87,76.22 83.69,76.04 83.69,75.62 83.51,75.44 83.14,75.44 82.96,75.62 82.96,76.04 82.78,76.22 82.41,76.22 82.23,76.04 82.23,75.62 82.04,75.44 81.68,75.44 81.5,75.62 81.5,76.04 81.31,76.22 81,76.22 80.71,75.92 80.33,75.92 79.97,76.29 79.57,76.29 79.32,76.04 79.32,75.55 79.22,75.44 78.23,75.44 78.15,75.52 78.15,75.78 77.93,76 77.53,76 77.21,75.69 76.77,75.69 76.59,75.87 76.59,75.96 76.41,76.14 76.04,76.14 75.86,75.96 75.86,75.87 75.68,75.69 75.31,75.69 75.13,75.87 75.13,76.11 74.94,76.29 74.58,76.29 74.4,76.11 74.4,75.87 74.21,75.69 73.85,75.69 73.66,75.87 73.66,75.94 73.48,76.12 73.11,76.12 72.93,75.94 72.93,75.87 72.75,75.69 72.15,75.69 70.97,74.51 69.97,74.51
  BOTTOM w0.076: v1(118.63,75.03) 118.63,75.02 118.98,74.6 UC1.AP43
  BOTTOM w0.183: JDIMM2.143 67.34,74.49 67.71,74.12 68.18,74.12 v1(68.69,74.63)
DDR_B_RAS#: length 67.7
  IN3 w0.076: 104.68,73.95 104.85,73.95 105.49,74.59 109.68,74.59 109.75,74.66 v1(109.75,75.46)
  IN3 w0.175: 104.68,73.95 103.31,72.57 103.03,72.57
  IN3 w0.183: 103.03,72.57 102.91,72.7 90.81,72.7 90.63,72.51 90.63,71.57 90.44,71.38 90.08,71.38 89.9,71.57 89.9,72.51 89.71,72.7 89.25,72.7 89.07,72.51 89.07,71.62 88.83,71.38 81.75,71.38 81.14,71.99 72.12,71.99 70.29,72 70.28,72.01 67.47,72.01 66.88,71.42 64.03,71.42 63.53,71.91 62.8,71.91 62.62,71.73 62.62,71.28 62.43,71.1 62.07,71.1 61.88,71.28 61.88,71.73 61.7,71.91 61.39,71.91 60.81,71.33 v1(60.81,70.51)
  BOTTOM w0.076: v1(109.75,75.46) 109.94,75.27 112.56,75.27 112.66,75.17 114.56,75.17 114.8,74.93 115.26,74.93 115.33,74.91 115.54,74.8 115.71,74.64 UC1.AW44
  BOTTOM w0.183: v1(60.81,70.51) 61.22,70.09 61.22,69.65 61.06,69.49 59.89,69.49 59.14,70.24 JDIMM2.152
DDR_B_WE#: length 68.9
  IN3 w0.076: v1(107.86,73.89) 107.97,73.99 107.97,74.18 107.89,74.26 105.63,74.26 105.42,74.05 105.42,73.4 105.34,73.32 104.88,73.32
  IN3 w0.175: 103.33,71.77 104.88,73.32
  IN3 w0.183: v1(63.86,70.51) 63.86,70.16 64.04,69.97 64.97,69.97 65.43,70.44 67.2,70.44 67.85,71.08 68.23,71.08 68.63,70.68 69.12,70.68 69.52,71.08 69.89,71.08 69.9,71.07 69.92,71.07 70.15,70.84 70.15,70.62 70.33,70.44 70.7,70.44 70.88,70.62 70.88,70.84 71.11,71.07 71.53,71.07 71.93,70.66 72.3,70.66 72.7,71.07 74.35,71.07 74.77,70.65 75.33,70.65 75.74,71.06 77.72,71.06 77.91,70.88 77.91,70.62 78.09,70.44 78.45,70.44 78.64,70.62 78.64,70.88 78.82,71.06 79.27,71.06 79.61,70.73 79.86,70.73 80.2,71.06 80.76,71.06 81.37,70.46 83.96,70.46 84.14,70.27 84.14,70.11 84.32,69.92 84.69,69.92 84.87,70.11 84.87,70.27 85.06,70.46 85.42,70.46 85.6,70.27 85.6,70.11 85.79,69.92 86.15,69.92 86.34,70.11 86.34,70.27 86.52,70.46 86.89,70.46 87.07,70.27 87.07,70.11 87.25,69.92 87.62,69.92 87.8,70.11 87.8,70.27 87.98,70.46 88.35,70.46 88.53,70.27 88.53,70.11 88.71,69.92 89.08,69.92 89.26,70.11 89.26,70.27 89.45,70.46 89.81,70.46 89.99,70.27 89.99,70.11 90.18,69.92 90.54,69.92 90.73,70.11 90.73,70.27 90.91,70.46 91.37,70.46 92.12,71.21 100.29,71.21 100.85,71.77 103.33,71.77
  BOTTOM w0.076: UC1.AY44 115.22,74.68 115.14,74.76 114.99,74.76 114.72,74.49 114.65,74.47 114.51,74.47 114.28,74.53 114.14,74.53 114.03,74.47 113.75,74.47 113.55,74.68 112.46,74.68 112.36,74.78 110.48,74.78 110.41,74.7 109.69,74.7 109.61,74.63 109.61,74.44 109.53,74.37 109.07,74.37 108.99,74.44 108.99,74.63 108.92,74.7 108.72,74.7 108.64,74.63 108.64,74.35 108.56,74.28 108.41,74.28 108.33,74.35 108.33,74.63 108.26,74.7 108.11,74.7 108.03,74.63 108.03,74.35 107.95,74.28 107.8,74.28 107.72,74.35 107.72,74.63 107.65,74.7 107.23,74.7 107.15,74.63 107.15,74.46 107.72,73.89 v1(107.86,73.89)
  BOTTOM w0.183: JDIMM2.151 65.24,70.49 65.08,70.65 65.08,70.94 64.88,71.14 63.85,71.14 63.68,70.97 63.68,70.68 63.85,70.51 v1(63.86,70.51)
DDR_VTT_CNTL: length 21
  TOP w0.089: v1(104.85,98.66) v2(104.85,97.86)
  TOP w0.102: v1(104.85,98.66) UC2.2
  BOTTOM w0.076: UC1.AW67 115.66,88.06 115.24,87.86 113.67,87.86 113.64,87.9 ; 113.13,91.49 111.24,93.38
  BOTTOM w0.102: 113.13,91.49 113.13,90.95 112.51,90.33 112.51,89.51 112.72,89.31 112.72,89.21 112.72,89.21 112.72,88.81 113.64,87.9 ; v1(104.85,98.66) 105.59,97.91 108.42,97.91 110.42,95.91 110.42,94.2 111.24,93.38
DGPU_HOLD_RST#: length 197.6
  TOP w0.089: v1(144.74,109.6) 144.16,109.02 v2(143.48,109.02)
  TOP w0.102: v1(169.71,68.7) 169.71,70 172.13,72.42 172.13,73.59 173.51,74.97 v1(174.71,74.97)
  IN1 w0.102: v1(174.71,74.97) 174.54,74.97 172.75,76.76 172.75,84.7 171.96,87.68 171.68,89.16 171.47,90.59 171.2,94.85 166.06,100 164,100 157.53,106.47 147.29,106.47 144.83,108.94 144.83,109.47 144.74,109.56 v1(144.74,109.6)
  IN2 w0.089: v1(139.01,44.63) 139.01,43.95 141.42,41.54 141.42,39.97 141.99,39.41 145.26,39.41 145.56,39.11 146.99,39.11 147.57,38.53 150.97,38.53 152.5,37 154.47,37 155.21,36.26 158.2,36.26 158.79,36.85 158.79,39.6 157.09,41.3 157.09,46.91 157.97,47.78 159.9,47.78 162.55,50.43 162.55,54.61 163.93,55.99 164.44,55.99 165.68,57.24 165.68,59.42 170.2,63.93 170.2,68.21 v1(169.71,68.7)
  IN2 w0.102: v1(109.2,121.14) 109.66,120.68 109.66,120.23 110.04,119.85 110.52,119.85 110.79,119.58 116.52,119.58 116.8,119.86 120.87,119.86 122.63,118.11 123.71,118.11 124.81,117 126.03,117 126.32,116.71 129.05,116.71 129.76,117.42 133.66,117.42 135.76,115.32 135.76,113.56 136.08,113.24 136.08,112.2 136.53,111.74 137.74,111.74 138.45,111.03 142.53,111.03 143.96,109.6 v1(144.74,109.6)
  BOTTOM w0.076: UC1.P3 129.93,51.29 130.28,50.94 130.49,50.94 130.81,50.62 131.15,50.62 131.29,50.48 131.29,50.43 131.33,50.39 131.33,50.24 131.29,50.21 131.29,49.78 131.54,49.53 131.94,49.53 132.01,49.46
  BOTTOM w0.089: v1(139.01,44.63) 142.01,41.64 142.01,38.45 RC48.1
  BOTTOM w0.102: v1(109.2,121.14) 109.2,121.67 108.75,122.12 UV2.2
  BOTTOM w0.112: v1(139.01,44.63) 138.86,44.48 138.86,44.21 138.32,43.67 136.66,43.67 136.41,43.67 134.35,45.73 134.35,47 133.98,47.38 133.98,47.78 132.8,48.95 132.67,48.95 132.67,48.95 132.62,48.95 132.13,49.44 132.03,49.44 132.01,49.46
DGPU_PWR_EN: length 337.3
  TOP w0.089: v1(67.94,129.34) PRV15.1 ; v1(138.35,115.24) 138.35,111.06 135.99,108.7 134.43,108.7 133.1,107.36 132.18,107.36 131.95,107.59 v1(131.95,108.15) 131.5,107.7 125.93,107.7 125.33,108.3 119.33,108.3 109.93,117.69 109.93,121.15 109.43,121.65 108.76,121.65 v1(108.7,121.59)
  IN1 w0.089: v1(108.7,121.59) 108.24,121.13 108.24,119.68 107.23,118.68 95.75,118.68 95.07,119.36 90.3,119.36 89.87,119.79 87.67,119.79 87.41,120.05 83.74,120.05 81.18,122.61 79.35,122.61 79.2,122.76 78.36,122.76 78.02,123.1 78.02,124.22 77.02,125.22 76.65,125.22 75.9,124.47 71.76,124.47 71.33,124.04 69.83,124.04 69.15,124.72 69.15,125.2 67.94,126.41 v1(67.94,129.34)
  IN2 w0.089: v1(49.44,116.48) 48.78,116.48 47.04,114.75 47.04,113.22 46.24,112.41 46.24,105.66 47.98,103.92 47.98,98.41 49.45,96.93 49.45,89.81 46.82,87.18 46.82,74.81 49.12,72.51 49.12,69.28 49.82,68.58 50.22,68.58 51.3,67.5 51.3,64.15 50.73,63.58 50.73,60.47 50.88,60.33 50.88,56.45 51.33,56 51.33,52.67 50.59,51.92 50.59,48.13 51.81,46.91 51.81,42.86 54.75,39.92 57.8,39.92 62.4,35.32 67.95,35.32 68.61,35.98 69.77,35.98 70.2,35.55 71.9,35.55 72.51,34.94 75.4,34.94 75.86,35.4 81.46,35.4 83.32,37.26 84.24,37.26 84.83,37.85 86.93,37.85 87.16,38.08 90.93,38.08 91.4,37.61 94.13,37.61 94.36,37.84 96.45,37.84 97.14,38.54 98.32,38.54 98.86,39.08 100.33,39.08 100.67,39.42 106.43,39.42 107.02,38.83 108.07,38.83 108.65,39.42 108.94,39.7 108.94,40.38 111.96,43.4 114.43,43.4 117.15,40.67 117.48,40.67 118.32,41.51 119.2,41.51 119.68,41.03 120.14,41.03 120.19,41.08 120.94,41.08 121.3,40.72 123.4,40.72 124.28,41.59 124.28,42.94 125.62,44.28 128.25,44.28 129.74,42.79 131.64,42.79 132.55,43.7 v1(132.9,43.7) 133.43,44.23 133.43,45.22 133.97,45.75 138.57,45.75 139.43,44.89 139.43,43.95 142.71,40.67 v1(142.71,40.39)
  BOTTOM w0.089: UC1.U1 127.73,49.65 128.01,49.37 129.49,49.37 130.33,48.53 131.34,48.53 132.71,47.17 132.71,45.27 133.34,44.64 133.34,44.13 v1(132.9,43.7) ; RZ8.1 130.22,108.56 130.53,108.88 131.22,108.88 v1(131.95,108.15) 132.33,108.53 132.33,110.41 131.65,111.09 130.13,111.09 RZ7.1 ; v1(49.44,116.48) 50.19,117.23 54.76,117.23 56.4,118.87 56.4,120.03 59.66,123.3 67.09,123.3 68.23,124.44 68.23,129.05 v1(67.94,129.34) ; v2(138.86,115.08) 138.7,115.24 v1(138.35,115.24) 137.84,115.24 RZ6.1 ; RC50.2 143.48,37.87 143.43,37.87 143.05,38.24 RC49.2 142.32,39 142.32,40.01 v1(142.71,40.39)
DGPU_PWROK: length 162.4
  TOP w0.089: v1(140.26,112.93) 140.26,112.68 136.03,108.44 134.44,108.44 133.16,107.16 131.85,107.16 131.5,107.5 125.78,107.5 125.52,107.76 v1(124.47,107.76)
  TOP w0.254: PRV20.2 79.6,124.95 79.6,123.94 v1(79.05,123.39)
  IN2 w0.102: v1(138.75,51.6) 139.26,52.11 140.58,52.11 141.24,52.77 142.38,52.77 143.39,51.76 v1(143.39,51.52) 144.94,51.52 145.71,50.76 v1(146.41,50.76)
  IN3 w0.102: v1(146.41,50.76) 146.41,52.89 146.98,53.46 146.98,57.66 146.35,58.29 145.4,58.29 144.61,59.08 144.61,61.55 144.85,61.79 144.85,67.15 146.69,69 147.56,69 149.76,71.21 149.76,80.84 150.05,81.13 150.05,87.35 150.37,87.67 150.37,90.34 149.38,91.34 149.38,92.04 149.38,92.05 149.38,92.38 148.55,93.2 148.55,95.15 147.02,96.68 147.02,106.37 141.04,112.34 140.85,112.34 v1(140.26,112.93)
  BOTTOM w0.076: UC1.C8 136.4,54.08 136.84,53.64 136.84,53.12 137.66,52.31
  BOTTOM w0.089: v1(79.05,123.39) 79.05,122.77 79.37,122.45 79.78,122.45 80.27,121.96 80.92,121.96 82.47,120.41 87.73,120.41 88.06,120.09 89.74,120.09 92.47,117.36 98.58,117.36 109.06,106.88 115.8,106.88 116.24,106.44 123.15,106.44 v1(124.47,107.76) ; v2(138.78,113.62) 139.81,113.62 140.26,113.17 v1(140.26,112.93) 140.26,112.45 PRW01.1
  BOTTOM w0.102: RC116.2 143.14,51.28 143.38,51.52 v1(143.39,51.52) ; v1(138.75,51.6) 138.61,51.75 138.22,51.75 137.66,52.31
DIFFOUT_2PH_CPU: length 7.1
  TOP w0.089: v1(178.02,51.86) 178.28,51.61 179.13,51.61 179.47,51.27 v2(179.47,50.77)
  BOTTOM w0.203: PUZ01.2 177.23,52.46 177.82,51.86 v1(178.02,51.86) 178.93,51.86 179.58,51.21 PRZ21.1 179.58,49.57 PRZ20.1
DIMM_CHA_SA0: length 3.3
  TOP w0.102: RD4.1 70.34,44.86 v1(69.66,44.18) 70.16,43.68 RD1.2
  BOTTOM w0.102: JDIMM1.256 69.72,44.24 v1(69.66,44.18)
DIMM_CHA_SA1: length 4.7
  TOP w0.102: RD5.1 68.91,44.5 v1(68.91,44.18) 69.21,43.89 RD2.2
  BOTTOM w0.127: JDIMM1.260 69.04,43.24 68.91,43.37 v1(68.91,44.18)
DIMM_CHA_SA2: length 4.8
  TOP w0.089: RD6.1 69.22,65.34 v2(68.72,64.83)
  TOP w0.102: RD3.2 69.03,66.41 v1(69.02,66.4) 69.22,66.19 RD6.1
  BOTTOM w0.102: JDIMM1.166 70.95,66.74 69.92,66.74 69.82,66.84 69.46,66.84 v1(69.02,66.4)
DIMM_CHB_SA0: length 3.2
  TOP w0.127: v1(57.01,44.6) 56.64,44.24 RD13.2 RD16.1
  BOTTOM w0.127: JDIMM2.256 58.25,44.24 57.37,44.24 v1(57.01,44.6)
DIMM_CHB_SA1: length 3.4
  TOP w0.127: RD17.1 RD14.2 56.91,43.81 v1(56.97,43.81)
  BOTTOM w0.127: JDIMM2.260 57.5,43.24 56.97,43.77 v1(56.97,43.81)
DIMM_CHB_SA2: length 3.2
  TOP w0.102: RD15.2 RD18.1 56.52,66.86 v1(56.87,66.51)
  BOTTOM w0.102: v1(56.87,66.51) 57.11,66.74 JDIMM2.166
DMIC_CLK: length 2.2
  TOP w0.112: UA1.3 30.62,11.85 v2(30.88,11.6) 31.23,11.25 L5.2
DMIC_CLK_EDP: length 224.6
  TOP w0.112: L5.1 32.74,11.11 33.22,11.11 v1(33.23,11.11) 33.24,11.11 33.74,11.11 CA9.1
  IN1 w0.119: v1(33.23,11.11) 33.28,11.07 34.79,11.07 38.42,14.7 38.42,15.91 39.46,16.95 39.46,17.88 38.48,18.86 38.48,23.63 39.43,24.57 40.79,24.57 41.98,25.75 42.94,25.75 45.34,28.16 45.34,28.86 48.37,31.88 55.84,31.88 57.18,30.54 57.18,27.5 58.94,25.75 68.77,25.75 70.54,23.97 100.29,23.97 101.24,24.92 115.98,24.92 117.27,26.21 121.19,26.21 121.66,26.68 136.63,26.68 140.23,30.29 145.2,30.29 145.81,29.68 151.78,29.68 152.19,30.08 154.34,30.08 155.19,30.93 155.55,30.93 158.32,33.7 161.34,33.7 161.73,33.3 163.17,33.3 164.04,34.17 167.45,34.17 167.77,34.49 177.11,34.49 178.73,36.12 183.07,36.12 183.65,35.54 190.41,35.54 191.32,34.63 192.18,34.63 192.84,35.29 197.58,35.29 198.01,34.86 200.1,34.86 201.4,33.56 203.88,33.56 207.13,36.81 211.7,36.81 212.44,37.54 213.43,37.54 214.53,38.64 214.53,39.62 217.05,42.14 217.05,44.36 216.9,44.51 216.75,44.51 v1(216.54,44.3)
  BOTTOM w0.112: v1(216.54,44.3) 216.32,44.53 215.06,44.53 213.96,45.62 213.23,45.62 213.07,45.46 212.38,45.46 JEDP1.31
DMIC_DATA: length 4.1
  TOP w0.112: v2(32.72,9.41) 32.44,9.69 31.91,9.69 31.71,9.88 RA42.2 31.71,10.37 31.32,10.75 31.02,10.75 30.33,11.45 UA1.2
DMIC_DATA_EDP: length 226.5
  TOP w0.112: RA42.1 32.89,10.61 33.15,10.61 v1(33.23,10.53) 33.37,10.66 33.55,10.66 CA40.1
  IN1 w0.119: v1(33.23,10.53) 33.61,10.53 33.65,10.57 35,10.57 38.85,14.42 38.92,14.49 38.92,15.7 39.96,16.74 39.96,18.09 38.98,19.06 38.98,23.42 39.63,24.07 41,24.07 42.18,25.25 43.15,25.25 45.84,27.95 45.84,28.65 48.58,31.38 55.63,31.38 56.68,30.33 56.68,27.3 58.73,25.25 68.56,25.25 70.34,23.47 100.5,23.47 101.45,24.42 116.19,24.42 117.48,25.71 121.4,25.71 121.87,26.18 136.83,26.18 140.44,29.79 145,29.79 145.61,29.17 151.99,29.17 152.39,29.58 154.55,29.58 155.39,30.43 155.76,30.43 158.53,33.2 161.13,33.2 161.53,32.8 163.38,32.8 164.25,33.67 167.66,33.67 167.98,33.99 177.31,33.99 178.94,35.62 182.87,35.62 183.44,35.04 190.2,35.04 191.11,34.13 192.38,34.13 193.04,34.79 197.37,34.79 197.8,34.36 199.89,34.36 201.19,33.06 204.08,33.06 207.34,36.31 211.91,36.31 212.64,37.04 213.64,37.04 215.03,38.44 215.03,39.41 217.55,41.93 217.55,44.57 217.11,45.01 216.63,45.01 216.56,45.07 v1(216.56,45.23)
  BOTTOM w0.112: v1(216.56,45.23) 216.35,45.02 215.26,45.02 214.17,46.11 213.03,46.11 212.87,45.95 JEDP1.30
DP_AUXN: length 15.8
  TOP w0.112: RT103.2 30.22,112.63 30.22,112.93 30.57,113.28 30.57,114.29 29.46,115.41 26.99,115.41 26.31,116.09 v4(23.68,116.09) 21.97,116.09 21.95,116.08 21.33,116.08 21.31,116.09 20.77,116.09 20.12,115.43 19.07,115.43 18.79,115.71 18.79,115.96 CT90.2
DP_AUXP: length 15.7
  TOP w0.112: RT102.2 30.44,112.63 30.44,112.84 30.79,113.19 30.79,114.38 29.55,115.63 27.08,115.63 26.4,116.31 23.99,116.31 23.97,116.32 23.41,116.32 23.4,116.31 v4(21.67,116.31) 20.68,116.31 20.02,115.65 19.16,115.65 19.01,115.8 19.01,116.05 CT89.2
DP_N0: length 26.7
  TOP w0.112: CT82.2 25.23,126.62 25.39,126.62 25.52,126.5 25.52,125.8 25.75,125.57 25.99,125.57 v1(26.15,125.41)
  IN3 w0.135: v1(39.62,112.09) 39.79,112.25 39.79,114.09 39.73,114.14 39.73,114.93 39.09,115.58 35.1,115.58 34.11,116.57 33.44,116.57 32.61,117.39 32.32,117.39 30.53,119.18 30.53,119.96 29.5,120.99 29.5,121.81 27.71,123.6 27.71,124.7 26.82,125.58 26.32,125.58 v1(26.15,125.41)
  BOTTOM w0.112: RT105.2 40.59,112.95 40.59,112.8 40.51,112.72 40.04,112.72 39.79,112.46 39.79,112.25 v1(39.62,112.09)
DP_N1: length 22.2
  TOP w0.112: v1(26.41,122.83) 26.18,123.07 26.04,123.07 25.78,123.33 25.78,123.99 25.58,124.18 25.42,124.18 CT84.2
  IN3 w0.135: v1(37.79,112.06) 37.96,112.23 37.96,112.77 36.81,113.92 34.23,113.92 31.73,116.42 31.73,116.94 29.76,118.91 29.76,119.64 28.72,120.69 28.72,121.59 27.31,123 26.58,123 v1(26.41,122.83)
  BOTTOM w0.112: v1(37.79,112.06) 37.97,112.24 37.97,112.44 38.22,112.7 38.67,112.7 38.81,112.84 38.81,112.95 RT107.2
DP_N2: length 20.6
  TOP w0.112: CT86.2 24.81,122.08 25.04,122.08 25.25,122.29 25.53,122.29 v1(25.71,122.11)
  IN3 w0.135: v1(36.11,112.04) 36.28,112.21 36.28,112.9 35.94,113.24 33.79,113.24 31.94,115.1 30.66,115.1 27.16,118.59 27.16,121.83 26.93,122.06 26.25,122.06 26.06,122.25 25.85,122.25 v1(25.71,122.11)
  BOTTOM w0.112: RT109.2 37,112.94 37,112.84 36.88,112.72 36.54,112.72 36.27,112.46 36.27,112.2 v1(36.11,112.04)
DP_N3: length 16.6
  TOP w0.112: CT88.2 24.8,119.91 25.02,119.91 25.31,119.61 25.31,118.9 v1(25.12,118.7)
  IN3 w0.135: v1(34.25,111.99) 34.41,112.15 34.41,112.4 34.26,112.56 32.21,112.56 27.42,117.36 26.21,117.36 25.3,118.27 25.3,118.52 v1(25.12,118.7)
  BOTTOM w0.112: RT111.2 35.29,112.93 35.29,112.77 35.2,112.69 34.73,112.69 34.46,112.41 34.46,112.19 v1(34.25,111.99)
DP_P0: length 27.1
  TOP w0.112: CT81.2 25.24,126.84 25.48,126.84 25.74,126.59 25.74,125.89 25.84,125.79 25.94,125.79 v1(26.15,126)
  IN3 w0.135: v1(26.15,126) 26.32,125.82 26.92,125.82 27.95,124.8 27.95,123.7 29.74,121.91 29.74,121.09 30.77,120.06 30.77,119.29 32.42,117.64 32.71,117.64 33.54,116.81 34.21,116.81 35.2,115.82 39.19,115.82 39.98,115.03 39.98,114.24 40.03,114.19 40.03,112.26 v1(40.2,112.09)
  BOTTOM w0.112: RT104.2 40.81,112.91 40.81,112.71 40.61,112.5 40.14,112.5 40.01,112.37 40.01,112.28 v1(40.2,112.09)
DP_P1: length 22.5
  TOP w0.112: v1(26.41,123.41) 26.28,123.29 26.13,123.29 26,123.42 26,124.08 25.68,124.4 25.43,124.4 CT83.2
  IN3 w0.135: v1(26.41,123.41) 26.58,123.24 27.41,123.24 28.96,121.69 28.96,120.79 30.01,119.74 30.01,119.01 31.97,117.04 31.97,116.52 34.33,114.16 36.91,114.16 38.2,112.87 38.2,112.23 v1(38.37,112.06)
  BOTTOM w0.112: v1(38.37,112.06) 38.19,112.24 38.19,112.35 38.31,112.47 38.76,112.47 39.04,112.75 39.04,112.91 RT106.2
DP_P2: length 21.1
  TOP w0.112: v1(25.71,122.69) 25.54,122.51 25.16,122.51 24.94,122.3 24.81,122.3 CT85.2
  IN3 w0.135: v1(36.7,112.04) 36.7,112.05 36.52,112.23 36.52,113 36.04,113.48 33.89,113.48 32.04,115.34 30.76,115.34 27.4,118.69 27.4,121.93 27.03,122.3 26.35,122.3 26.16,122.49 25.92,122.49 v1(25.71,122.69)
  BOTTOM w0.112: v1(36.7,112.04) 36.5,112.24 36.5,112.37 36.63,112.5 36.97,112.5 37.22,112.75 37.22,112.92 RT108.2
DP_P3: length 16.9
  TOP w0.112: CT87.2 24.81,120.13 25.1,120.13 25.54,119.69 25.54,118.87 v1(25.7,118.7)
  IN3 w0.135: v1(25.7,118.7) 25.54,118.54 25.54,118.37 26.31,117.6 27.52,117.6 32.31,112.8 34.36,112.8 34.65,112.5 34.65,112.17 v1(34.84,111.99)
  BOTTOM w0.112: RT110.2 35.51,112.93 35.51,112.68 35.29,112.46 34.82,112.46 34.68,112.32 34.68,112.15 v1(34.84,111.99)
DP_VSSR: length 1.6
  BOTTOM w0.089: 111.51,139 v2(110.8,139)
  BOTTOM w0.305: v1(112.07,134.54) 112.13,134.6 UV1.AM18
  vias: v1(111.71,136.37) v1(112.38,132.55) v1(112.52,138.19) v1(114.62,131.92) v1(114.94,131.06) v1(115.66,139) v1(116.08,136.94)
DRAM_RST: length 50.8
  TOP w0.102: UV12.J2 155.11,137.12 v1(155.51,136.72) ; UV14.J2 v1(155.51,129.31)
  IN1 w0.119: v1(155.51,136.72) 155.51,135.92 156.19,135.24 161.47,135.24 164.06,132.66 164.06,120.56 160.07,116.57 150.81,116.57 v1(150.05,117.33)
  BOTTOM w0.102: v1(155.51,136.72) 155.11,137.12 UV12.J2 154.73,136.74 154.73,135.12 154.14,134.53 v2(154.14,133.15) 154.14,132.29 154.73,131.7 154.73,129.29 UV14.J2 v1(155.51,129.31) ; RV36.1 v1(150.05,117.33)
DRAM_RST_G: length 31.7
  TOP w0.089: v2(149.46,116.72) 149.29,116.89 v1(149.29,117.33)
  IN2 w0.127: v1(127.5,127.77) 128.67,126.6 129.46,126.6 129.82,126.24 129.82,125.21 134.26,120.77 135.78,120.77 137.09,122.08 144.81,122.08 147.32,119.58 147.32,119.3 v1(149.29,117.33)
  BOTTOM w0.102: v1(149.29,117.33) RV37.1 RV38.1 CV97.1 ; v1(127.5,127.77) 127.93,128.2 UV1.L10
DRVON: length 75.3
  TOP w0.089: v1(157.1,95.8) 156.81,95.51 v2(156.5,95.51)
  IN1 w0.102: v1(160.65,70.76) 161.28,70.13 164.23,70.13 169.21,65.16 169.21,61.09 v1(167.16,59.04)
  IN1 w0.305: v1(165.36,89.2) 165.36,88.76 164.97,88.37 160.16,88.37 157.14,91.39 157.14,95.76 v1(157.1,95.8)
  IN3 w0.102: v1(165.36,89.2) 166.09,89.2 166.35,88.93 166.35,81.29 165.97,80.9 165.97,74.17 163.86,72.07 161.96,72.07 v1(160.65,70.76)
  IN3 w0.254: v1(177.43,59.7) 176.8,59.07 172.62,59.07 172.16,59.53 171.47,59.53 171.24,59.29 169.64,59.29 169.25,59.69 167.64,59.69 167.16,59.21 v1(167.16,59.04)
  BOTTOM w0.203: v1(177.43,59.7) 177.23,59.5 PUZ01.35
  BOTTOM w0.254: v1(167.16,59.04) 166.95,59.04 166.61,58.69 PUA01.3 ; PUI02.16 165.72,88.91 165.43,89.2 v1(165.36,89.2) ; v1(160.65,70.76) 160.65,70.28 160.7,70.23 160.7,69.07 160.92,68.86 PUI01.16 ; PUG01.16 156.79,94.1 156.53,94.36 156.53,95.29 157.04,95.8 157.1,95.8 v1(157.1,95.8)
EC_AGND: length 33.7
  TOP w0.102: v2(29.57,77.12) 30.01,76.69 v1(30.51,76.69)
  TOP w0.203: v1(32.85,76.86) 33.18,76.86 33.9,76.13 34.58,76.13 34.9,75.81 UE1.112
  TOP w0.508: v1(30.51,76.69) 30.73,76.69 31.19,77.15 ; 31.19,77.15 31.19,77.08 31.29,76.98 31.29,76.09 31.16,75.96 CE30.2 ; 31.19,77.15 CE25.2 ; v1(32.59,89.58) 32.34,89.84 CE21.2 32.47,90.2 33.31,91.04 RE50.2 33.78,91.5 34.16,91.88 35.42,91.88 35.76,91.53 RE6.1 35.79,91.09 CE2.2 ; v1(33.19,87.65) 32.74,87.21 CE1.2 31.77,87.21 RE4.1
  IN2 w0.508: v1(33.19,87.65) 33.38,87.85 33.38,89.22 33.03,89.58 v1(32.59,89.58)
  IN3 w0.508: v1(32.85,76.86) 32.69,76.69 v1(30.51,76.69)
  BOTTOM w0.508: v1(33.19,87.65) 33.02,87.49 32.37,87.49 30.49,85.61 30.49,83.23 31.11,82.61 31.11,77.07 30.73,76.69 v1(30.51,76.69)
EC_MUTE#: length 95.8
  TOP w0.089: RA8.2 v2(29.96,9.05) 29.96,9.69 v1(29.5,10.16) ; 29.22,9.58 29.32,9.69
  TOP w0.102: RE28.2 32.24,82.46 31.9,82.8 31.9,83.71 v1(32.23,84.04) ; 29.22,9.58 28.8,9.58 28.54,9.85 UA1.47 ; v1(29.5,10.16) 29.32,9.98 29.32,9.69
  IN1 w0.102: v1(27.29,30.23) 27.51,30.02 27.51,26.31 27.61,26.21 27.61,25.69 30.15,23.14 30.15,20.67 31.83,18.98 31.83,17.25 29.69,15.11 29.69,10.26 29.59,10.16 v1(29.5,10.16)
  IN2 w0.089: v1(32.23,84.04) 34.32,81.95 34.32,78.75 33.73,78.16 33.73,76.84 33.35,76.46 33.35,74.11 34.13,73.33 34.13,70.57 32.7,69.14 32.7,66.64 35.32,64.02 35.32,63.09 34.55,62.31 32.6,62.31 32.19,61.91 32.19,60.16 31.6,59.56 30.82,59.56 28.83,57.58 28.83,56.33 25.44,52.94 25.18,52.94 22.23,50 22.23,44.32 21.83,43.91 21.83,43.35 22.32,42.86 22.32,36.83 27.29,31.86 v1(27.29,30.23)
EDP_AUX: length 2.9
  TOP w0.112: v1(213.33,53.78) 213.5,53.6 213.5,53.6 213.54,53.57 213.67,53.57 213.76,53.66 213.76,53.94 213.97,54.15 214.21,54.15 C11.2
  BOTTOM w0.112: v1(213.33,53.78) 213.01,53.45 JEDP1.15
EDP_AUX#: length 2.9
  TOP w0.112: v1(213.33,53.19) 213.49,53.35 213.76,53.35 213.98,53.56 213.98,53.84 214.06,53.93 214.17,53.93 C10.2
  BOTTOM w0.112: JEDP1.16 213.09,52.95 v1(213.33,53.19)
EDP_AUX_DN: length 129.5
  TOP w0.112: C10.1 215.77,53.91 216.04,53.91 v1(216.19,53.76)
  IN1 w0.076: 135.37,74.99 135.37,75 135.33,75 135.3,75.03 135.15,75.03 135.13,75.01 134.84,75.01 134.16,75.69 133.34,75.69 133.15,75.87 133.15,76 133.29,76.15 133.4,76.16 v1(133.51,76.06)
  IN1 w0.119: v1(216.19,53.76) 216.31,53.89 216.48,53.89 216.6,53.77 216.6,49.63 216.79,49.43 216.79,46.92 215.28,45.41 215.28,43.62 213.87,42.2 211.54,42.2 208.29,38.95 206.22,38.95 204.74,40.42 202.73,40.42 201.52,39.21 197.88,39.21 197.64,39.45 193.41,39.45 193.28,39.45 191.96,39.45 191.24,38.72 187.33,38.72 186.94,39.11 185.45,39.11 184.69,39.86 173.09,39.86 172.98,39.96 163.38,39.96 162.37,38.95 154.69,38.95 152.29,41.35 152.29,42.64 150.75,44.19 150.75,47.36 148.6,49.51 148.6,52.99 147.49,54.11 147.49,59.87 146.63,60.73 146.63,68.23 141.83,73.03 141.83,73.75 140.72,74.85 138.93,74.85 138.3,74.22 138.18,74.22 138.17,74.21 136.16,74.21 135.37,74.99
  BOTTOM w0.076: UC1.E45 133.99,75.51 134.17,75.7 134.17,75.92 134.03,76.06 v1(133.51,76.06)
EDP_AUX_DP: length 129.5
  TOP w0.112: C11.1 215.77,54.13 215.97,54.13 v1(216.19,54.35)
  IN1 w0.076: v1(132.79,76.03) 132.8,75.97 133.03,75.75 133.27,75.53 134.09,75.53 134.77,74.84 135.22,74.84
  IN1 w0.119: 135.22,74.84 136.07,74 138.39,74 139.02,74.63 140.63,74.63 141.61,73.66 141.61,72.94 146.41,68.13 146.41,60.64 147.27,59.78 147.27,54.02 148.38,52.9 148.38,49.42 150.53,47.27 150.53,44.1 152.08,42.55 152.08,41.26 154.6,38.73 162.28,38.73 162.28,38.73 162.32,38.73 162.46,38.73 163.47,39.74 172.89,39.74 173,39.64 184.6,39.64 185.35,38.89 186.85,38.89 187.24,38.5 191.33,38.5 192.05,39.23 193.27,39.23 193.4,39.23 197.55,39.23 197.79,38.99 201.61,38.99 202.82,40.2 204.65,40.2 206.13,38.73 208.38,38.73 211.63,41.98 213.96,41.98 215.5,43.53 215.5,45.32 217.01,46.83 217.01,49.53 216.82,49.72 216.82,53.86 216.57,54.11 216.43,54.11 v1(216.19,54.35)
  BOTTOM w0.076: UC1.F45 133.17,75.65 v1(132.79,76.03)
EDP_BKLT_CTRL: length 5.9
  TOP w0.112: v2(180.01,71.14) 179.6,71.55 R8.2 177.97,72.53 177.97,72.67 D3.2
EDP_COMP: length 11.6
  TOP w0.254: RC4.2 v2(142.55,81.59) 138.84,81.59 138.27,81.02 135.44,81.02 v1(134.05,79.63)
  BOTTOM w0.254: v1(134.05,79.63) UC1.E52
EDP_HPD: length 210.7
  TOP w0.112: 177.66,67.19 177.18,66.7 v1(177.15,66.7)
  IN1 w0.119: v1(177.15,66.7) 177.15,66.38 177.87,65.67 179.83,65.67 183.23,62.27 186.07,62.27 188.62,59.72 193.42,59.72 196.37,56.78 202.51,56.78 203.91,55.38 205.9,55.38 206.79,56.27 208.95,56.27 209.37,56.7 211.7,56.7 213.29,55.1 v1(213.6,55.1) ; v1(184.07,30.84) 183.61,31.3 182.44,31.3 180.89,29.76 180.89,25.12 180.49,24.71 169.91,24.71 168.79,25.83 154.95,25.83 154.87,25.91 v1(154.87,26.94)
  IN3 w0.135: v1(130.07,54.45) 130.34,54.45 130.85,53.94 130.85,52.76 130.95,52.67 130.95,51.95 130.56,51.56 130.56,51.19 131.53,50.22 131.53,46.39 130.98,45.84 130.98,43.05 130.28,42.34 130.28,42.02 129.32,41.06 129.32,40.3 128.94,39.91 128.94,38.26 128.86,38.19 128.86,36 126.72,33.86 126.72,33.14 v1(126.91,32.95) ; v1(184.07,30.84) 185.01,29.9 214.66,29.9 215.08,29.49 218.06,29.49 218.07,29.49 219.75,29.49 222.11,31.85 222.11,32.88 224.1,34.87 224.1,43.96 222.04,46.02 222.04,51.6 219.62,54.02 218.3,54.02 218.23,54.08 217.24,54.08 216.56,54.77 213.93,54.77 v1(213.6,55.1)
  BOTTOM w0.089: v1(130.07,54.45) 130.07,54.82 UC1.L10
  BOTTOM w0.112: v1(154.87,26.94) 154.33,27.48 148.2,27.48 142.99,32.68 140.11,32.68 136.78,29.36 134.21,29.36 132.85,30.71 131.77,30.71 130.77,31.71 v2(130.42,31.71) 129.62,31.71 128.86,32.46 127.4,32.46 v1(126.91,32.95) ; JEDP1.12 212.98,54.95 213.13,55.1 v1(213.6,55.1)
EDP_TX0: length 2.5
  TOP w0.112: C7.2 214.22,52.1 214.01,52.1 213.89,51.98 213.59,51.98 v1(213.42,51.81)
  BOTTOM w0.112: v1(213.42,51.81) 213.06,51.45 JEDP1.19
EDP_TX0#: length 2.6
  TOP w0.112: v1(213.42,52.4) 213.62,52.2 213.8,52.2 213.92,52.32 214.16,52.32 C6.2
  BOTTOM w0.112: JEDP1.18 212.97,51.95 v1(213.42,52.4)
EDP_TX0_DN: length 121.1
  TOP w0.112: v1(216.19,52.57) 215.98,52.37 215.76,52.37 C6.1
  IN1 w0.076: 137.4,77.12 137.31,77.05 137.3,77.05 136.48,77.05 136.29,76.85 136.29,76.71 v1(136.07,76.49)
  IN1 w0.119: v1(216.19,52.57) 216,52.39 215.61,52.39 215.21,51.99 215.21,51.03 214.91,50.73 214.91,50.73 214.84,50.66 214.84,49.14 215.09,48.89 215.09,47.09 213.91,45.92 212.55,45.92 211.4,44.76 209.76,44.76 207.61,42.62 205.75,42.62 204.86,41.73 202.06,41.73 200.83,40.51 198.62,40.51 198.39,40.73 191.43,40.73 191.09,40.39 185.98,40.39 185.23,41.14 173.89,41.14 173.2,41.83 168.9,41.83 168.31,41.25 162.84,41.25 162.25,40.65 155.05,40.65 153.79,41.9 153.79,43.29 152.17,44.92 152.17,47.76 149.89,50.05 149.89,53.53 148.77,54.64 148.77,62.87 149.23,63.33 149.23,66.42 148.74,66.91 148.74,67.94 143.19,73.48 143.19,75.65 142.24,76.6 138.55,76.6 138.33,76.83 138.31,76.83 138.02,77.12 137.4,77.12
  BOTTOM w0.076: UC1.C47 135.12,76.82 135.12,76.68 135.16,76.65 135.37,76.65 135.39,76.67 135.7,76.67 135.88,76.49 v1(136.07,76.49)
EDP_TX0_DP: length 121.2
  TOP w0.112: C7.1 215.44,51.92 215.66,52.14 216.03,52.14 v1(216.19,51.98)
  IN1 w0.076: v1(136.64,76.49) 136.46,76.68 136.46,76.78 136.55,76.88 137.35,76.88 137.4,76.91 137.44,76.91
  IN1 w0.119: v1(216.19,51.98) 216,52.17 215.71,52.17 215.43,51.89 215.43,50.94 215.13,50.64 215.06,50.57 215.06,49.23 215.31,48.98 215.31,47 214.01,45.7 212.64,45.7 211.49,44.54 209.85,44.54 207.7,42.4 205.84,42.4 204.95,41.51 202.15,41.51 200.92,40.29 198.52,40.29 198.3,40.51 191.52,40.51 191.18,40.18 185.89,40.18 185.14,40.93 173.8,40.93 173.11,41.61 168.99,41.61 168.4,41.03 162.94,41.03 162.34,40.43 154.96,40.43 153.57,41.81 153.57,43.2 151.95,44.83 151.95,47.67 149.67,49.95 149.67,53.44 148.55,54.55 148.55,62.96 149.02,63.42 149.02,66.33 148.52,66.82 148.52,67.85 142.98,73.39 142.98,75.56 142.15,76.39 138.46,76.39 137.93,76.91 137.44,76.91
  BOTTOM w0.076: v1(136.64,76.49) 136.64,76.15 136.57,76.07 135.68,76.07 135.57,76.18 UC1.C46
EDP_TX1: length 2.6
  TOP w0.112: C9.2 214.2,50.31 214.03,50.31 213.86,50.15 213.63,50.15 v1(213.45,49.98)
  BOTTOM w0.112: JEDP1.22 212.8,49.95 213,50.14 213.34,50.14 213.45,50.03 v1(213.45,49.98)
EDP_TX1#: length 2.6
  TOP w0.112: C8.2 214.18,50.53 213.94,50.53 213.77,50.37 213.64,50.37 v1(213.44,50.56)
  BOTTOM w0.112: v1(213.44,50.56) 213.44,50.5 213.31,50.36 212.96,50.36 212.88,50.45 JEDP1.21
EDP_TX1_DN: length 121.8
  TOP w0.112: C8.1 215.72,50.6 215.98,50.6 216.18,50.79 v1(216.18,50.82)
  IN1 w0.119: v1(134.42,76.27) 134.62,76.06 134.82,76.06 135.01,76.26 135.52,76.26 136.98,74.8 137.69,74.8 138.58,75.69 140.93,75.69 142.47,74.15 142.47,73.3 148.09,67.67 148.09,66.64 148.54,66.2 148.54,63.75 148.13,63.34 148.13,54.38 149.24,53.26 149.24,49.78 151.46,47.56 151.46,44.57 153.1,42.94 153.1,41.69 154.9,39.89 162.39,39.89 163.11,40.6 173.35,40.6 173.45,40.5 184.96,40.5 185.71,39.75 191.36,39.75 191.7,40.09 197.91,40.09 198.14,39.85 201.25,39.85 202.46,41.06 205.16,41.06 206.05,41.96 207.35,41.96 208.03,41.27 209.7,41.27 211.28,42.85 212.34,42.85 212.72,43.23 213.81,43.23 214.61,44.03 214.61,45.65 215.73,46.77 215.73,49.26 215.49,49.5 215.49,50.37 215.73,50.62 215.98,50.62 v1(216.18,50.82)
  BOTTOM w0.076: v1(134.42,76.27) 134.81,76.27 UC1.D46
EDP_TX1_DP: length 121.7
  TOP w0.112: v1(216.18,50.23) 216.03,50.38 215.82,50.38 C9.1
  IN1 w0.119: v1(216.18,50.23) 216.01,50.4 215.82,50.4 215.71,50.28 215.71,49.59 215.95,49.35 215.95,46.68 214.83,45.56 214.83,43.94 213.9,43.01 212.81,43.01 212.43,42.63 211.37,42.63 209.79,41.05 207.94,41.05 207.26,41.74 206.14,41.74 205.25,40.85 202.55,40.85 201.34,39.64 198.05,39.64 197.82,39.87 191.79,39.87 191.45,39.53 185.62,39.53 184.87,40.28 173.36,40.28 173.26,40.39 163.2,40.39 162.48,39.67 154.81,39.67 152.88,41.6 152.88,42.85 151.24,44.48 151.24,47.47 149.03,49.69 149.03,53.17 147.91,54.29 147.91,63.43 148.32,63.84 148.32,66.11 147.87,66.55 147.87,67.58 142.25,73.21 142.25,74.06 140.84,75.47 138.67,75.47 137.79,74.59 136.89,74.59 135.43,76.05 135.09,76.05 134.83,75.78 134.83,75.54 v1(134.95,75.42)
  BOTTOM w0.076: UC1.C45 134.95,75.52 v1(134.95,75.42)
EDP_VDD_EN: length 76.8
  TOP w0.102: D4.2 v1(165.37,26.88)
  IN1 w0.089: v1(165.37,26.88) 164.83,26.34 156.06,26.34 v1(155.46,26.94)
  IN3 w0.135: v1(128.08,56.34) 127.84,56.34 127.5,55.99 127.5,55.48 127.69,55.28 128.06,55.28 128.57,54.77 128.57,54.07 129.22,53.42 129.22,52.7 128.88,52.36 128.88,51.51 128.69,51.32 128.69,49.36 128.42,49.1 128.42,45.31 128.64,45.09 128.64,42.45 128.29,42.1 127.69,42.1 127.15,41.56 126.09,41.56 124.88,40.34 124.88,39.34 125.19,39.03 125.19,37.04 125.28,36.95 125.28,32.81 v1(125.32,32.77)
  BOTTOM w0.089: v1(125.32,32.77) 125.76,32.33 126.77,32.33 127.05,32.05 128.64,32.05 129.38,31.31 130.6,31.31 131.6,30.31 132.68,30.31 134.04,28.95 136.95,28.95 140.28,32.28 142.82,32.28 148.03,27.07 v2(148.87,27.07) 149.84,26.09 154.61,26.09 v1(155.46,26.94)
  BOTTOM w0.102: v1(128.08,56.34) 128.08,56.69 UC1.U13
EDRAM_OPIO_RCOMP: length 2.2
  TOP w0.089: v2(132.99,87.31) 132.84,87.16 v1(132.39,87.16) 132.31,87.08 RC121.1
  BOTTOM w0.076: UC1.H66 131.94,87.48 132.26,87.16 v1(132.39,87.16)
EMMC_CLK: length 62.5
  TOP w0.112: RM14.1 75.41,33.17 76.18,33.94 v2(76.51,33.94) 77.24,33.94 77.64,33.54 v1(77.64,33.2)
  IN3 w0.135: v1(77.64,33.2) 78.42,33.98 84.17,33.98 84.57,34.37 84.57,34.37 84.72,34.52 86.63,34.52 87.77,33.38 97.44,33.38 97.77,33.05 99.88,33.05 100.52,33.69 105.49,33.69 106.52,34.73 109.76,34.73 111.18,36.15 115.63,36.15 119.05,39.58 v1(119.26,39.58)
  BOTTOM w0.076: 119.89,48.68 120.06,48.85 120.06,49.24 120.19,49.37 120.19,50.16 120.18,50.17 120.18,50.47 120.19,50.48 120.19,50.8 120.11,50.94 119.99,51.06 119.99,51.1 119.8,51.29 UC1.AM3
  BOTTOM w0.112: v1(119.26,39.58) 119.69,39.58 120.82,40.71 120.82,41.2 121.24,41.62 121.24,43.01 120.04,44.22 120.04,46.59 119.69,46.94 119.69,47.28 119.84,47.43 119.84,48.63 119.89,48.68
EMMC_CLK_R: length 11.4
  TOP w0.089: UM1.M6 81.86,32.04 81.01,32.04 80.31,31.34 80.31,31.16
  TOP w0.112: 80.31,31.16 80.31,30.14 79.59,29.41 78.19,29.41 77.61,29.99 77.61,31.15 76.66,32.1 RM13.2 RM14.2 CM8.2
EMMC_CMD: length 59.8
  TOP w0.112: v1(78.71,40.6) 79.22,40.09 RM15.1
  IN1 w0.119: v1(119.13,42.73) 119.22,42.82 119.22,43.38 118.29,44.31 118.03,44.31 116.38,45.96 110.36,45.96 108.84,44.44 107.37,44.44 106.39,43.45 101.96,43.45 100.13,41.63 100.13,41.33 99.9,41.1 98.97,41.1 97.3,42.76 96.51,42.76 96.08,42.33 85.56,42.33 84.32,41.09 82.48,41.09 82.13,40.75 81.75,40.75 81.09,40.09 79.68,40.09 79.65,40.11 79.2,40.11 v1(78.71,40.6)
  BOTTOM w0.076: 117.54,48.68 117.54,48.71 118.49,49.66 118.53,49.66 118.7,49.84 118.7,49.84 118.7,50.14 118.7,50.15 118.7,50.49 118.7,50.49 118.7,51.69 UC1.AP4
  BOTTOM w0.112: 117.54,48.68 117.54,48.38 117.4,48.24 117.4,46.64 117.21,46.45 117.21,44.13 117.06,43.98 117.06,42.88 117.56,42.38 118.78,42.38 v1(119.13,42.73)
EMMC_CMD_R: length 9.7
  TOP w0.089: 80.31,32.76 80.79,32.76 81.01,32.54 81.78,32.54 82.04,32.79 UM1.M5
  TOP w0.112: 80.31,32.76 79.74,32.76 79.52,32.98 79.52,37.38 79.99,37.85 RM3.2 79.22,38.83 RM15.2
EMMC_D0_R: length 11.8
  TOP w0.112: UM1.A3 88.2,33.79 88.61,34.2 88.76,34.2 88.98,33.98 89.12,33.98 89.27,34.12 89.27,34.27 89.04,34.49 89.04,34.63 89.15,34.74 90.94,34.74 91.02,34.82 91.02,35.26 91.13,35.38 91.41,35.38 91.51,35.28 91.51,34.84 91.63,34.73 91.88,34.73 92,34.85 92,35.32 92.11,35.43 RPM1.7 93.28,35.43 93.47,35.24 93.47,34.87 93.7,34.64 94.62,34.64 95.65,35.67 RM16.2
EMMC_D1_R: length 10.5
  TOP w0.112: RM17.2 95.2,33.44 93.28,33.44 92.8,32.96 RPM2.5 92.39,32.86 92.29,32.96 92.29,33.14 92.74,33.6 92.74,33.79 92.52,34.02 92.32,34.02 91.56,33.25 87.65,33.25 UM1.A4
EMMC_D2_R: length 11.3
  TOP w0.112: UM1.A5 89.79,32.79 89.9,32.68 89.9,32.01 90.01,31.9 90.22,31.9 90.33,32.01 90.33,32.68 90.44,32.79 90.69,32.79 90.81,32.66 90.81,31.97 90.93,31.86 RPM2.7 93.14,31.86 93.4,31.59 93.4,31.3 93.63,31.07 94.51,31.07 95.55,32.11 RM18.2
EMMC_D3_R: length 12.3
  TOP w0.089: 87.94,34.72 87.76,34.54 87.36,34.54 UM1.B2
  TOP w0.112: RM19.2 95.36,37.66 93.98,37.66 93.23,36.9 93.23,36.56 93.1,36.43 RPM1.5 90.8,36.43 90.56,36.19 90.56,35.34 90.41,35.19 89.5,35.19 89.38,35.3 89.38,35.96 89.27,36.08 88.98,36.08 88.87,35.96 88.87,35.3 88.75,35.19 88.41,35.19 87.94,34.72
EMMC_D4_R: length 12.3
  TOP w0.089: UM1.B3 87.36,34.04 87.76,34.04
  TOP w0.112: 87.76,34.04 88.68,34.96 90.5,34.96 90.8,35.26 90.8,36.04 90.97,36.2 91.22,36.2 91.33,36.09 91.33,35.73 91.45,35.62 91.69,35.62 91.8,35.73 91.8,36.09 91.92,36.2 92.3,36.2 92.57,35.93 RPM1.6 93.2,35.93 93.44,36.18 93.44,36.81 93.99,37.36 94.31,37.36 94.78,36.89 94.91,36.89 95.24,36.55 RM20.2
EMMC_D5_R: length 13.1
  TOP w0.089: 87.93,33.54 87.36,33.54 UM1.B4
  TOP w0.112: 87.93,33.54 89.37,33.54 89.52,33.69 89.52,34.36 89.63,34.48 89.89,34.48 90,34.36 90,33.64 90.11,33.52 90.38,33.52 90.49,33.64 90.49,34.36 90.6,34.48 90.9,34.48 91.01,34.36 91.01,33.71 91.12,33.6 91.42,33.6 91.53,33.71 91.53,34.36 91.64,34.48 92.02,34.48 92.48,34.93 RPM1.8 93.11,34.93 93.62,34.43 94.71,34.43 95.06,34.78 RM21.2
EMMC_D6_R: length 10.9
  TOP w0.089: UM1.B5 87.37,33.04 87.92,33.04 87.94,33.02
  TOP w0.112: 87.94,33.02 90.98,33.02 91.09,32.9 91.09,32.42 91.2,32.3 91.46,32.3 91.58,32.42 91.58,32.9 91.69,33.02 91.94,33.02 92.06,32.9 92.06,32.47 92.17,32.36 RPM2.6 93.17,32.36 93.34,32.53 93.34,32.9 93.6,33.16 94.95,33.16 95.11,33 RM22.2
EMMC_D7_R: length 10.9
  TOP w0.089: 87.94,32.54 87.37,32.54 UM1.B6
  TOP w0.112: 87.94,32.54 88.52,32.54 88.63,32.43 88.63,32.03 88.74,31.92 88.99,31.92 89.1,32.03 89.1,32.43 89.21,32.54 89.52,32.54 89.61,32.46 89.61,31.71 89.71,31.61 92.15,31.61 92.39,31.36 RPM2.8 93.04,31.36 93.57,30.83 94.56,30.83 94.95,31.22 RM23.2
EMMC_DATA0: length 59.8
  TOP w0.112: RM16.1 97.06,35.17 97.06,34.92 97.17,34.81 97.52,34.81 97.93,34.4 98.38,34.4 98.49,34.29 v2(98.49,34.15) 98.49,34.01 98.61,33.9 98.83,33.9 98.94,34.01 98.94,34.29 99.05,34.4 99.28,34.4 99.39,34.29 99.39,34 99.5,33.88 100.16,33.88 100.27,33.77 100.27,33.12 100.19,33.03 99.94,33.03 99.89,32.97 99.89,32.53 100.74,31.68 101.03,31.68 101.14,31.79 101.14,32.33 100.72,32.75 100.72,33.71 100.83,33.82 101.06,33.82 101.17,33.71 101.17,32.99 101.28,32.88 101.5,32.88 101.61,32.99 101.61,33.71 101.73,33.82 104.18,33.82 104.47,34.11 104.82,34.11 105.71,35 105.87,35 106.29,34.59 106.44,34.59 106.95,35.1 109.94,35.1 111.07,36.23 111.07,36.39 109.53,37.93 108.81,37.93 108.7,38.04 108.7,38.3 108.81,38.41 109.22,38.41 109.33,38.52 109.33,38.8 109.22,38.91 108.57,38.91 108.46,39.02 108.46,39.25 108.57,39.36 109.15,39.36 109.27,39.47 109.27,39.69 109.15,39.81 108.81,39.81 108.7,39.92 108.7,40.14 108.81,40.25 109.15,40.25 109.27,40.37 109.27,40.59 109.15,40.7 108.81,40.7 108.7,40.81 108.7,41.04 108.81,41.15 109.32,41.15 109.69,41.52 109.69,41.74 109.54,41.89 109.54,42.05 109.7,42.2 109.85,42.2 109.9,42.15 110.06,42.15 110.22,42.31 110.22,42.47 110.17,42.52 110.17,42.68 110.33,42.84 110.49,42.84 110.54,42.79 110.69,42.79 110.85,42.94 110.85,43.1 110.62,43.34 110.62,43.5 110.77,43.66 110.93,43.66 111.17,43.42 111.33,43.42 111.5,43.59 112.25,43.59 112.37,43.7 112.37,43.96 112.48,44.07 112.7,44.07 112.81,43.96 112.81,43.72 112.92,43.61 113.15,43.61 113.26,43.72 113.26,43.96 113.37,44.07 113.59,44.07 113.71,43.96 113.71,43.72 113.84,43.59 114.66,43.59 114.83,43.42 114.99,43.42 115.47,43.9 115.63,43.9 115.79,43.74 115.79,43.59 115.31,43.1 115.31,42.95 115.48,42.78 115.63,42.78 116.14,43.28 116.3,43.28 116.45,43.12 116.45,42.96 115.95,42.46 115.95,42.3 116.21,42.05 116.37,42.05 116.53,42.21 v1(116.53,42.39)
  BOTTOM w0.076: 116.83,48.68 116.83,48.76 117.21,49.15 117.46,49.15 118.2,49.88 118.2,50.14 118.31,50.26 118.31,50.36 118.2,50.47 118.2,50.6 118.29,50.69 118.4,50.69 UC1.AP2
  BOTTOM w0.112: v1(116.53,42.39) 116.31,42.39 116.17,42.52 116.17,43.27 115.96,43.49 115.96,43.77 116.58,44.39 116.58,46.71 116.77,46.9 116.77,47.8 116.58,47.98 116.58,48.22 116.77,48.41 116.77,48.49 116.83,48.55 116.83,48.68
EMMC_DATA1: length 60.8
  TOP w0.112: RM17.1 97,33.45 97,33.01 97.2,32.81 97.36,32.81 97.43,32.88 97.59,32.88 97.75,32.73 97.75,32.57 97.68,32.49 97.68,32.28 97.79,32.17 99.37,32.17 100.06,31.47 v2(100.06,30.03) 100.06,29.44 100.17,29.33 100.9,29.33 101.01,29.44 101.01,29.66 100.84,29.83 100.61,29.83 100.5,29.93 100.5,30.9 100.62,31.01 100.94,31.01 101.05,30.9 101.05,30.66 101.16,30.55 101.46,30.55 101.57,30.66 101.57,30.94 101.68,31.05 103.16,31.05 103.2,31.09 104.91,31.09 105.02,31.2 105.02,31.57 104.91,31.69 103.44,31.69 103.03,32.09 103.03,32.62 103.58,33.16 105.11,33.16 105.74,33.8 108.38,33.8 108.52,33.66 108.52,33.3 108.64,33.18 108.94,33.18 109.05,33.29 109.05,33.65 109.2,33.8 110.18,33.8 110.29,33.69 110.29,33.32 110.18,33.21 109.8,33.21 109.46,32.86 109.11,32.86 109.04,32.79 109.04,32.29 109.13,32.2 110.53,32.2 110.6,32.27 110.6,33.82 112.43,35.65 114.9,35.65 115.33,36.08 115.49,36.08 115.93,35.63 116.09,35.63 116.24,35.79 116.24,35.95 115.8,36.39 115.8,36.55 115.96,36.71 116.12,36.71 116.5,36.33 116.66,36.33 116.82,36.48 116.82,36.64 116.43,37.03 116.43,37.18 116.68,37.43 116.68,37.68 116.68,37.68 116.76,37.85 117.13,38.65 117.14,38.65 117.14,38.92 117.79,39.57 118.25,41.87 118.38,41.97 v1(118.59,41.97)
  BOTTOM w0.076: 117.23,48.68 117.27,48.68 118.45,49.85 UC1.AP1
  BOTTOM w0.112: v1(118.59,41.97) 118.65,42.03 119.02,42.03 119.13,41.92 119.13,41.46 119.02,41.34 118.48,41.34 117.79,42.03 117.05,42.03 116.94,42.14 116.94,42.56 116.49,43.01 116.49,43.86 116.9,44.26 116.9,46.58 117.08,46.77 117.08,48.37 117.2,48.49 117.2,48.65 117.23,48.68
EMMC_DATA2: length 60.6
  TOP w0.112: RM18.1 97.14,31.54 99.11,31.54 99.4,31.24 99.4,28.81 99.51,28.7 101.88,28.7 101.99,28.81 101.99,29.36 102.1,29.47 102.75,29.47 103.73,30.46 105.78,30.46 105.93,30.61 105.93,31.8 105.51,32.23 105.51,32.63 106.04,33.17 107.76,33.17 107.87,33.06 107.87,30.88 108.01,30.74 v2(108.26,30.74) 110.46,30.74 110.73,31.01 110.73,31.4 111.23,31.91 111.23,33.56 112.69,35.02 114.29,35.02 114.73,34.57 114.73,33.64 114.84,33.53 115.24,33.53 117.72,36.01 117.72,37.69 118.43,38.39 118.43,39.34 119.15,40.06 119.41,40.06 119.52,40.18 119.52,40.67 119,41.19 119,41.35 119.66,42.02 v1(119.97,42.02)
  BOTTOM w0.076: UC1.AP3 118.45,51.26 118.04,50.85 118.04,50.22 118.03,50.21 118.03,49.95 117.39,49.31 117.14,49.31 116.51,48.68
  BOTTOM w0.112: 116.51,48.68 116.51,48.68 116.45,48.62 116.45,48.54 116.27,48.35 116.27,44.52 115.74,44 114.81,44 114.69,43.88 114.69,43.39 114.8,43.28 115.72,43.28 115.86,43.14 115.86,42.39 116.55,41.71 117.67,41.71 118.35,41.03 119.35,41.03 119.46,41.14 119.46,41.54 119.94,42.02 v1(119.97,42.02)
EMMC_DATA3: length 59.4
  TOP w0.112: RM19.1 96.91,37.35 97.02,37.23 97.02,36.45 97.33,36.14 97.33,35.9 98.19,35.03 98.75,35.03 98.87,35.15 98.87,35.6 98.98,35.71 100.17,35.71 100.24,35.77 100.24,36.13 99.83,36.53 99.37,36.53 98.91,37 98.91,37.32 99.25,37.66 99.54,37.66 v2(99.86,37.35) 100.97,36.24 100.97,36.04 100.8,35.87 100.8,35.5 101,35.3 101,34.73 101.09,34.64 101.6,34.64 101.79,34.45 103.55,34.45 103.66,34.56 103.66,34.86 104.01,35.21 104.7,35.21 104.81,35.33 104.81,35.79 104.95,35.92 105.75,35.92 106.07,36.24 106.07,36.63 106.3,36.86 106.61,36.86 107.24,36.23 107.35,36.23 107.86,36.74 108.25,36.74 108.37,36.63 108.37,35.84 108.48,35.73 108.9,35.73 109.01,35.84 109.01,36.34 109.25,36.58 109.53,36.58 109.64,36.7 109.64,36.93 109.27,37.3 108.55,37.3 108.22,37.63 108.06,37.63 107.33,36.89 107.17,36.89 106.9,37.17 106.9,37.32 107.7,38.13 107.7,38.34 107.54,38.51 107.54,39.24 107.65,39.35 107.68,39.35 108.07,39.75 108.07,41.47 108.36,41.76 108.37,41.76 108.39,41.78 108.77,41.78 108.91,41.92 108.91,42.31 109.93,43.33 109.93,43.93 110.41,44.41 110.63,44.41 110.76,44.29 111.61,44.29 111.72,44.4 111.72,44.59 111.83,44.7 112.89,44.7 113,44.81 113,45.43 112.52,45.91 112.52,46.09 112.64,46.2 114.5,46.2 116.97,43.73 118.16,43.73 v1(118.25,43.65)
  BOTTOM w0.076: UC1.AN3 118.96,51.62 118.87,51.53 118.87,51.36 118.96,51.27 119.22,51.27 119.37,51.12 119.37,50.17 119.35,50.15 119.35,49.79 118.49,48.93 118.49,48.68
  BOTTOM w0.112: 118.49,48.68 118.49,47.99 118.34,47.84 118.34,46.38 118.69,46.03 118.69,45.58 118.57,45.47 118.27,45.47 118.15,45.36 118.15,45.14 118.27,45.03 118.57,45.03 118.69,44.91 118.69,43.76 118.57,43.65 v1(118.25,43.65)
EMMC_DATA4: length 59.8
  TOP w0.112: RM20.1 96.57,36.46 97.01,36.01 97.01,35.77 98.06,34.72 99.07,34.72 99.18,34.83 99.18,35.28 99.29,35.39 99.57,35.39 99.68,35.28 99.68,34.42 99.8,34.3 100.1,34.3 100.22,34.41 100.22,35.19 100.33,35.3 100.55,35.3 100.66,35.19 v2(100.66,34.88) 100.66,34.24 100.78,34.13 101.01,34.13 101.2,34.32 101.47,34.32 101.66,34.13 104.05,34.13 104.18,34.26 104.18,34.42 104.01,34.58 104.01,34.74 104.17,34.9 104.54,34.9 104.77,34.66 104.93,34.66 105.25,34.99 105.25,35.14 105.14,35.26 105.14,35.42 105.3,35.57 105.46,35.57 105.62,35.41 105.91,35.41 106.28,35.03 106.44,35.03 106.66,35.25 106.66,35.44 106.27,35.84 106.27,36 106.46,36.19 106.62,36.19 107.4,35.41 109.81,35.41 110.63,36.23 110.63,36.39 109.4,37.62 108.68,37.62 108.39,37.91 108.39,38.37 108.22,38.53 107.97,38.53 107.86,38.64 107.86,38.86 107.97,38.97 108.04,38.97 108.15,39.09 108.15,39.38 108.39,39.62 108.39,41.34 108.51,41.46 109.11,41.46 109.22,41.57 109.22,42.18 110.25,43.2 110.25,43.8 110.42,43.97 110.71,43.97 110.95,43.97 111.93,43.97 112.35,44.39 113.21,44.39 113.32,44.5 113.32,45.55 113.27,45.6 113.27,45.78 113.38,45.89 113.69,45.89 113.85,45.73 113.85,45.37 113.98,45.25 114.13,45.25 114.27,45.38 114.27,45.61 114.38,45.72 114.54,45.72 115,45.26 115,44.99 114.89,44.88 113.83,44.88 113.68,44.73 113.68,44.44 113.94,44.17 114.2,43.91 115.03,43.91 115.34,44.22 115.43,44.22 115.66,44.44 115.82,44.44 116.9,43.36 116.9,42.58 117.01,42.47 117.23,42.47 117.35,42.58 117.35,43.28 117.47,43.4 117.74,43.4 117.98,43.16 118.26,43.16 118.37,43.05 v1(118.37,42.79)
  BOTTOM w0.076: 118.17,48.68 118.17,48.84 118.76,49.43 118.94,49.61 119.03,49.71 119.03,49.71 119.18,49.87 119.18,50.25 UC1.AN1
  BOTTOM w0.112: v1(118.37,42.79) 118.38,42.8 118.38,43.09 118.27,43.2 117.87,43.2 117.69,43.38 117.69,43.72 117.84,43.87 117.84,44.09 117.95,44.2 118.24,44.2 118.35,44.32 118.35,44.6 118.24,44.71 117.95,44.71 117.84,44.82 117.84,46.19 118.03,46.38 118.03,47.97 118.17,48.12 118.17,48.68
EMMC_DATA5: length 57.9
  TOP w0.112: v1(117.79,42.79) 118.04,42.54 118.04,42.26 117.93,42.15 116.91,42.15 116.46,41.7 116.46,41.54 116.68,41.32 116.84,41.32 117.12,41.6 117.64,41.6 117.77,41.52 117.83,41.37 117.68,40.62 117.55,40.53 117.03,40.64 116.9,40.55 116.86,40.33 116.94,40.2 117.46,40.09 117.55,39.96 117.5,39.73 116.83,39.06 116.82,39.02 116.82,38.73 116.56,38.2 116.46,37.97 116.39,37.86 116.34,37.76 116.19,37.56 116.04,37.34 115.96,37.26 115.62,36.81 115.06,36.51 114.89,36.4 114.73,36.33 114.05,35.96 112.3,35.96 112.09,35.75 111.93,35.75 111.56,36.12 111.4,36.12 111.25,35.96 111.25,35.8 111.61,35.43 111.61,35.28 111.45,35.12 111.3,35.12 110.93,35.49 110.77,35.49 110.61,35.33 110.61,35.17 110.98,34.8 110.98,34.64 110.45,34.12 110.21,34.12 110.1,34.23 110.1,34.67 109.99,34.78 109.77,34.78 109.65,34.67 109.65,34.23 109.54,34.12 109.32,34.12 109.21,34.23 109.21,34.67 109.1,34.78 108.87,34.78 108.76,34.67 108.76,34.23 108.65,34.12 108.43,34.12 108.31,34.23 108.31,34.67 108.2,34.78 107.98,34.78 107.87,34.67 107.87,34.23 107.75,34.12 107.53,34.12 107.42,34.23 107.42,34.67 107.31,34.78 107.08,34.78 106.97,34.67 106.97,34.23 106.86,34.12 106.31,34.12 105.87,34.55 105.71,34.55 104.66,33.5 103.06,33.5 102.95,33.39 102.95,32.99 102.84,32.87 102.62,32.87 102.5,32.99 102.5,33.39 102.39,33.5 102.15,33.5 102.04,33.39 102.04,32.68 101.93,32.57 101.57,32.57 101.46,32.46 101.46,31.95 101.59,31.81 102.87,31.81 102.98,31.7 102.98,31.48 102.87,31.37 v2(100.61,31.37) 99.58,32.4 99.58,33.02 99.46,33.13 99.07,33.13 98.96,33.02 98.96,32.56 98.88,32.48 98.49,32.48 98.38,32.59 98.38,32.76 98.27,32.88 98.05,32.88 97.86,33.06 97.86,33.22 98.18,33.55 98.18,33.7 98.03,33.86 97.87,33.86 97.53,33.53 97.37,33.53 97.21,33.68 97.21,33.84 97.55,34.18 97.55,34.34 97.39,34.5 97.24,34.5 97.12,34.38 96.96,34.38 RM21.1
  BOTTOM w0.076: 117.86,48.68 117.86,48.76 118.65,49.55 118.82,49.73 118.87,49.77 118.87,49.91 118.87,50.21 118.86,50.22 118.86,50.42 118.87,50.43 118.87,50.89 118.94,50.97 UC1.AN2
  BOTTOM w0.112: v1(117.79,42.79) 117.6,42.79 117.38,43.01 117.38,43.85 117.53,44 117.53,46.32 117.71,46.51 117.71,48.11 117.86,48.25 117.86,48.68
EMMC_DATA6: length 60.5
  TOP w0.112: RM22.1 97.06,32.5 97.06,32.06 97.27,31.85 99.24,31.85 99.72,31.37 99.72,29.12 99.83,29.01 101.52,29.01 101.63,29.12 v2(101.63,29.61) 101.81,29.78 102.62,29.78 103.6,30.77 105.25,30.77 105.37,30.89 105.37,31.89 105.26,32 103.72,32 103.61,32.11 103.61,32.58 103.87,32.85 105.24,32.85 105.88,33.49 108.04,33.49 108.19,33.34 108.19,31.77 108.33,31.62 108.54,31.62 108.66,31.74 108.66,31.86 108.74,31.94 108.94,31.94 109.15,31.73 109.15,31.17 109.26,31.06 109.59,31.06 109.7,31.17 109.7,31.79 109.8,31.89 110.74,31.89 110.92,32.06 110.92,33.69 112.56,35.33 114.93,35.33 115.05,35.22 115.05,34.44 115.16,34.33 115.49,34.33 115.6,34.44 115.6,34.9 115.72,35.01 116.28,35.01 116.42,35.15 116.42,35.52 116.63,35.74 117,35.74 117.13,35.87 117.13,36.49 117.41,36.76 117.41,37.09 117.13,37.37 117.13,37.91 117.55,38.33 117.92,38.33 118.11,38.52 118.11,39.47 118.19,39.56 118.19,39.83 118.4,40.03 118.67,40.03 119.03,40.39 v1(119.03,40.57)
  BOTTOM w0.076: UC1.AM4 119.78,52.04 119.7,52.12 119.51,52.12 119.45,52.06 119.45,51.92 119.41,51.88 119.41,51.3 119.53,51.19 119.53,51.08 119.66,50.94 119.88,50.94 119.98,50.84 120.03,50.76 120.03,50.54 120.02,50.54 120.02,50.1 120.03,50.09 120.03,49.65 119.86,49.48 119.86,49.11 119.42,48.68
  BOTTOM w0.112: v1(119.03,40.57) 118.87,40.41 118.87,40.14 119.01,40 119.52,40 119.75,40.22 119.75,40.38 119.53,40.6 119.53,40.77 119.68,40.91 119.85,40.91 120.06,40.7 120.22,40.7 120.4,40.88 120.4,41.37 120.83,41.79 120.83,42.84 119.62,44.04 119.62,46.42 119.28,46.76 119.28,47.46 119.42,47.6 119.42,48.68 119.42,48.68
