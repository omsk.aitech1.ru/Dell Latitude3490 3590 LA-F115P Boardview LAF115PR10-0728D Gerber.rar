# Allegro board LAF115PR10-0728D_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_CTX_LANRX_P5: length 274.5
  TOP w0.112: v1(30.49,81.63) 30.3,81.82 30.04,81.82 CL3.2
  IN1 w0.119: v1(111.46,120.57) 111.32,120.71 111.32,120.71 110.37,120.71 107.71,118.05 95.49,118.05 94.81,118.73 90.04,118.73 89.61,119.16 87.41,119.16 87.15,119.42 83.48,119.42 80.95,121.95 79.12,121.95 78.94,122.13 77.85,122.13 76.19,123.79 72.09,123.79 71.62,123.33 69.47,123.33 68.52,124.28 68.52,124.88 67.36,126.04 66.36,126.04 62.12,130.28 59.9,130.28 57.44,132.75 54.04,132.75 53.14,131.84 51.09,131.84 51.08,131.83 50.44,131.83 v1(50.27,131.67)
  IN3 w0.135: v1(50.27,131.67) 50.45,131.84 50.9,131.84 51.15,131.58 51.15,130.16 50.17,129.18 50.17,127.6 48.76,126.19 48.76,124.96 47.14,123.34 47.14,121.4 47.58,120.95 47.58,119.07 43.32,114.8 43.32,114.09 42.73,113.51 42.2,113.51 40.7,112.01 40.7,111.73 39.84,110.87 34.88,110.87 34.11,110.09 32.8,110.09 31.45,110.09 30.57,110.09 30.36,109.89 23.35,109.89 20.7,107.23 16.63,107.23 15.46,106.06 15.46,102.72 14.01,101.27 14.01,91.21 16.94,88.29 22.15,88.29 23.47,86.97 23.47,84.9 23.96,84.4 25.02,84.4 25.99,83.42 26.24,83.42 27.84,81.82 30.3,81.82 v1(30.49,81.63) ; v1(144.87,57.31) 144.69,57.49 144.38,57.49 143.59,58.28 143.59,62.15 143.94,62.5 143.94,67.47 146.36,69.88 147.22,69.88 148.9,71.56 148.9,80.23 148.77,80.36 147.33,80.36 146.48,81.22 146.48,87.84 146.77,88.13 147.9,88.13 148.47,88.7 148.47,89.55 145.18,92.84 145.18,94.9 144.45,95.63 144.45,105.77 140.04,110.17 138.77,110.17 137.61,111.34 137.31,111.34 136.39,112.26 136.39,113.31 135.59,114.1 135.59,115.35 130.93,120.01 130.51,120.01 129.52,120.01 126.54,122.99 125.73,122.99 123.74,121.01 122.45,121.01 122.15,120.71 120.04,120.71 119.71,120.39 117.65,120.39 116.6,121.44 113.74,121.44 113.05,120.74 111.63,120.74 v1(111.46,120.57)
  BOTTOM w0.076: UC1.D19 134.67,60.95 134.75,60.87 134.75,60.68 134.94,60.49 135.33,60.49 135.55,60.56 135.67,60.56 135.67,60.56 135.73,60.55 135.78,60.53 137.08,60.53 137.31,60.75 138.15,60.75 138.44,61.04 138.8,61.04
  BOTTOM w0.112: v1(144.87,57.31) 144.72,57.46 144.12,57.46 144.12,57.46 143.71,57.46 143.7,57.46 143.21,57.46 143.2,57.46 142.79,57.46 142.79,57.46 142.29,57.46 141.52,58.23 141.52,59.48 139.95,61.04 v4(139.35,61.04) 138.8,61.04
PCIE_CTX_NVMERX_N9: length 151.6
  IN1 w0.076: 138.81,64.31 138.8,64.32 138.8,64.36 138.24,64.92 138.24,65.36 138.41,65.53 138.62,65.53 138.96,65.87 v1(138.96,65.95)
  IN1 w0.119: v1(36.47,37.6) 36.2,37.34 36.2,36.84 37.17,35.88 38.52,35.88 38.95,36.3 45.96,36.3 47.23,37.58 57.92,37.58 63.45,32.05 65.72,32.05 66.65,31.12 73.44,31.12 74.83,29.73 77.18,29.73 78.13,28.78 89.36,28.78 90.47,29.89 91.18,29.89 91.58,30.28 97.24,30.28 97.53,30 98.9,30 99.47,29.42 102.39,29.42 103.69,30.72 112.1,30.72 112.9,31.52 116.12,31.52 116.68,32.09 119.04,32.09 119.41,31.71 129.98,31.71 130.86,32.59 132.12,32.59 133.2,33.68 134.3,33.68 136.18,35.56 139.48,35.56 141.25,37.32 141.25,37.8 141.39,37.93 141.39,45.57 140.54,46.41 140.54,47.56 141.35,48.36 141.35,49.89 140.29,50.94 140.29,52.69 140.42,52.82 140.42,54.21 140.28,54.34 140.28,58.18 139.26,59.21 139.26,63.86 138.81,64.31
  BOTTOM w0.076: v1(138.96,65.95) 138.76,65.75 138.42,65.75 137.98,65.31 137.98,65.02 136.85,63.89 136.36,63.89 UC1.B23
  BOTTOM w0.112: CS16.1 36.55,36.95 36.27,37.23 36.27,37.41 v1(36.47,37.6)
PCIE_CTX_NVMERX_N10: length 158.4
  IN1 w0.119: v1(33.94,37.59) 33.89,37.59 33.75,37.45 33.75,37.38 33.57,37.2 33.57,36.94 34.41,36.1 35.82,36.1 36.69,35.23 41.46,35.23 41.89,35.66 46.22,35.66 47.49,36.93 57.49,36.93 63.02,31.41 65.45,31.41 66.43,30.43 73.23,30.43 75.53,28.12 89.69,28.12 90.43,28.86 91.75,28.86 92.34,29.45 96.17,29.45 96.84,28.78 102.66,28.78 103.96,30.08 107.42,30.08 108.19,29.31 112.21,29.31 113.78,30.88 116.38,30.88 116.95,31.44 118.77,31.44 119.15,31.07 130.25,31.07 131.13,31.95 132.38,31.95 133.46,33.03 134.56,33.03 136.45,34.91 140.04,34.91 142.3,37.17 142.3,37.73 142.07,37.95 142.07,44.68 142.35,44.96 142.35,46.16 142.01,46.49 142.01,50.13 140.94,51.21 140.94,52.43 141.06,52.55 141.06,54.47 140.93,54.61 140.93,58.49 139.9,59.52 139.9,61.01 140.4,61.51 140.4,63.27 140.6,63.46 140.6,64.15 140.53,64.21 140.31,64.21 140.23,64.3 v1(140.23,64.57)
  BOTTOM w0.076: UC1.D23 134.72,63.43 134.9,63.25 134.9,63.1 134.93,63.07 134.97,63.03 135.15,62.94 135.27,62.93 135.51,63.03 135.63,63.03 135.73,62.99 135.97,62.99 136.11,63.03 136.3,63.03 136.3,63.03 136.48,63 136.8,63 137.05,63.25 137.08,63.25 137.18,63.36 137.18,63.41 137.2,63.43 137.2,63.44
  BOTTOM w0.112: v1(33.94,37.59) 33.83,37.59 33.77,37.52 33.77,37.47 33.75,37.46 33.75,37.14 33.95,36.95 CS18.1 ; 137.2,63.44 137.2,63.47 138.29,64.56 v4(138.78,64.56) 139.22,64.56 140.06,65.4 140.43,65.4 140.59,65.24 140.59,64.94 v1(140.23,64.57)
PCIE_CTX_NVMERX_N11: length 165
  IN1 w0.119: v1(30.84,37.6) 30.84,37.53 30.47,37.17 30.47,36.78 31.12,36.13 33.48,36.13 35.01,34.59 41.72,34.59 42.15,35.02 46.49,35.02 47.76,36.29 57.23,36.29 62.75,30.77 64.43,30.77 65.58,29.61 73.13,29.61 75.27,27.48 89.95,27.48 90.61,28.14 103.12,28.14 103.58,28.6 104.12,28.6 104.93,29.41 107.18,29.41 107.93,28.66 112.47,28.66 114.05,30.23 116.65,30.23 117.21,30.79 118.51,30.79 118.88,30.42 130.51,30.42 131.4,31.31 133.19,31.31 134.11,32.23 134.67,32.23 136.71,34.27 140.31,34.27 142.94,36.9 142.94,39.26 143.79,40.12 143.79,41.76 143.94,41.91 143.94,43.94 143.14,44.74 143.14,46.28 142.65,46.77 142.65,50.4 142.11,50.94 142.11,54.33 141.57,54.87 141.57,60.92 141.3,61.19 141.3,65.13 141.18,65.25 140.02,65.25 139.71,65.56 139.71,66.32 140.09,66.7 140.38,66.7 v1(140.58,66.9)
  BOTTOM w0.076: 139.18,66.92 138.97,66.92 137.33,65.29 137.33,64.92 136.71,64.3 135.48,64.3 135.17,63.99 UC1.D24
  BOTTOM w0.112: v1(140.58,66.9) 139.19,66.92 139.18,66.92 ; CS20.1 30.9,36.95 30.64,37.21 30.64,37.4 v1(30.84,37.6)
PCIE_CTX_NVMERX_N12: length 182.6
  IN1 w0.119: v1(140.33,67.99) 140.5,68.16 140.5,68.16 140.7,68.36 141.71,68.36 141.83,68.24 141.83,67.81 142.59,67.06 142.59,61.72 142.85,61.45 142.85,55.41 143.4,54.86 143.4,52.21 144.04,51.57 144.04,49.35 146.36,47.03 147.86,47.03 148.07,46.82 148.07,42.13 146.85,40.92 145.78,40.92 145.08,40.21 145.08,39.58 144.22,38.73 144.22,36.37 140.84,32.99 139.19,32.99 136.13,29.92 131.83,29.92 131.02,29.1 129.31,29.1 128.83,28.62 118.92,28.62 118.7,28.84 114.47,28.84 112.79,27.16 107.61,27.16 107.14,27.63 104.99,27.63 104.66,27.31 104.13,27.31 103.67,26.85 100.29,26.85 99.36,25.92 97.47,25.92 96.83,26.56 95.12,26.56 94.46,25.89 75.03,25.89 73.15,27.78 67.77,27.78 67.24,28.3 63.12,28.3 56.49,34.94 48.65,34.94 45.59,31.87 41.15,31.87 39.71,33.31 34.4,33.31 33.49,34.22 30.95,34.22 30.45,34.72 28.31,34.72 27.81,35.21 27.81,36.22 28.42,36.83 29.31,36.83 29.61,37.13 29.61,37.61 29.37,37.84 29.37,38.36 v1(29.37,38.36)
  BOTTOM w0.076: 139.18,67.74 139.12,67.74 136.82,65.45 136.82,65.33 136.82,65.33 136.82,65.19 136.46,64.83 136.46,64.83 136.44,64.81 136.32,64.81 136.24,64.73 136.24,64.63 136.32,64.55 136.54,64.55 UC1.A25
  BOTTOM w0.112: CS22.1 27.98,37.01 27.65,37.34 27.59,37.34 27.47,37.46 27.47,37.62 27.63,37.78 28.16,37.78 28.74,37.21 29.19,37.21 29.43,37.45 29.43,37.79 29.37,37.85 v1(29.37,38.36) ; 139.18,67.74 139.23,67.74 139.83,68.34 139.98,68.34 v1(140.33,67.99)
PCIE_CTX_NVMERX_P9: length 151.7
  IN1 w0.076: v1(138.96,65.37) 138.48,65.37 138.4,65.29 138.4,64.99 138.91,64.47 138.95,64.47 138.96,64.46
  IN1 w0.119: 138.96,64.46 139.39,64.04 139.47,63.95 139.47,59.3 140.5,58.27 140.5,54.43 140.64,54.3 140.64,52.73 140.51,52.6 140.51,51.03 141.57,49.98 141.57,48.27 140.76,47.47 140.76,46.51 141.6,45.66 141.6,37.84 141.46,37.7 141.46,37.23 139.57,35.34 136.27,35.34 134.39,33.46 133.29,33.46 132.21,32.37 130.96,32.37 130.07,31.49 119.32,31.49 118.94,31.87 116.77,31.87 116.21,31.3 112.99,31.3 112.19,30.5 103.78,30.5 102.48,29.2 99.38,29.2 98.81,29.78 97.44,29.78 97.15,30.07 91.67,30.07 91.27,29.68 90.56,29.68 89.45,28.56 78.04,28.56 77.08,29.51 74.74,29.51 73.35,30.9 66.56,30.9 65.63,31.83 63.36,31.83 57.83,37.36 47.32,37.36 46.05,36.09 39.04,36.09 38.61,35.66 37.07,35.66 35.99,36.75 35.99,37.5 v1(35.88,37.6)
  BOTTOM w0.076: UC1.A23 136.53,63.41 136.39,63.41 136.32,63.49 136.32,63.61 136.43,63.73 136.92,63.73 138.15,64.95 138.15,65.24 138.49,65.59 138.88,65.59 138.96,65.51 v1(138.96,65.37)
  BOTTOM w0.112: v1(35.88,37.6) 36.05,37.43 36.05,37.27 CS17.1
PCIE_CTX_NVMERX_P10: length 158.4
  IN1 w0.119: v1(140.81,64.57) 140.81,63.37 140.62,63.18 140.62,61.42 140.12,60.92 140.12,59.61 141.14,58.58 141.14,54.7 141.28,54.56 141.28,52.46 141.15,52.34 141.15,51.3 142.23,50.22 142.23,46.58 142.57,46.25 142.57,44.86 142.29,44.59 142.29,38.04 142.51,37.82 142.51,37.07 140.13,34.7 136.54,34.7 134.65,32.81 133.55,32.81 132.47,31.73 131.22,31.73 130.34,30.85 119.06,30.85 118.68,31.22 117.04,31.22 116.47,30.66 113.87,30.66 112.3,29.09 108.1,29.09 107.33,29.86 104.05,29.86 102.75,28.56 96.75,28.56 96.08,29.23 92.43,29.23 91.84,28.64 90.52,28.64 89.78,27.9 75.44,27.9 73.14,30.21 66.34,30.21 65.36,31.19 62.93,31.19 57.4,36.71 47.59,36.71 46.31,35.44 41.98,35.44 41.55,35.02 36.6,35.02 35.73,35.88 34.32,35.88 33.36,36.85 v1(33.36,37.57)
  BOTTOM w0.076: UC1.C23 135.24,63.43 135.14,63.43 135.06,63.35 135.06,63.17 135.06,63.16 135.19,63.1 135.36,63.15 135.36,63.15 135.37,63.15 135.47,63.2 135.67,63.2 135.77,63.15 135.94,63.15 136.08,63.2 136.36,63.2 136.38,63.18 136.43,63.17 136.74,63.17 137,63.44
  BOTTOM w0.112: v1(33.36,37.57) 33.53,37.4 33.53,37.29 CS19.1 ; v1(140.81,64.57) 140.81,65.33 140.52,65.62 139.97,65.62 139.14,64.79 138.25,64.79 137,63.55 137,63.44
PCIE_CTX_NVMERX_P11: length 165
  IN1 w0.119: v1(140.58,66.31) 140.42,66.48 140.18,66.48 139.92,66.23 139.92,65.65 140.12,65.46 141.27,65.46 141.52,65.22 141.52,61.28 141.79,61.01 141.79,54.96 142.33,54.42 142.33,51.03 142.87,50.49 142.87,46.86 143.36,46.37 143.36,44.83 144.16,44.03 144.16,41.82 144.01,41.67 144.01,40.03 143.16,39.17 143.16,36.81 140.4,34.05 136.81,34.05 134.76,32.01 134.2,32.01 133.28,31.09 131.49,31.09 130.61,30.2 118.79,30.2 118.42,30.57 117.3,30.57 116.74,30.02 114.14,30.02 112.56,28.44 107.84,28.44 107.09,29.19 105.03,29.19 104.21,28.38 103.67,28.38 103.21,27.92 90.7,27.92 90.04,27.26 75.18,27.26 73.04,29.4 65.49,29.4 64.34,30.55 62.66,30.55 57.14,36.07 47.85,36.07 46.58,34.8 42.24,34.8 41.82,34.37 34.92,34.37 33.39,35.91 31.03,35.91 30.26,36.69 v1(30.26,37.6)
  BOTTOM w0.076: 139.18,66.7 139.17,66.7 139.13,66.74 139.02,66.74 137.5,65.22 137.5,64.85 136.77,64.13 136.06,64.13 135.99,64.05 135.99,63.88 135.79,63.68 135.65,63.68 135.57,63.76 UC1.C24
  BOTTOM w0.112: 139.18,66.7 140.21,66.68 v1(140.58,66.31) ; v1(30.26,37.6) 30.42,37.43 30.42,37.23 CS21.1
PCIE_CTX_NVMERX_P12: length 182.7
  IN1 w0.119: v1(28.96,37.95) 29.39,37.52 29.39,37.22 29.22,37.04 28.33,37.04 27.59,36.31 27.59,35.12 28.22,34.5 30.36,34.5 30.86,34 33.4,34 34.31,33.09 39.62,33.09 41.06,31.66 45.68,31.66 48.74,34.72 56.4,34.72 63.03,28.09 67.15,28.09 67.68,27.56 73.06,27.56 74.94,25.68 94.55,25.68 95.21,26.34 96.74,26.34 97.38,25.7 99.45,25.7 100.38,26.63 103.76,26.63 104.22,27.09 104.75,27.09 105.08,27.41 107.05,27.41 107.52,26.94 112.88,26.94 114.56,28.63 118.61,28.63 118.83,28.41 128.92,28.41 129.4,28.89 131.11,28.89 131.92,29.7 136.22,29.7 139.28,32.77 140.75,32.77 140.93,32.77 144.44,36.28 144.44,38.64 145.29,39.49 145.29,40.12 145.87,40.7 146.94,40.7 148.28,42.04 148.28,46.91 147.95,47.25 146.45,47.25 144.26,49.45 144.26,51.66 143.62,52.3 143.62,54.96 143.07,55.5 143.07,61.54 142.81,61.81 142.81,67.15 142.05,67.9 142.05,68.33 141.8,68.58 v1(140.33,68.58)
  BOTTOM w0.076: 139.18,68.03 139.1,67.95 139.09,67.95 136.65,65.51 136.65,65.26 136.39,64.99 136.39,64.99 136.37,64.98 136.25,64.98 136.05,64.78 136.05,64.63 135.97,64.55 UC1.B25
  BOTTOM w0.112: 139.18,68.03 v4(139.39,68.24) 139.72,68.56 140.32,68.56 v1(140.33,68.58) ; v1(28.96,37.95) 29.21,37.7 29.21,37.54 29.1,37.43 28.83,37.43 28.26,38 27.54,38 27.25,37.71 27.25,37.11 CS23.1
PCIE_CTX_WLANRX_N6: length 125.4
  IN1 w0.076: 134.33,74.68 132.76,74.68 132.44,75 132.44,78.04 132.64,78.24 133.69,78.24 133.71,78.22 133.87,78.22 133.9,78.25 133.93,78.25 133.94,78.26
  IN1 w0.119: 134.33,74.68 135.56,73.45 138.69,73.45 139.19,73.96 140.6,73.96 141.1,73.46 141.1,72.69 142.01,71.78 142.01,71.01 142.66,70.36 142.75,70.36 142.85,70.25 143.28,70.25 144.85,68.69 144.85,64.62 144.96,64.5 145.17,64.5 v1(145.32,64.65) ; 133.94,78.26 135.88,80.2 135.88,82.92 135.38,83.42 135.38,89.24 133.5,91.12 133.5,91.82 129.27,96.05 129.27,98.96 127.65,100.57 127.65,102.57 125.83,104.39 123.34,104.39 117.63,110.1 115.75,110.1 115.4,110.45 108.39,110.45 108.04,110.1 104.77,110.1 104.26,110.6 99.62,110.6 99.2,110.18 98.24,110.18 98.07,110.35 98.07,110.42 v1(98.22,110.57)
  BOTTOM w0.076: UC1.D20 135.17,61.51 135.48,61.82 135.99,61.82 136.17,61.64 137.49,61.64 138.53,62.68 138.75,62.68 138.78,62.71 138.8,62.71
  BOTTOM w0.112: CW1.1 76.84,115.34 77.06,115.12 82.69,115.12 83.42,114.38 88.46,114.38 93.4,109.45 97.97,109.45 98.22,109.71 v1(98.22,110.57) ; 138.8,62.71 141.87,62.71 141.88,62.72 142.44,62.72 144.37,64.65 v1(145.32,64.65)
PCIE_CTX_WLANRX_P6: length 125.4
  IN1 w0.076: 134.22,74.49 134.2,74.51 132.69,74.51 132.27,74.93 132.27,78.11 132.57,78.41 133.79,78.41
  IN1 w0.119: 133.79,78.41 135.67,80.28 135.67,82.83 135.17,83.34 135.17,89.15 133.29,91.03 133.29,91.73 132.93,92.09 132.92,92.09 132.77,92.24 129.05,95.96 129.05,98.87 127.44,100.48 127.44,102.48 125.74,104.17 123.25,104.17 117.54,109.88 115.66,109.88 115.31,110.23 108.48,110.23 108.13,109.88 104.67,109.88 104.17,110.38 99.71,110.38 99.29,109.96 98.15,109.96 97.85,110.26 97.85,110.39 97.67,110.57 v1(97.64,110.57) ; 134.22,74.49 135.47,73.24 138.16,73.24 138.17,73.23 138.78,73.23 139.28,73.74 140.51,73.74 140.88,73.37 140.88,72.59 141.79,71.69 141.79,70.92 142.57,70.14 142.66,70.14 142.76,70.04 143.19,70.04 144.63,68.59 144.63,64.53 144.87,64.28 145.14,64.28 145.32,64.1 v1(145.32,64.07)
  BOTTOM w0.076: 138.8,62.49 138.78,62.49 138.76,62.51 138.6,62.51 137.56,61.47 136.19,61.47 135.92,61.2 135.49,61.2 135.42,61.28 135.42,61.44 135.49,61.51 UC1.C20
  BOTTOM w0.112: v1(97.64,110.57) 98,110.21 98,109.8 97.88,109.67 93.49,109.67 88.56,114.61 83.51,114.61 82.78,115.34 77.15,115.34 77.06,115.43 77.06,115.55 CW2.1 ; 138.8,62.49 v4(142.25,62.49) 142.52,62.49 144.46,64.43 144.96,64.43 v1(145.32,64.07)
PCIE_RCOMPN: length 2.5
  TOP w0.089: v2(132.72,51.38) 133.08,51.74 RC65.1
  TOP w0.254: v1(133.37,53.09) 133.37,52.7 RC65.1
  BOTTOM w0.254: UC1.F5 133.37,52.85 v1(133.37,53.09)
PCIE_RCOMPP: length 1.8
  TOP w0.089: v1(134.05,53.09) 134.05,53.18 v2(133.73,53.5)
  TOP w0.254: RC65.2 133.99,53.03 v1(134.05,53.09)
  BOTTOM w0.254: UC1.E5 133.82,52.86 v1(134.05,53.09)
PCIE_WAKE#: length 306.7
  TOP w0.089: v1(104.64,55.54) 105.08,55.54 RC99.1
  TOP w0.112: UE1.4 38.55,68.91 v1(38.83,69.18) ; v1(24.21,85.4) 24,85.19 UL1.21 ; RW15.2 76.08,134.65 v1(76.18,134.76) ; RE12.1 73.24,38.29 72.94,38.58 v1(72.63,38.58) ; v1(100.7,40.85) 100.86,40.7 v2(100.86,39.58)
  IN1 w0.119: v1(26.13,27.62) 26.13,26.91 24.7,25.49 23.49,25.49 23.19,25.79 21.25,25.79 18.76,28.29 18.76,30.97 19.91,32.13 19.91,41.1 21.05,42.24 21.05,43.51 22.59,45.05 22.59,52.74 25.15,55.3 25.15,75.53 24.49,76.2 24.49,78.42 26.04,79.98 26.04,84.12 v1(26.28,84.36) 26.28,84.53 25.13,85.68 24.49,85.68 v1(24.21,85.4) ; v1(38.83,69.18) 41.42,66.6 47.41,66.6 48.34,65.67 52.46,65.67 v1(53.03,66.24)
  IN3 w0.135: v1(76.18,134.76) 74.35,132.92 71.95,132.92 70.89,131.86 70.89,128.38 69.31,126.8 65.77,126.8 64.98,126.02 64.27,126.02 63.03,124.78 63.03,123.66 62.36,122.99 62.36,121.1 61.92,120.66 61.11,120.66 60.46,120.01 54.25,120.01 52.97,118.73 49.08,118.73 43.09,112.73 42.46,112.73 41.41,111.68 41.41,111.48 40.12,110.19 35.24,110.19 34.47,109.41 32.62,109.41 31.73,109.41 30.85,109.41 24.82,103.39 24.82,98.29 22,95.46 21.09,95.46 19.95,94.32 19.95,89.43 20.35,89.02 22.37,89.02 25.82,85.58 25.82,84.83 v1(26.28,84.36) 28.06,82.58 29.57,82.58 29.89,82.9 30.6,82.9 31.15,82.35 31.15,79.14 31.77,78.52 32.69,78.52 34.34,76.87 36.56,76.87 39.16,74.26 39.16,69.52 v1(38.83,69.18) ; v1(100.7,40.85) 100.49,41.07 97.94,41.07 97.63,41.37 96.67,41.37 95.69,42.35 88.73,42.35 88.4,42.02 88.4,41.28 87.15,40.03 82.92,40.03 81.32,38.44 75.68,38.44 75.53,38.58 v1(72.63,38.58) 71.75,38.58 70.92,39.41 68.95,39.41 68.24,40.12 61.49,40.12 60.47,41.13 60.05,41.13 57.37,43.81 57.37,43.97 57.14,44.2 56.7,44.2 56.56,44.35 56.56,46.99 55.13,48.42 55.13,49.07 55.38,49.32 55.38,50.31 54.45,51.24 54.45,51.57 53.26,52.75 53.26,56.6 52.4,57.46 52.4,58.29 51.59,59.1 51.59,60.91 52.37,61.69 52.37,63.41 52.33,63.45 52.33,65.54 v1(53.03,66.24)
  BOTTOM w0.112: v1(104.64,55.54) 103.66,54.56 102.39,54.56 100.93,53.1 100.93,47 99.08,45.15 99.08,43.42 100.55,41.94 100.55,41.02 100.7,40.88 v1(100.7,40.85) ; JSSD1.54 v1(26.13,27.62)
PECI_EC: length 179.7
  TOP w0.112: v1(34.65,88.69) 34.92,88.42 RE23.2 34.2,88 DE1.1 ; v1(145.42,85.34) v2(145.42,84.56)
  IN1 w0.119: v1(145.42,85.34) 145.42,85.4 143.9,86.92 143.9,91 143.14,91.77 140.68,91.77 137.78,94.67 136.1,94.67 132.21,98.57 132.21,101.77 123.3,110.68 121.32,110.68 118.91,113.09 85.62,113.09 84.77,113.94 83.46,113.94 82.59,114.8 79.7,114.8 77.51,116.99 67.04,116.99 66.06,116.01 65.31,116.01 63.84,117.48 60.92,117.48 60.81,117.37 58.81,117.37 58.21,117.98 55.48,117.98 54.85,118.6 49.53,118.6 49.31,118.38 37.28,118.38 35.62,116.72 33.8,116.72 v1(33.19,116.11)
  BOTTOM w0.076: UC1.A54 136.7,80.93 137.49,80.93 138.08,80.34
  BOTTOM w0.112: v1(34.65,88.69) 34.04,89.29 34.04,91.71 35.69,93.36 35.69,99.05 36.49,99.85 36.49,100.96 38.72,103.18 38.72,109.33 36.69,111.36 34.06,111.36 33.82,111.61 33.82,115.49 v1(33.19,116.11) ; v1(145.42,85.34) 144.03,83.94 144.03,83.92 143.58,83.47 143.34,83.47 140.42,80.56 138.94,80.56 138.72,80.34 138.08,80.34
PEG_CLKREQ#: length 7.7
  BOTTOM w0.102: UV1.N7 126.91,125.63 126.91,122.51 126.81,122.41 126.81,122.19
  BOTTOM w0.112: 126.81,122.19 v2(126.81,120.61) 126.52,120.32 RV368.2 124.91,119.38 RV153.2
PEG_GTX_C_HRX_N0: length 130.7
  IN3 w0.076: v1(132.78,57.68) 132.62,57.68 132.55,57.76 132.55,57.97 132.64,58.06 133.77,58.06 133.81,58.02 134.4,58.02 134.87,58.48 135.17,58.48 135.35,58.65 135.39,58.65 135.41,58.67
  IN3 w0.135: v1(111.9,148.94) 111.72,148.75 111.72,148.57 110.77,147.62 107.43,147.62 105.15,145.33 105.15,144.48 104.1,143.43 104.1,143.03 104.1,143.03 104.1,142.4 102.92,141.22 102.92,135.62 106.18,132.36 106.18,128.36 103.24,125.42 103.24,119.34 107.13,115.45 119.01,115.45 119.92,114.54 122.97,114.54 125.28,112.23 126.16,112.23 127.06,111.32 127.06,109.8 133.16,103.71 133.16,98.99 133.53,98.62 133.53,98.49 137.82,94.2 137.82,89.96 139.16,88.61 139.16,88.57 139.65,88.09 139.65,85.97 140.09,85.52 140.09,80.44 141.1,79.43 141.1,76.62 140.84,76.37 140.84,74.53 139.35,73.04 139.35,70.72 138.39,69.76 138.39,67.93 138.27,67.81
  IN3 w0.145: 135.41,58.67 135.72,58.98 135.72,59.11 137.16,60.54 137.16,61.41 137.78,62.02 137.78,66.77 138.27,67.27 138.27,67.81
  BOTTOM w0.076: UC1.G13 132.52,57.43 v1(132.78,57.68)
  BOTTOM w0.112: v1(111.9,148.94) 111.9,148.91 111.86,148.87 111.86,148.53 CV2.1
PEG_GTX_C_HRX_N1: length 134.6
  IN3 w0.076: 134.45,57.25 134.45,57.25 134.43,57.25 134.4,57.28 134.04,57.28 133.89,57.13 133.35,57.13 133.26,57.05 133.26,56.9 133.46,56.7 v1(133.53,56.7)
  IN3 w0.135: v1(113.68,149.65) 113.52,149.49 113.52,149.47 113.43,149.38 113.43,149.19 110.01,145.78 110.01,142.63 109.21,141.83 104.59,141.83 103.68,140.91 103.68,135.94 106.95,132.66 106.95,128.05 103.99,125.09 103.99,119.65 107.36,116.29 119.28,116.29 120.26,115.31 123.29,115.31 124.38,114.22 125.34,114.22 127.92,111.64 127.92,110.33 133.96,104.3 133.96,99.27 138.58,94.65 138.58,90.83 139.92,89.48 140.13,89.48 140.84,88.76 140.84,80.76 141.86,79.74 141.86,76.31 141.6,76.06 141.6,74.21 141,73.61 141,71.12 139.12,69.25 139.12,67.15 138.43,66.46 138.43,62.78
  IN3 w0.145: 134.45,57.25 134.65,57.25 137.1,59.7 138.15,59.7 138.43,59.98 138.43,62.78
  BOTTOM w0.076: v1(133.53,56.7) UC1.F11
  BOTTOM w0.112: v1(113.68,149.65) 113.6,149.57 113.6,148.59 CV4.1
PEG_GTX_C_HRX_N2: length 140
  TOP w0.102: CV6.1 116.67,142.73 116.78,142.63 117.32,142.63 117.43,142.73 117.43,143.19 116.85,143.77 116.85,144.68 116.75,144.78
  TOP w0.112: 116.75,144.78 116.51,145.02 116.5,145.02 116,145.52 116,145.53 114.56,146.97 111.07,146.97 109.41,148.63 109.41,149.1 v1(109.03,149.49)
  IN3 w0.076: 135.04,60.42 135.03,60.41 134.98,60.41 134.96,60.38 134.91,60.38 134.42,59.88 132.71,59.88 132.57,59.74 132.57,59.59 132.64,59.51 v1(132.78,59.51)
  IN3 w0.135: 138.17,74.16 139.19,75.19 139.19,77.38 138.56,78.02 138.56,80.52 138.83,80.79 138.83,84.67 136.48,87.01 136.48,90.16 135.94,90.71 135.94,91.78 135.42,92.3 135.42,94.46 132.01,97.86 132.01,97.99 131.64,98.36 131.64,102.87 121.49,113.02 119.3,113.02 118.38,113.94 106.5,113.94 101.72,118.71 101.72,126.04 104.67,128.99 104.67,131.73 101.38,135.02 101.38,141.83 102.58,143.03 102.58,144.91 107.75,150.08 109.09,150.08 109.25,149.91 109.25,149.71 v1(109.03,149.49)
  IN3 w0.145: 135.04,60.42 135.75,61.12 135.75,63.05 136.32,63.62 136.32,70.37 137.74,71.79 137.74,73.73 138.17,74.16
  BOTTOM w0.076: v1(132.78,59.51) 132.94,59.35 132.94,59.2 132.71,58.98 132.6,58.98 UC1.G16
PEG_GTX_C_HRX_N3: length 140.2
  TOP w0.102: CV8.1 118.45,144.07 118.27,144.25 118.27,144.5 118.46,144.69 118.46,144.76 118.46,144.76 118.46,144.78
  TOP w0.112: v1(110.7,149.82) 110.52,149.64 110.52,148.92 111.54,147.9 115.36,147.9 116.31,146.95 117.19,146.95 118.46,145.67 118.46,144.78
  IN3 w0.076: 135.11,59.45 135.05,59.38 135.05,59.36 134.94,59.25 134.84,59.14 134.67,58.97 134.53,58.97 133.25,58.97 133.18,58.9 133.18,58.76 133.35,58.6 v1(133.47,58.6)
  IN3 w0.135: 138.54,71.04 138.54,73.35 139.96,74.77 139.96,76.75 140.34,77.13 140.34,78.92 140.34,79.12 139.31,80.15 139.31,85.02 137.83,86.51 137.83,89.05 137.24,89.63 137.24,91.84 137.06,92.02 137.06,93.88 132.77,98.18 132.77,98.3 132.4,98.68 132.4,103.39 125.46,110.33 125.46,110.86 122.54,113.78 119.61,113.78 118.69,114.69 106.81,114.69 102.48,119.03 102.48,125.73 105.43,128.68 105.43,132.04 102.16,135.31 102.16,141.54 103.34,142.72 103.34,143.74 104.39,144.79 104.39,145.65 107.12,148.38 109.88,148.38 110.57,149.07 110.57,149.69 v1(110.7,149.82)
  IN3 w0.145: 135.11,59.45 136.52,60.86 136.52,62.93 137.11,63.51 137.11,67.1 137.49,67.48 137.49,69.99 138.54,71.04
  BOTTOM w0.076: v1(133.47,58.6) 133.17,58.29 UC1.F15
PEG_GTX_C_HRX_P0: length 130.8
  IN3 w0.076: 135.24,58.83 135.24,58.83 135.24,58.78 135.11,58.65 134.8,58.65 134.33,58.18 133.88,58.18 133.84,58.22 132.57,58.22 132.37,58.02 132.37,57.76 132.29,57.68 132.19,57.68 v1(132.15,57.71)
  IN3 w0.135: 138.05,67.97 138.16,68.08 138.16,69.88 139.11,70.82 139.11,73.14 140.6,74.63 140.6,76.47 140.86,76.72 140.86,79.33 139.85,80.34 139.85,85.42 139.4,85.87 139.4,87.99 138.94,88.46 138.94,88.52 137.6,89.86 137.6,92.08 137.58,92.09 137.58,94.1 133.29,98.39 133.29,98.52 132.91,98.89 132.91,103.61 126.82,109.7 126.82,111.22 126.06,111.98 125.18,111.98 122.87,114.29 119.82,114.29 118.91,115.21 107.02,115.21 103,119.24 103,125.52 105.94,128.46 105.94,132.26 102.68,135.52 102.68,141.32 103.86,142.5 103.86,142.93 103.86,142.93 103.86,143.53 104.91,144.58 104.91,145.43 107.33,147.86 110.67,147.86 111.48,148.67 111.48,148.78 v1(111.32,148.94)
  IN3 w0.145: 138.05,67.97 138.04,67.96 138.04,67.36 137.54,66.87 137.54,62.12 136.93,61.5 136.93,60.64 135.49,59.2 135.49,59.08 135.24,58.83
  BOTTOM w0.076: UC1.H13 131.87,57.41 132.15,57.69 v1(132.15,57.71)
  BOTTOM w0.112: v1(111.32,148.94) 111.32,148.91 111.41,148.82 111.41,148.57 CV1.1
PEG_GTX_C_HRX_P1: length 134.5
  IN3 w0.076: v1(132.81,56.7) 133.03,56.78 133.09,56.87 133.09,57.11 133.28,57.3 133.82,57.3 133.97,57.45 134.36,57.45 134.37,57.45 134.4,57.45 134.44,57.49 134.45,57.49
  IN3 w0.135: 138.2,62.78 138.2,62.81 138.2,62.81 138.2,62.87 138.21,62.88 138.21,66.55 138.9,67.25 138.9,69.34 139.02,69.46 139.02,69.49 140.76,71.22 140.76,73.71 141.36,74.31 141.36,76.16 141.61,76.41 141.61,79.64 140.6,80.66 140.6,88.66 140.03,89.24 139.82,89.24 139.01,90.05 139.01,90.08 138.35,90.73 138.35,91.32 138.34,91.34 138.34,94.55 133.71,99.17 133.71,104.2 127.68,110.23 127.68,111.54 125.24,113.98 124.28,113.98 123.19,115.07 120.16,115.07 119.18,116.05 107.26,116.05 103.75,119.55 103.75,125.19 106.71,128.15 106.71,132.56 103.43,135.84 103.43,141.01 104.49,142.07 109.11,142.07 109.77,142.73 109.77,145.88 113.19,149.29 113.19,149.56 v1(113.1,149.65)
  IN3 w0.145: 134.45,57.49 134.56,57.49 137,59.93 138.05,59.93 138.2,60.08 138.2,62.78
  BOTTOM w0.076: v1(132.81,56.7) UC1.G11
  BOTTOM w0.112: CV3.1 113.38,148.71 113.38,149.37 v1(113.1,149.65)
PEG_GTX_C_HRX_P2: length 140
  TOP w0.102: CV5.1 117.64,142.63 117.64,143.28 117.06,143.85 117.06,144.78
  TOP w0.112: 117.06,144.78 v4(116.39,145.45) 114.66,147.19 111.17,147.19 109.64,148.72 109.64,149.46 v1(109.61,149.49)
  IN3 w0.076: 134.87,60.58 134.87,60.57 134.35,60.05 132.64,60.05 132.17,59.57 v1(132.17,59.51)
  IN3 w0.135: 137.5,73.83 137.5,73.84 138.95,75.29 138.95,77.28 138.32,77.92 138.32,78.37 138.34,78.39 138.34,80.64 138.6,80.91 138.6,84.58 136.26,86.92 136.26,90.07 135.71,90.62 135.71,91.69 135.32,92.08 135.29,92.08 135.17,92.2 135.17,94.36 131.77,97.76 131.77,97.89 131.4,98.26 131.4,102.77 121.39,112.78 119.2,112.78 118.28,113.7 106.4,113.7 101.48,118.61 101.48,126.14 104.43,129.09 104.43,131.63 101.14,134.92 101.14,141.93 102.34,143.13 102.34,145.01 107.65,150.32 109.19,150.32 109.61,149.9 109.61,149.49 v1(109.61,149.49)
  IN3 w0.145: 137.5,73.83 137.5,71.88 136.08,70.46 136.08,63.72 135.51,63.15 135.51,61.22 134.87,60.58
  BOTTOM w0.076: UC1.H16 131.87,59.22 v1(132.17,59.51)
PEG_GTX_C_HRX_P3: length 140.3
  TOP w0.102: CV7.1 118.14,143.77 118.14,144.08 118.06,144.17 118.06,144.59 118.24,144.78 118.24,144.78
  TOP w0.112: 118.24,144.78 118.24,145.58 117.1,146.73 116.22,146.73 115.27,147.68 111.45,147.68 110.3,148.83 110.3,149.63 v1(110.12,149.82)
  IN3 w0.076: v1(132.78,58.6) 132.94,58.6 133.01,58.67 133.01,58.96 133.18,59.14 134.6,59.14 134.72,59.26 134.82,59.37 134.89,59.43 134.89,59.45 134.91,59.48 134.91,59.53 134.94,59.56 134.94,59.6 134.95,59.61
  IN3 w0.135: v1(110.12,149.82) 110.33,149.6 110.33,149.17 109.78,148.62 107.02,148.62 104.15,145.75 104.15,144.89 103.1,143.84 103.1,142.82 101.92,141.64 101.92,135.21 105.18,131.94 105.18,128.78 102.24,125.83 102.24,118.93 106.71,114.45 118.59,114.45 119.51,113.54 122.44,113.54 125.22,110.76 125.22,110.23 132.16,103.29 132.16,98.58 132.53,98.2 132.53,98.08 136.82,93.78 136.82,92.24 136.84,92.22 136.84,91.93 137.02,91.75 137.02,89.54 137.61,88.95 137.61,86.41 139.09,84.93 139.09,80.03 140.1,79.02 140.1,77.23 139.71,76.85 139.71,74.87 138.3,73.45 138.3,71.14 137.25,70.1 137.25,70.09
  IN3 w0.145: 137.25,70.09 137.25,67.58 136.87,67.2 136.87,63.61 136.29,63.02 136.29,60.95 134.95,59.61
  BOTTOM w0.076: v1(132.78,58.6) 132.52,58.34 UC1.G15
PEG_GTX_HRX_N0: length 6.7
  BOTTOM w0.076: 114.8,144.78 114.8,144.77 114.78,144.76 114.78,144.69 115.06,144.41 115.06,143.83 115.14,143.75 115.29,143.75 UV1.AG31
  BOTTOM w0.112: 114.8,144.78 114.8,144.98 113.86,145.92 112.96,145.92 112.19,145.92 111.46,146.65 111.46,146.9 111.97,147.42 CV2.2
PEG_GTX_HRX_N1: length 6.3
  BOTTOM w0.076: UV1.AF28 115.85,142.89 115.85,143.67 115.88,143.71 115.88,143.97 115.5,144.35 115.5,144.69 115.52,144.71 115.52,144.76 115.54,144.78 115.54,144.78
  BOTTOM w0.112: CV4.2 113.58,147.1 113.58,146.8 113.75,146.63 114.16,146.63 115.54,145.25 115.54,144.78
PEG_GTX_HRX_N2: length 2.3
  TOP w0.102: v1(115.75,140.68) 115.75,140.68 115.75,140.68 115.78,140.72 115.78,142.35 CV6.2
  BOTTOM w0.102: UV1.AF26 116.06,141 115.75,140.69 v1(115.75,140.68)
PEG_GTX_HRX_N3: length 3.8
  TOP w0.102: v1(118.11,140.62) 118.11,140.67 118.26,140.82 118.47,140.82 119.11,141.46 119.11,142.24 119.11,142.25 119.11,143.14 CV8.2
  BOTTOM w0.102: UV1.AD26 118.11,140.63 v1(118.11,140.62)
PEG_GTX_HRX_P0: length 6.7
  BOTTOM w0.076: UV1.AH30 114.54,143.5 114.88,143.84 114.88,144.33 114.58,144.64 114.58,144.78
  BOTTOM w0.112: CV1.2 111.21,147.37 111.21,146.58 112.1,145.7 112.91,145.7 113.77,145.7 114.58,144.89 114.58,144.78
PEG_GTX_HRX_P1: length 6.3
  BOTTOM w0.076: UV1.AG29 115.34,142.94 115.46,142.82 115.57,142.82 115.67,142.91 115.67,143.74 115.7,143.78 115.7,143.89 115.32,144.27 115.32,144.78
  BOTTOM w0.112: 115.32,144.78 115.32,145.16 114.07,146.41 113.65,146.41 113.36,146.7 113.36,147.01 CV3.2
PEG_GTX_HRX_P2: length 2.4
  TOP w0.102: v1(116.51,140.68) 116.5,140.68 116.18,141.26 CV5.2
  BOTTOM w0.102: UV1.AF27 116.51,141.43 v1(116.51,140.68)
PEG_GTX_HRX_P3: length 3.8
  TOP w0.102: v1(118.09,141.42) 118.02,141.35 118.02,141.14 118.13,141.03 118.38,141.03 118.89,141.53 v4(118.89,141.94) 118.89,142.73 118.78,142.84 CV7.2
  BOTTOM w0.102: v1(118.09,141.42) 117.84,141.42 117.74,141.52 UV1.AD27
PEG_HTX_C_GRX_N0: length 9.8
  BOTTOM w0.076: 138.8,59.84 138.68,59.84 138.64,59.8 138.62,59.8 138.6,59.78 137.88,59.78 137.74,59.64 136.58,59.64 UC1.A17
  BOTTOM w0.112: CV306.2 142.77,54.84 142.37,54.84 v4(142,55.21) 140.32,56.89 140.32,57.48 140.31,57.49 140.31,58.55 139.02,59.84 138.8,59.84
PEG_HTX_C_GRX_N1: length 12
  BOTTOM w0.076: UC1.C16 135.57,59.27 135.65,59.34 135.79,59.34 135.95,59.18 136.86,59.18 136.98,59.31 138.1,59.31 138.22,59.19 138.27,59.19
  BOTTOM w0.112: 138.27,59.19 138.42,59.04 138.65,59.04 138.83,58.87 138.84,58.87 139.26,58.45 139.26,58.43 139.59,58.1 139.59,56.56 140.91,55.25 140.91,54.46 v4(141.85,53.51) 142.42,52.95 142.66,52.95 CV305.2
PEG_HTX_C_GRX_N2: length 11.1
  BOTTOM w0.076: UC1.C17 135.12,59.47 135.12,59.37 135.18,59.31 135.37,59.31 135.57,59.5 135.57,59.71 135.66,59.81 135.86,59.87 135.98,59.87 136.08,59.83 136.38,59.83 136.44,59.87 137.17,59.87 137.17,59.86 137.73,59.86 138.23,60.36 138.75,60.36 138.78,60.33 138.8,60.33
  BOTTOM w0.112: CV309.2 142.62,56.46 142.28,56.46 141.81,56.93 141.8,56.93 141.37,57.35 141.37,57.37 140.8,57.94 140.8,58.91 v4(140.21,59.5) 139.38,60.33 138.8,60.33
PEG_HTX_C_GRX_N3: length 8.7
  BOTTOM w0.076: UC1.A19 136.58,61.05 136.62,61.08 137.76,61.08 138.51,61.83 138.71,61.83 138.73,61.81 138.75,61.81 138.79,61.77 138.8,61.77
  BOTTOM w0.112: 138.8,61.77 140.33,61.77 140.82,61.27 140.84,61.27 v4(141.88,60.23) 142.23,59.89 142.23,59.08 142.47,58.84 142.65,58.84 CV304.2
PEG_HTX_C_GRX_P0: length 10.6
  BOTTOM w0.076: 138.69,59.62 137.95,59.62 137.81,59.47 136.83,59.47 136.7,59.34 136.1,59.34 136.01,59.47 UC1.B17
  BOTTOM w0.112: 138.69,59.62 138.93,59.62 140.09,58.46 v4(140.09,57.21) 140.09,56.81 141.65,55.25 141.65,55.23 142.02,54.86 142.04,54.86 142.28,54.62 142.68,54.62 CV312.2
PEG_HTX_C_GRX_P1: length 12.5
  BOTTOM w0.076: 138.11,59.04 138,59.14 137.05,59.14 136.92,59.02 135.97,59.02 135.97,59.01 135.89,58.85 135.55,58.73 UC1.D16
  BOTTOM w0.112: CV308.2 142.71,52.68 142.71,52.68 142.67,52.73 142.33,52.73 141.92,53.13 141.91,53.13 141.47,53.57 141.47,53.59 140.69,54.37 140.69,55.16 139.37,56.47 139.37,58.01 v4(138.88,58.5) 138.56,58.82 138.33,58.82 138.2,58.95 138.11,59.04
PEG_HTX_C_GRX_P2: length 11
  BOTTOM w0.076: UC1.D17 135.16,59.94 135.53,59.94 135.83,60.04 136.01,60.04 136.11,60 136.34,60 136.4,60.03 137.23,60.03 137.24,60.02 137.66,60.02 138.16,60.52 138.75,60.52 138.78,60.55 138.8,60.55
  BOTTOM w0.112: CV307.2 142.71,56.68 142.37,56.68 v4(141.77,57.28) 141.02,58.03 141.02,59 140.63,59.39 140.63,59.41 140.19,59.85 140.17,59.85 139.47,60.55 138.8,60.55
PEG_HTX_C_GRX_P3: length 9.4
  BOTTOM w0.076: 138.8,61.99 138.44,61.99 137.69,61.24 136.38,61.24 136.14,61.01 136.03,61.01 UC1.B19
  BOTTOM w0.112: 138.8,61.99 140.44,61.99 v4(140.8,61.63) 141.84,60.59 141.86,60.59 142.26,60.19 142.26,60.17 142.45,59.98 142.45,59.18 142.56,59.06 142.68,59.06 CV313.2
PEG_HTX_GRX_N0: length 139.7
  IN3 w0.135: v1(146.35,55.16) 146.2,55.01 146.2,55.01 145.06,55.01 142.21,57.86 142.21,62.81 142.67,63.27 142.67,66.57 142.1,67.13 142.1,68.39 144.87,71.16 146.56,71.16 147.63,72.23 147.63,77.54 146.65,78.52 146.07,78.52 145.82,78.77 145.82,79.99 143.72,82.09 143.72,89.44 142.87,90.29 142.87,91.88 142.36,92.39 142.36,93.21 141.56,94.01 141.56,97.58 142.33,98.35 142.33,102.86 133.62,111.58 133.62,115.53 130.41,118.74 126.35,118.74 126.06,119.03 124.01,119.03 123.65,119.39 120.58,119.39 119.79,118.6 115.72,118.6 115.02,119.29 110.79,119.29 109.94,120.15 109.94,133.17 109.38,133.73 109.38,137.97 111.53,140.12 111.53,145.15 113.02,146.64 113.65,146.64 v1(115.32,148.31)
  BOTTOM w0.102: UV1.AE31 116.77,143.63 116.67,143.63 116.57,143.72 116.57,143.88 116.67,143.98 116.67,144.61 116.59,144.69 116.59,144.78
  BOTTOM w0.112: v1(115.32,148.31) 115.06,148.05 115.06,147.24 115.88,146.42 116.3,146 116.3,145.24 116.59,144.95 116.59,144.78 ; CV306.1 144.56,54.55 144.71,54.55 145.14,54.98 146.17,54.98 v1(146.35,55.16)
PEG_HTX_GRX_N1: length 143.5
  IN3 w0.135: v1(115.52,149.64) 115.37,149.49 115.37,149.16 115.09,148.89 114.19,148.89 110.77,145.46 110.77,141.05 108.16,138.44 108.16,136.31 108.01,136.16 108.01,133.11 107.71,132.81 107.71,128.69 108.21,128.19 108.21,119.67 109.34,118.54 114.71,118.54 115.45,117.8 120.07,117.8 120.49,118.23 125.45,118.23 127.13,116.55 129.33,116.55 129.87,116.01 130.72,116.01 132.86,113.87 132.86,111.26 141.57,102.55 141.57,98.81 140.1,97.34 140.1,93.36 141.07,92.4 141.28,92.4 142.11,91.57 142.11,89.93 142.97,89.08 142.97,81.17 144.3,79.83 144.3,77.96 143.89,77.55 143.89,74.34 142.55,73 142.55,70.51 141.34,69.31 141.34,66.29 141.91,65.71 141.91,63.87 140.03,61.99 140.03,58.98 144.93,54.07 145.42,54.07 v1(145.7,54.35)
  BOTTOM w0.102: 117.3,144.78 117.37,144.72 117.37,144.1 117.46,144.02 117.46,143.58 117.43,143.56 117.43,142.99 117.42,142.99 117.42,142.91 UV1.AD28
  BOTTOM w0.112: 117.3,144.78 117.3,145.57 117.21,145.66 117.21,146.16 116.08,147.29 116.08,148.63 115.37,149.34 115.37,149.5 v1(115.52,149.64) ; CV305.1 144.37,52.83 144.65,52.83 144.76,52.94 144.76,53.59 145.3,54.12 145.47,54.12 v1(145.7,54.35)
PEG_HTX_GRX_N2: length 135.1
  IN3 w0.135: v1(116.88,147.97) 115.71,147.97 113.87,146.13 113.23,146.13 112.42,145.31 112.42,142.38 112.08,142.04 112.08,139.86 111.6,139.39 111.6,138.61 110.08,137.09 110.08,133.92 110.6,133.4 110.6,132.13 111.26,131.47 111.26,130.17 110.49,129.39 110.49,120.37 111.04,119.82 115.23,119.82 115.42,119.63 120.06,119.63 120.38,119.95 122.46,119.95 122.75,120.24 125.64,120.24 126.62,119.25 130.62,119.25 134.81,115.07 134.81,113.82 135.63,112.99 135.63,110.29 142.88,103.04 142.88,92.6 144.24,91.24 144.24,82.37 146.38,80.24 146.38,79.55 148.15,77.78 148.15,71.88 146.9,70.64 145.85,70.64 143.19,67.98 143.19,62.9 142.74,62.45 142.74,58.06 144.63,56.17 145.11,56.17 v1(145.16,56.11)
  BOTTOM w0.102: UV1.AC31 118.43,143.69 118.31,143.69 118.24,143.76 118.24,143.96 118.49,144.21 118.49,144.78
  BOTTOM w0.112: 118.49,144.78 118.49,145.33 118.11,145.71 118.11,147.57 117.71,147.97 v1(116.88,147.97) ; v1(145.16,56.11) 145.06,56.22 144.05,56.22 CV309.1
PEG_HTX_GRX_N3: length 131.4
  IN3 w0.135: v1(145.98,58.84) 145.86,58.96 145.85,58.96 145.44,58.96 145.14,59.26 145.14,59.75 145.75,60.36 145.75,65.93 145.75,65.93 145.75,65.96 150.55,70.76 150.55,87.14 150.87,87.46 150.87,90.55 149.89,91.53 149.89,94.51 148.45,95.95 148.45,97.82 147.52,98.76 147.52,101.05 148.59,102.13 148.59,105.6 146.19,108 146.19,109.23 139.65,115.77 139.65,116.67 137.66,118.66 136.78,118.66 136.17,119.27 133.81,119.27 129.44,123.65 129.16,123.65 127.91,124.9 125.5,124.9 123.4,122.8 122.89,122.8 122.38,122.3 120.43,122.3 118.92,123.8 117.2,123.8 116.53,123.13 115.05,123.13 114.4,123.78 114.4,126.87 113.6,127.67 113.6,133.56 114.25,134.21 114.25,138.93 115.08,139.77 115.08,141 117.1,143.02 117.1,145.34 117.67,145.92 117.67,146.67 118.01,147.01 118.62,147.01 118.63,147 v1(118.75,147.12)
  BOTTOM w0.102: 119.26,144.78 119.26,144.76 119.26,144.76 119.26,144.69 119.25,144.69 119.25,144.55 119,144.3 119,144.07 119.06,144.01 119.06,143.54 119.04,143.52 119.04,143.27 119.06,143.25 119.06,143.24 119.19,143.11 119.19,142.74 UV1.AB28
  BOTTOM w0.112: CV304.1 144.89,58.5 145.24,58.84 v1(145.98,58.84) ; v1(118.75,147.12) 118.83,147.04 119.51,147.04 119.75,146.8 119.75,146.33 119.26,145.85 119.26,144.78
PEG_HTX_GRX_P0: length 139.8
  IN3 w0.135: v1(114.56,148.31) 114.56,147.89 113.55,146.88 112.92,146.88 111.29,145.25 111.29,140.22 109.14,138.07 109.14,133.63 109.7,133.07 109.7,120.05 110.69,119.05 114.92,119.05 115.62,118.36 119.89,118.36 120.68,119.15 123.55,119.15 123.91,118.79 125.96,118.79 126.25,118.5 130.31,118.5 133.37,115.43 133.37,111.48 142.09,102.76 142.09,98.45 141.32,97.68 141.32,93.91 142.12,93.11 142.12,92.29 142.63,91.78 142.63,90.19 143.48,89.34 143.48,81.99 145.58,79.89 145.58,78.67 145.97,78.28 146.55,78.28 147.39,77.44 147.39,72.33 146.46,71.4 144.77,71.4 141.86,68.49 141.86,67.03 142.43,66.47 142.43,63.37 141.97,62.91 141.97,57.76 144.96,54.77 146.1,54.77 v1(146.35,54.52)
  BOTTOM w0.102: UV1.AF30 116.24,143.4 116.36,143.52 116.36,143.97 116.46,144.07 116.46,144.52 116.38,144.61 116.38,144.69 116.37,144.69 116.37,144.76 116.37,144.76 116.37,144.78
  BOTTOM w0.112: CV312.1 144.07,54.33 144.81,54.33 145.23,54.76 146.11,54.76 v1(146.35,54.52) ; v1(114.56,148.31) 114.82,148.05 114.82,147.16 115.66,146.33 115.66,146.33 116.08,145.91 116.08,145.14 116.37,144.86 116.37,144.78
PEG_HTX_GRX_P1: length 143.4
  IN3 w0.135: v1(145.7,53.71) 145.58,53.83 144.83,53.83 139.78,58.88 139.78,62.09 141.67,63.97 141.67,65.61 141.1,66.19 141.1,69.41 142.31,70.61 142.31,73.1 143.65,74.44 143.65,77.65 144.06,78.06 144.06,79.73 142.73,81.07 142.73,88.98 141.87,89.83 141.87,91.47 141.18,92.16 140.97,92.16 139.86,93.26 139.86,97.44 141.33,98.91 141.33,102.45 132.62,111.16 132.62,113.77 130.62,115.77 129.77,115.77 129.23,116.31 127.03,116.31 125.35,117.99 120.59,117.99 120.17,117.56 115.35,117.56 114.61,118.3 109.24,118.3 107.97,119.57 107.97,128.09 107.47,128.59 107.47,132.91 107.77,133.21 107.77,136.26 107.92,136.41 107.92,138.54 110.53,141.15 110.53,145.56 114.09,149.13 114.99,149.13 115.13,149.26 115.13,149.45 v1(114.94,149.64)
  BOTTOM w0.102: 117.08,144.78 117.08,144.69 117.16,144.61 117.16,144.02 117.24,143.93 117.24,143.67 117.22,143.64 117.22,143.08 117.13,143 UV1.AE29
  BOTTOM w0.112: 117.08,144.78 117.08,145.48 116.99,145.57 116.99,146.07 115.86,147.2 115.86,148.54 115.1,149.3 115.1,149.48 v1(114.94,149.64) ; CV308.1 144.12,52.61 144.74,52.61 144.98,52.85 144.98,53.5 145.39,53.9 145.51,53.9 v1(145.7,53.71)
PEG_HTX_GRX_P2: length 135.2
  IN3 w0.135: v1(145.16,56.75) 145.16,56.71 144.86,56.41 144.73,56.41 142.99,58.16 142.99,62.35 143.43,62.8 143.43,67.88 145.95,70.4 147,70.4 148.39,71.78 148.39,77.88 146.62,79.65 146.62,80.34 144.48,82.47 144.48,91.34 143.12,92.7 143.12,103.14 135.87,110.39 135.87,113.09 135.05,113.92 135.05,115.17 130.72,119.5 126.72,119.5 125.74,120.48 122.65,120.48 122.36,120.19 120.28,120.19 119.96,119.87 115.52,119.87 115.33,120.06 111.14,120.06 110.73,120.47 110.73,129.29 111.5,130.07 111.5,131.57 110.84,132.23 110.84,133.5 110.32,134.02 110.32,136.99 111.84,138.51 111.84,139.29 112.32,139.76 112.32,141.94 112.66,142.28 112.66,145.21 113.33,145.89 113.97,145.89 115.81,147.73 116.52,147.73 116.87,147.39 v1(116.88,147.39)
  BOTTOM w0.102: 118.27,144.78 118.27,144.76 118.28,144.76 118.28,144.69 118.28,144.69 118.28,144.3 118.02,144.04 118.02,143.67 118.15,143.54 118.15,143.4 118.02,143.26 117.87,143.26 UV1.AD30
  BOTTOM w0.112: v1(145.16,56.75) 144.85,56.44 144.45,56.44 CV307.1 ; v1(116.88,147.39) 117.24,147.75 117.62,147.75 117.89,147.48 117.89,145.62 118.27,145.24 118.27,144.78
PEG_HTX_GRX_P3: length 131.4
  IN3 w0.135: v1(118.75,146.54) 118.52,146.76 118.11,146.76 117.92,146.57 117.92,145.82 117.34,145.24 117.34,142.92 115.32,140.9 115.32,139.67 114.49,138.83 114.49,134.11 113.84,133.46 113.84,127.77 114.64,126.97 114.64,123.88 115.15,123.38 116.43,123.38 117.1,124.04 119.02,124.04 120.53,122.54 122.28,122.54 122.79,123.05 123.3,123.05 125.4,125.14 128.01,125.14 129.26,123.89 129.54,123.89 133.91,119.52 136.27,119.52 136.88,118.9 137.76,118.9 139.89,116.77 139.89,115.87 146.43,109.33 146.43,108.1 148.83,105.7 148.83,102.03 147.76,100.95 147.76,98.86 148.69,97.92 148.69,96.05 150.14,94.61 150.14,91.63 151.11,90.65 151.11,87.36 150.79,87.04 150.79,70.66 145.99,65.86 145.99,65.83 145.99,65.83 145.99,60.26 145.38,59.65 145.38,59.36 145.54,59.2 145.75,59.2 v1(145.98,59.43)
  BOTTOM w0.102: UV1.AC29 118.54,142.73 118.64,142.63 118.78,142.63 118.98,142.83 118.98,143.02 118.84,143.16 118.84,143.16 118.82,143.18 118.82,143.61 118.84,143.63 118.84,143.92 118.79,143.98 118.79,144.38 119.04,144.63 119.04,144.78
  BOTTOM w0.112: v1(145.98,59.43) 145.61,59.06 145.14,59.06 144.8,58.72 144.57,58.72 144.42,58.87 144.42,58.88 CV313.1 ; v1(118.75,146.54) 119.03,146.82 119.42,146.82 119.53,146.71 119.53,146.43 119.04,145.94 119.04,144.78
PEQ: length 11.6
  TOP w0.089: v1(43.77,116.26) 43.17,115.66 RT84.1 RT83.1
  TOP w0.102: v1(39.67,111.32) 39.94,111.06 UT5.8
  IN2 w0.102: v1(43.77,116.26) 43.77,114.48 40.61,111.32 v1(39.67,111.32)
  BOTTOM w0.089: v1(43.77,116.26) 44.32,116.81 v2(44.32,117.09)
PHASE_VCORE1: length 3.3
  TOP w0.089: v2(165.76,69.01) PCI09.2
  TOP w0.508: PCI09.2 165.76,70.41 165.25,70.92 v1(164.97,70.92)
  BOTTOM w0.254: v1(164.97,70.92) 165.02,70.87 PUI01.7
PHASE_VCORE2: length 3.1
  TOP w0.089: PCI29.2 v2(168.5,85.68)
  TOP w0.254: PCI29.2 168.02,84.51 v1(167.64,84.89)
  BOTTOM w0.254: v1(167.64,84.89) 167.26,84.52 PUI02.7
PL0: length 3.5
  TOP w0.102: RT79.1 44.44,111.41 v2(44.33,111.3) 44.2,111.18 44.2,109.7 43.88,109.37 UT5.60
PL1: length 5.3
  TOP w0.089: v2(45.03,114.31) 44.76,114.04 RT81.1 RT80.1 44.76,112.37 44.39,111.99 44.12,111.99 42.74,110.61 UT5.1
PLL_ANALOG_IN: length 2.4
  BOTTOM w0.102: UV1.AA1 120.18,122.56 120.18,120.84 119.97,120.64 119.96,120.64 TP68.1
PLL_ANALOG_OUT: length 6.1
  BOTTOM w0.089: RV83.1 120.17,119.31 119.26,118.4 v2(119.26,117.94)
  BOTTOM w0.102: UV1.AA3 120.14,123.17 120.47,122.84 120.47,119.66 RV83.1
PLT_RST_VGA#: length 139.1
  TOP w0.102: v1(52.64,92.18) 52.64,94.25 52.38,94.52 v3(52.38,102.42) 52.38,104.99 v1(53.25,105.86) ; v1(90.13,117.82) 90.61,117.34 107.44,117.34 108.67,118.58 v1(108.67,119.92) ; UE1.23 46.15,68.59 46.55,68.99 46.55,69.71 v1(45.72,70.54)
  IN2 w0.102: v1(90.13,117.82) 89.93,118.02 87.57,118.02 86.91,118.68 77.13,118.68 76.51,118.07 74.64,118.07 74.06,117.48 72.3,117.48 71.5,116.68 67.58,116.68 66.26,115.37 58.68,115.37 55.69,112.38 54.09,112.38 52.7,111 52.7,106.41 v1(53.25,105.86)
  IN3 w0.102: v1(52.64,92.18) 53.18,91.64 53.18,90.18 51.48,88.47 50.91,88.47 50.38,87.94 50.38,86.01 47.2,82.83 47.2,79.59 46.68,79.08 46.68,75.42 46.24,74.98 46.24,73.28 46.26,73.26 46.26,72.95 46.24,72.93 46.1,72.79 46.1,70.91 v1(45.72,70.54)
  BOTTOM w0.089: 107.77,123.48 107.77,122.15 107.77,122.14 107.77,120.82 v1(108.67,119.92)
  BOTTOM w0.102: 107.77,123.48 108.1,123.81 UV2.4 108.1,124.98 107.5,125.58 106.99,125.58 105.8,126.77 105.8,128.35 106.26,128.81 106.26,129.77 107.59,131.1 107.59,138.3 107.98,138.7 107.98,140.76 108.3,141.08 109.31,141.08 RV4.1 109.82,141.33 112.87,141.33 UV1.AL27
PLTRST#: length 531.4
  TOP w0.089: v1(217.99,55.41) 217.82,55.24 JWWAN.16 ; v1(70.87,119.74) 72.26,118.35 74.42,118.35 77.28,121.21 81.09,121.21 82.2,120.1 88.49,120.1 89.33,119.25 89.33,117.9 90.24,116.99 v3(95.26,116.99) 107.91,116.99 109.24,118.32 v1(109.24,120.48) ; v1(24.98,85.21) 24.98,84.98 24.91,84.92 ; v1(112.85,34.13) 112.85,33.97 113.48,33.33 113.48,32.33 111.9,30.74 111.44,30.74 110.75,30.06 110.75,29.6 110.45,29.29 107.44,29.29 v1(106.9,28.75) ; v1(37.69,97.39) 33.16,92.86 29.97,92.86 27.58,90.47 25.23,90.47 v1(24.79,90.03) ; v1(43.81,99.21) 44.08,99.21 RE65.1 44.78,99.91 45.84,99.91 46.73,100.8 46.73,102.09 47.76,103.12 49.04,103.12 49.78,102.38 51.29,102.38 51.89,102.98 v1(51.89,104.22)
  TOP w0.102: UL1.19 24.8,84.8 24.91,84.92
  TOP w0.112: RC108.2 106.21,43.42 107.5,44.71 v1(107.5,45.19) 107.43,45.12 106.28,45.12 RC109.1 105.95,45.44 105.28,45.44 105.16,45.32 UC4.4
  IN1 w0.102: v1(27.13,27.62) 24.79,25.28 23.38,25.28 23.07,25.59 21.13,25.59 18.55,28.17 18.55,31.06 19.71,32.22 19.71,41.18 20.85,42.32 20.85,43.59 22.39,45.13 22.39,52.83 24.95,55.39 24.95,75.45 24.28,76.11 24.28,78.52 25.84,80.08 25.84,83.94 24.98,84.81 v1(24.98,85.21) ; v1(43.81,99.21) 43.19,98.59 43.19,97.65 42.82,97.28 37.8,97.28 v1(37.69,97.39)
  IN2 w0.089: v1(24.98,85.21) 24.98,85.68 24.3,86.36 24.3,89.54 v1(24.79,90.03) ; v1(106.9,28.75) 107.48,28.17 112.35,28.17 113.5,29.32 116.37,29.32 117.28,30.23 133.45,30.23 136.24,33.03 142.97,33.03 144.6,31.4 145.5,31.4 148.35,28.55 155.3,28.55 155.91,29.17 166.05,29.17 166.22,29.34 168.53,29.34 168.8,29.06 172.53,29.06 172.94,28.65 173.85,28.65 174.69,28.65 175.24,29.21 177.54,29.21 178.25,29.92 179.06,29.92 181.01,31.86 184.71,31.86 185.66,30.91 213.59,30.91 215.79,33.12 215.79,37.89 217.66,39.76 217.66,43.8 217.25,44.2 217.25,54.67 v1(217.99,55.41)
  IN3 w0.089: v1(70.87,119.74) 70.75,119.86 69.67,119.86 69.13,119.32 68.43,119.32 67.41,120.33 66.25,120.33 66.02,120.56 65.42,120.56 65.26,120.4 64.63,120.4 63.28,119.05 56.25,119.05 v1(55.85,119.45)
  IN3 w0.102: v1(107.5,45.19) 107.3,45 106.35,45 105.48,44.13 105.48,41.09 103.63,39.24 99.62,39.24 99,39.86 97.69,39.86 97.6,39.77 95.75,39.77 95.53,39.55 93.37,39.55 92.81,40.11 89.12,40.11 88.34,39.33 82.81,39.33 81.86,38.39 81.85,38.39 81.49,38.03 78.85,38.03 74.81,38.03 74.72,37.94 71.66,37.94 70.61,39 68.78,39 68.07,39.71 61.32,39.71 60.3,40.72 59.88,40.72 57.69,42.91 56.78,42.91 56.15,43.54 56.15,45.21 54.5,46.86 54.5,48.14 53.8,48.84 53.8,51.38 52.67,52.51 52.67,56.21 51.81,57.07 51.81,58.04 50.88,58.98 50.88,61.01 50.39,61.49 50.39,62.81 50.91,63.33 50.91,67.93 50.41,68.44 49.81,68.44 49.35,68.9 49.35,70.59 48.93,71.01 48.57,71.01 48.47,71.12 48.47,71.27 48.37,71.37 48.09,71.37 47.99,71.27 47.99,71.12 47.89,71.01 47.32,71.01 47.17,71.16 47.17,72.34 47.43,72.6 47.43,74.25 50.77,77.6 50.77,77.61 51.34,78.17 51.34,85.59 54.14,88.39 54.14,91.77 53.23,92.67 53.23,93.08 53.67,93.52 53.67,102.45 v1(51.89,104.22)
  BOTTOM w0.089: JWLAN1.52 70.69,133.4 67.73,130.44 67.73,130.21 66.64,129.13 66.18,129.13 61.1,124.05 60.16,124.05 55.85,119.75 v1(55.85,119.45) 54.98,118.57 50.64,118.57 48.88,116.8 48.88,116.19 45.65,112.97 45.65,104.92 46.35,104.22 v1(51.89,104.22) ; UX1.17 113.06,32.97 113.22,33.13 113.22,33.35 112.85,33.71 v1(112.85,34.13) 112.85,34.64 112.61,34.88 111.29,34.88 108.4,37.77 108.4,41.35 108.12,41.63 108.12,44.67 107.6,45.19 v1(107.5,45.19)
  BOTTOM w0.102: JSSD1.50 v1(27.13,27.62) ; UV2.1 109.4,122.06 109.7,121.76 109.7,120.94 v1(109.24,120.48)
PME#: length 1.3
  TOP w0.089: v1(116.64,55.85) 116.57,55.92 TP12.1
  BOTTOM w0.076: v1(116.64,55.85) 117.03,56.25 UC1.AU11
POK: length 383.2
  TOP w0.089: v1(30.83,116.03) 30.61,115.81 RT6.2 ; v1(76.69,113.95) 76.69,113.2 77.16,112.73 DC2.1 ; v1(167.31,52.88) 167.71,53.28 v2(168.25,53.28)
  TOP w0.254: v1(18.35,45.22) 18.52,45.05 PR304.2 ; PR35.1 177.05,34.22 177.05,37.22 177.17,37.35 v1(177.17,39.05)
  IN1 w0.089: v1(76.69,113.95) 76.42,114.22 71.86,114.22 70.86,115.22 67.78,115.22 66.79,114.24 64.58,114.24 63.48,115.34 60.53,115.34 60.43,115.44 53.58,115.44 52.27,114.13 46.91,114.13 45.79,113.01 34.57,113.01 31.92,115.66 31.21,115.66 v1(30.83,116.03)
  IN1 w0.254: v1(177.17,39.05) 176.81,38.68 173.15,38.68 172.67,39.16 165.27,39.16 164.28,38.17 148.52,38.17 145.73,35.38 v1(145.73,34.34) ; v1(28.51,93.34) 27.19,93.34 27.01,93.16 27.01,91.59 25.78,90.36 25.78,89.71 25.26,89.2 24.51,89.2 23.95,88.63 23.95,87.71 22.04,85.8 22.04,82.65 21.37,81.97 20.62,81.97 20.35,81.7 20.35,79.01 21.84,77.52 21.84,76.08 24.49,73.42 24.49,64.29 22.35,62.15 22.35,57.16 22.13,56.94 22.13,56.93 19.96,54.75 19.96,53.69 19.26,52.99 19.26,51.58 18.55,50.87 18.55,46.15 18.54,46.14 18.54,46.08 18.35,45.89 v1(18.35,45.22)
  IN2 w0.102: v1(30.83,116.03) 30.41,116.03 28.8,114.42 28.8,113.14 29.49,112.44 29.49,110.91 29.04,110.46 23.3,110.46 23.11,110.27 23.11,107.99 21.93,106.82 16.25,106.82 15.3,105.86 15.3,99.77 15.46,99.6 15.46,97.82 15.85,97.44 20.75,97.44 22.23,95.96 22.23,93.23 22.64,92.82 25.42,92.82 25.94,93.34 v1(28.51,93.34)
  IN2 w0.254: v1(176.17,48.03) 176.74,47.46 178.74,47.46 179.33,46.86 179.33,41.21 v1(177.17,39.05) ; v1(145.73,34.34) 144.36,34.34 143.57,35.13 134.62,35.13 133.54,34.04 130.2,34.04 129.59,33.44 117.29,33.44 115.19,31.34 112.43,31.34 111.86,30.76 108.43,30.76 108.19,31.01 103.9,31.01 102.52,29.62 101.7,29.62 v1(101.2,30.12) 100.32,31.01 97.81,31.01 96.86,30.06 92.97,30.06 91.73,28.82 78.98,28.82 78.26,29.55 77.27,29.55 77.06,29.76 76.26,29.76 76.13,29.88 70.71,29.88 70.33,30.26 67.6,30.26 66.74,29.39 63.6,29.39 v1(63.32,29.68)
  IN3 w0.254: v1(18.35,45.22) 18.64,45.22 23.08,40.78 31.96,40.78 32.63,40.1 34.65,40.1 35.85,41.3 39.15,41.3 41.06,39.4 41.06,36.62 40.7,36.27 40.7,34.86 41.07,34.49 51.01,34.49 51.52,33.98 53.74,33.98 55.17,32.55 55.84,32.55 56.75,31.64 57.18,31.64 59.15,29.68 v1(63.32,29.68) ; v1(167.31,52.88) 167.31,52.57 168.36,51.52 168.36,49.36 167.62,48.62 v1(167.62,48.07) 168.02,47.67 169.78,47.67 170.62,48.51 171.76,48.51 172.25,48.03 v1(176.17,48.03)
  BOTTOM w0.203: PU501.9 27.63,96.72 27.97,96.37 27.97,94.2 27.66,93.89 PR504.2
  BOTTOM w0.254: v1(18.35,45.22) 17.66,44.54 17.66,43.77 17.95,43.49 PU301.9 ; PR504.2 27.79,93.34 v1(28.51,93.34) ; PRH01.1 166.1,53.16 167.03,53.16 v1(167.31,52.88) ; PR1801.1 165.96,47.93 167.48,47.93 v1(167.62,48.07)
POWER_SW#_MB: length 266.7
  TOP w0.102: v1(222.09,64.96) 223.58,64.96 TPS9.1
  IN2 w0.089: v1(42.67,65.18) 43.54,64.31 43.54,62.02 45.75,59.8 45.75,54.53 45.39,54.16 44.66,53.43 44.66,45.05 44.83,44.88 44.83,43.69 45.91,42.6 45.91,41.32 52.08,35.16 55.46,35.16 57.48,33.14 57.82,33.14 62.77,28.19 75.89,28.19 76.63,27.46 93.67,27.46 94.18,27.97 104.1,27.97 105.61,29.49 107.2,29.49 107.98,28.72 112.12,28.72 113.27,29.87 116.1,29.87 117.01,30.78 133.22,30.78 136.01,33.58 143.2,33.58 144.82,31.95 145.73,31.95 148.52,29.16 155.13,29.16 155.69,29.72 155.84,29.72 165.8,29.72 166.02,29.95 168.79,29.95 169.13,29.61 172.76,29.61 173.16,29.2 173.62,29.2 174.45,29.2 175,29.76 177.26,29.76 177.97,30.47 178.83,30.47 180.78,32.41 187.51,32.41 188.19,31.73 192.47,31.73 193.32,32.58 195.66,32.58 196.74,31.49 210.33,31.49 211.4,32.56 214.72,32.56 215.42,33.27 215.42,39.25 215.78,39.61 215.78,44.51 215.08,45.21 215.08,56.74 214.34,57.48 214.34,59.24 215.92,60.82 216.56,60.82 217.54,61.81 219.67,61.81 222.09,64.23 v1(222.09,64.96)
  IN3 w0.089: v1(42.67,65.18) 42.67,65 41.23,63.57 37.95,63.57 37.26,62.87 32.37,62.87 v1(31.09,61.59)
  BOTTOM w0.089: JPWR2.4 222.2,64.85 v1(222.09,64.96)
  BOTTOM w0.508: SW1.1 29.82,63.36 31.09,62.1 v1(31.09,61.59)
